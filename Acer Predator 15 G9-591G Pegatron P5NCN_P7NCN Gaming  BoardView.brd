# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Nets (continued)
HDMI_OUT_DATA1_N: CON4800.6 L4801.3 RN4801.1
HDMI_OUT_DATA1_P: CON4800.4 L4801.4 RN4801.3
HDMI_OUT_DATA2_N: CON4800.3 L4802.3 RN4802.1
HDMI_OUT_DATA2_P: CON4800.1 L4802.4 RN4802.3
HDMI_OUT_DDC_CLK: C4809.1 CON4800.15 Q4803.3 R4807.2
HDMI_OUT_DDC_DATA: C4810.1 CON4800.16 Q4802.3 R4806.2
HDMI_PD#: Q1302.3 R1314.2 U1301.26
HDMI_REQ: R1308.2 R1309.1 U1301.4
HDMI_REXT: R1301.1 U1301.7
HDMI_SE_STBY_OFF_CK: Q4805.3 R4808.2 R4809.2 R4810.2 R4811.2 R4812.2 R4813.2 R4814.2 R4815.2
HDMI_TMDSD_AUXN: C1190.1 R1316.2 U1301.27
HDMI_TMDSD_AUXP: C1189.1 R1315.1 R1320.2 U1301.28
HDMI_TMDSD_CLK#_C: C4808.2 L4803.2 R4813.1 RN4803.2
HDMI_TMDSD_CLK_C: C4807.2 L4803.1 R4814.1 RN4803.4
HDMI_TMDSD_DATA0#_C: C4805.2 L4802.2 R4812.1 RN4802.2
HDMI_TMDSD_DATA0_C: C4804.2 L4802.1 R4809.1 RN4802.4
HDMI_TMDSD_DATA1#_C: C4803.2 L4801.2 R4815.1 RN4801.2
HDMI_TMDSD_DATA1_C: C4802.2 L4801.1 R4808.1 RN4801.4
HDMI_TMDSD_DATA2#_C: C4801.2 L4800.2 R4810.1 RN4800.2
HDMI_TMDSD_DATA2_C: C4800.2 L4800.1 R4811.1 RN4800.4
HDMID_DDI2_AUXN: C1316.1 R0306.2 U0300.E26
HDMID_DDI2_AUXN_C: C1316.2 U1301.29
HDMID_DDI2_AUXP: C1315.1 R0307.1 U0300.F26
HDMID_DDI2_AUXP_C: C1315.2 U1301.30
HDMID_DDI2_DATA0: C1309.1 U0300.H34
HDMID_DDI2_DATA0#: C1305.1 U0300.H33
HDMID_DDI2_DATA0#_C: C1305.2 U1301.39
HDMID_DDI2_DATA0_C: C1309.2 U1301.38
HDMID_DDI2_DATA1: C1314.1 U0300.F37
HDMID_DDI2_DATA1#: C1307.1 U0300.G38
HDMID_DDI2_DATA1#_C: C1307.2 U1301.42
HDMID_DDI2_DATA1_C: C1314.2 U1301.41
HDMID_DDI2_DATA2: C1313.1 U0300.F34
HDMID_DDI2_DATA2#: C1306.1 U0300.F35
HDMID_DDI2_DATA2#_C: C1306.2 U1301.45
HDMID_DDI2_DATA2_C: C1313.2 U1301.44
HDMID_DDI2_DATA3: C1308.1 U0300.E37
HDMID_DDI2_DATA3#: C1310.1 U0300.E36
HDMID_DDI2_DATA3#_C: C1310.2 U1301.48
HDMID_DDI2_DATA3_C: C1308.2 U1301.47
HDMID_TMDSD_DATA0: C1119.1 U1301.23
HDMID_TMDSD_DATA0#: C1120.1 U1301.22
HDMID_TMDSD_DATA1: C1121.1 U1301.20
HDMID_TMDSD_DATA1#: C1122.1 U1301.19
HDMID_TMDSD_DATA2: C1123.1 U1301.17
HDMID_TMDSD_DATA2#: C1124.1 U1301.16
HDMID_TMDSD_DATA3: C1125.1 U1301.14
HDMID_TMDSD_DATA3#: C1126.1 U1301.13
HG_C: Q8002.4 U8005.1
HOOK3_SPI_MOSI_VRM_PWRGD: C4403.1 R4411.2 R4414.1 R4417.1 XDP4400.47
HOOK6_ITP_PMODE_PLTRST_CPU#: R4410.2 R4413.1 R4418.1 R4423.1 XDP4400.46
HPD_DDPB_DP1_Q: R2149.1 U2000.AW4
HPD_DDPC_HDMI: R2152.2 R2163.1 U1301.9 U2000.AY2
HPD_DDPC_HDMI_R: R1119.1 U1101.AA2 U1301.11
HPD_DDPD_DP: R2127.1 U1401.9 U2000.AV4
HPD_DDPD_DP_R: R1142.1 U1101.Y6 U1401.11
HPD_IFPC_DP2: R2377.1 R7435.2 R7449.2 U4601.9
HPD_IFPC_DP2_PCH: R2372.2 R2377.2 U2000.AU41
HPOUT1_JD#: CON6700.17 Q6701.1 R3623.2
HPOUT1_JD_EC: Q6701.3 R3005.2 U3001.126
HPOUT1_L: C6704.1 CON6700.18 U3600.32
HPOUT1_R: C6705.1 CON6700.19 U3600.33
I2C_IRQ2Z: R1230.1 R3077.2 U1201.B6
I2C_SCL2: Q1202.3 R1231.1 U1201.B5
I2C_SDA2: Q1201.3 R1232.1 U1201.A5
IFPABCDEF_IOVDD: C7219.1 C7220.1 C7221.1 C7227.1 L7204.2 U7000.BA11 U7000.BA12
IFPABCDEF_PLLVDD: C7222.1 C7223.1 C7224.1 C7225.1 C7226.1 L7203.2 U7000.BB12
IFPC_RSET: R7212.2 U7000.BB14
ILIM_SEL: R5206.1 R5207.2 U5200.4
IMON_A: C8035.2 R8092.2 U8000.14
IMON_B: C8014.2 R8029.2 U8000.2
IMON_C: C8004.1 R8038.1 U8000.28
IN+1: C8745.2 R8731.2 U8702.12
IN+2: C8748.1 R8734.2 U8702.15
IN-1: C8745.1 R8732.2 U8702.11
IN-2: C8748.2 R8735.2 U8702.1 U8702.14
INT_SERIRQ: R2224.1 R3013.2 U3001.5 U6200.27
ISEN1_A: C8017.2 R8006.2 R80125.1 U8000.21
ISEN1_B: C8029.1 R80103.2 R80140.1 U8000.9
ISEN2_A: C8019.2 R8007.2 R80130.1 U8000.22
ISEN2_B: C8030.1 R8091.2 R80145.1 U8000.10
ISEN3_A: C8011.2 R8034.2 R80135.1 U8000.23
ISH_I2C0_SCL: R2417.2 U2000.BC38
ISH_I2C0_SDA: R2416.2 U2000.BB38
ISH_I2C1_SCL: R2415.2 U2000.BD38
ISH_I2C1_SDA: R2414.2 U2000.BE39
ISUMN_A: C8018.1 R8008.2 R8098.1 U8000.20
ISUMN_A_R: C8011.1 C8017.1 C8019.1 C8020.2 C8026.1 R8057.1 R8059.1 R8061.1 R8082.1 R8083.1 R8097.1 R8098.2 R80102.2
ISUMN_B: C8034.1 R8045.2 R8076.1 U8000.8
ISUMN_B_R: C8027.2 C8028.1 C8029.2 C8030.2 R8040.2 R8043.1 R8044.2 R8045.1 R8064.1 R8066.1 R8088.2
ISUMN_C: C80106.1 R8032.2 R8035.1 U8000.33
ISUMN_C_R: C80104.2 C80105.1 R8025.1 R8026.1 R8035.2 R8036.2 R8069.1 R80124.1
ISUMP_A: C8026.2 C80109.2 C80133.2 R8056.1 R8058.1 R8060.1 R8083.2 R80101.2 U8000.19
ISUMP_B: C8027.1 C8036.1 C80110.1 R8044.1 R8062.1 R8063.1 R8094.1 U8000.7
ISUMP_C: C80103.2 C80105.2 C80111.2 R8024.2 R8025.2 R8067.1 U8000.32
ITP_PMODE: R4413.2 U2000.AT2
JD_PCH: R2499.2 U3600.48
JTAG_TCLK: T7406.1 U7000.BJ20
JTAG_TDI: T7408.1 U7000.BG20
JTAG_TDO: T7409.1 U7000.BH20
JTAG_TMS: T7407.1 U7000.BF20
JTAG_TRST#: R7425.2 T7410.1 U7000.BF21
KBL_A_0: R3141.2 R3142.1 U3102.2
KBL_A_1: R3143.2 R3144.1 U3102.3
KBL_A_2: R3145.2 R3146.1 U3102.4
KBL_A_3: R3147.2 R3148.1 U3102.5
KBL_B_2: CON3110.8 U3102.13
KBL_B_3: CON3110.11 U3102.22
KBL_B_4: CON3110.14 U3102.17
KBL_G_2: CON3110.7 U3102.12
KBL_G_3: CON3110.10 U3102.21
KBL_G_4: CON3110.13 U3102.16
KBL_R_3: CON3110.9 U3102.20
KBL_R_4: CON3110.12 U3102.15
KBL_RESET#_R: R3137.1 U3102.25
KSI0: CN5.1 CON3100.8 U3001.58
KSI1: CN5.3 CON3100.7 U3001.59
KSI2: CN5.5 CON3100.6 U3001.60
KSI3: CN5.7 CON3100.5 U3001.61
KSI4: CN6.1 CON3100.4 U3001.62
KSI5: CN6.3 CON3100.3 U3001.63
KSI6: CN6.5 CON3100.2 U3001.64
KSI7: CN6.7 CON3100.1 U3001.65
KSO0: CN1.1 CON3100.26 U3001.36
KSO1: CN1.3 CON3100.25 U3001.37
KSO2: CN1.5 CON3100.24 U3001.38
KSO3: CN1.7 CON3100.23 U3001.39
KSO4: CN2.1 CON3100.22 U3001.40
KSO5: CN2.3 CON3100.21 U3001.41
KSO6: CN2.5 CON3100.20 U3001.42
KSO7: CN2.7 CON3100.19 U3001.43
KSO8: CN3.1 CON3100.18 U3001.44
KSO9: CN3.3 CON3100.17 U3001.45
KSO10: CN3.5 CON3100.16 U3001.46
KSO11: CN3.7 CON3100.15 U3001.51
KSO12: CN4.1 CON3100.14 U3001.52
KSO13: CN4.3 CON3100.13 U3001.53
KSO14: CN4.5 CON3100.12 U3001.54
KSO15: CN4.7 CON3100.11 U3001.55
KSO16: CN7.1 CON3100.10 U3001.56
KSO17: CN7.3 CON3100.9 U3001.57
L1+: CON5500.3 D5502.1 L5501.2 RN5501.4
L1-: CON5500.2 D5501.1 L5501.3 RN5501.2
L2+: CON5501.3 D5504.1 L5504.2 RN5504.4
L2-: CON5501.2 D5503.1 L5504.3 RN5504.2
LAD0_ESPI_IO0: R2219.2 U2000.AT22
LAD0_ESPI_IO1: R2220.2 U2000.AV22
LAD0_ESPI_IO2: R2221.2 U2000.AT19
LAD0_ESPI_IO3: R2222.2 U2000.BD16
LAN_CLKREQ#: R2432.2 R3304.2 U2000.BB31
LAN_GND: C3401.2 C3402.2 C3403.2 C3404.2 CON3400.9 CON3400.10 D3400.2 R3404.2
LAN_MDI0_N: U3300.12 U3401.3
LAN_MDI0_N_C: CON3400.2 L3403.3 RN3403.2
LAN_MDI0_N_L: L3403.4 RN3403.1 U3401.22
LAN_MDI0_P: U3300.11 U3401.2
LAN_MDI0_P_C: CON3400.1 L3403.2 RN3403.4
LAN_MDI0_P_L: L3403.1 RN3403.3 U3401.23
LAN_MDI1_N: U3300.15 U3401.6
LAN_MDI1_N_C: CON3400.6 L3402.3 RN3402.2
LAN_MDI1_N_L: L3402.4 RN3402.1 U3401.19
LAN_MDI1_P: U3300.14 U3401.5
LAN_MDI1_P_C: CON3400.3 L3402.2 RN3402.4
LAN_MDI1_P_L: L3402.1 RN3402.3 U3401.20
LAN_MDI2_N: U3300.18 U3401.9
LAN_MDI2_N_C: CON3400.5 L3401.3 RN3401.2
LAN_MDI2_N_L: L3401.4 RN3401.1 U3401.16
LAN_MDI2_P: U3300.17 U3401.8
LAN_MDI2_P_C: CON3400.4 L3401.2 RN3401.4
LAN_MDI2_P_L: L3401.1 RN3401.3 U3401.17
LAN_MDI3_N: U3300.21 U3401.12
LAN_MDI3_N_C: CON3400.8 L3400.3 RN3400.2
LAN_MDI3_N_L: L3400.4 RN3400.1 U3401.13
LAN_MDI3_P: U3300.20 U3401.11
LAN_MDI3_P_C: CON3400.7 L3400.2 RN3400.4
LAN_MDI3_P_L: L3400.1 RN3400.3 U3401.14
LAN_RXN: C3314.2 U2000.E20
LAN_RXN_C: C3314.1 U3300.29
LAN_RXP: C3313.2 U2000.G19
LAN_RXP_C: C3313.1 U3300.30
LAN_TXN: C2013.1 U3300.36
LAN_TXP: C2012.1 U3300.35
LAN_WAKE#: R2443.2 R2446.2 R3303.2 U2000.BC13
LCD_BKLTEN_EC: D4503.2 R4593.2 U3001.118
LED2_1PIN: PLED702.1 PR703.1
LED_1PIN: PLED701.1 PR701.1
LED_2PIN: PLED701.2 PLED702.2 PQ700.3
LFRAME#_ESPI_CS0#: R2223.2 U2000.BE16
LG_C: Q8001.4 U8005.5
LGF_LED_ON: Q4501.1 R3084.2
LGF_LED_ON#: CON4500.36 Q4501.3
LID_SW#: CON5602.25 D4502.2 R4592.2 U3001.17
LID_SW#_IO: CON402.25 PD702.1 PR702.1 PU701.2
LINE1_JD#: CON6700.22 R3624.2
LINE1_L: C3639.2 L6701.1 R6737.2
LINE1_R: C3640.2 L6700.1 R6738.2
LINE1_VREFO_L: R6737.1 U3600.31
LINE1_VREFO_R: R6738.1 U3600.30
LP9+: CON4500.32 L4500.3 RN4500.2 U4501.3
LP9-: CON4500.33 L4500.2 RN4500.4 U4501.4
LPC_AD0: CON4400.11 R2219.1 R3016.1 U6200.26
LPC_AD1: CON4400.9 R2220.1 R3015.1 U6200.23
LPC_AD2: CON4400.7 R2221.1 R3014.1 U6200.20
LPC_AD3: CON4400.5 R2222.1 R3020.1 U6200.17
LPC_FRAME#: CON4400.3 R2223.1 R3018.1 U6200.22
LPCPD#: R2226.1 U6200.28
M2_SSD_PEDET: CON5102.69 R2105.2 R2110.1 R5115.2 U2000.AG36
M_CHA_ACT#: CON1600.114 CON1601.114 U0300.AU3
M_CHA_ALERT#: CON1600.116 CON1601.116 U0300.AU5
M_CHA_BA0: CON1600.150 CON1601.150 U0300.AH5
M_CHA_BA1: CON1600.145 CON1601.145 U0300.AH1
M_CHA_BG0: CON1600.115 CON1601.115 U0300.AU1
M_CHA_BG1: CON1600.113 CON1601.113 U0300.AU2
M_CHA_CKE0: CON1600.109 U0300.AT1
M_CHA_CKE1: CON1600.110 U0300.AT2
M_CHA_CKE2: CON1601.109 U0300.AT3
M_CHA_CKE3: CON1601.110 U0300.AT5
M_CHA_CLK0: CON1600.137 U0300.AG1
M_CHA_CLK0#: CON1600.139 U0300.AG2
M_CHA_CLK1: CON1600.138 U0300.AK2
M_CHA_CLK1#: CON1600.140 U0300.AK1
M_CHA_CLK2: CON1601.137 U0300.AL3
M_CHA_CLK2#: CON1601.139 U0300.AK3
M_CHA_CLK3: CON1601.138 U0300.AL2
M_CHA_CLK3#: CON1601.140 U0300.AL1
M_CHA_CS#0: CON1600.149 U0300.AD5
M_CHA_CS#1: CON1600.157 U0300.AE2
M_CHA_CS#2: CON1601.149 U0300.AD2
M_CHA_CS#3: CON1601.157 U0300.AE5
M_CHA_DQ0: CON1600.8 CON1601.7 U0300.BR6
M_CHA_DQ1: CON1600.7 CON1601.8 U0300.BT6
M_CHA_DQ2: CON1600.17 CON1601.16 U0300.BP3
M_CHA_DQ3: CON1600.20 CON1601.21 U0300.BR3
M_CHA_DQ4: CON1600.3 CON1601.4 U0300.BN5
M_CHA_DQ5: CON1600.4 CON1601.3 U0300.BP6
M_CHA_DQ6: CON1600.21 CON1601.20 U0300.BP2
M_CHA_DQ7: CON1600.16 CON1601.17 U0300.BN3
M_CHA_DQ8: CON1600.24 CON1601.25 U0300.BL4
M_CHA_DQ9: CON1600.28 CON1601.29 U0300.BL5
M_CHA_DQ10: CON1600.37 CON1601.38 U0300.BL2
M_CHA_DQ11: CON1600.41 CON1601.42 U0300.BM1
M_CHA_DQ12: CON1600.29 CON1601.28 U0300.BK4
M_CHA_DQ13: CON1600.25 CON1601.24 U0300.BK5
M_CHA_DQ14: CON1600.42 CON1601.41 U0300.BK1
M_CHA_DQ15: CON1600.38 CON1601.37 U0300.BK2
M_CHA_DQ16: CON1600.45 CON1601.46 U0300.BG4
M_CHA_DQ17: CON1600.49 CON1601.50 U0300.BG5
M_CHA_DQ18: CON1600.50 CON1601.49 U0300.BF4
M_CHA_DQ19: CON1600.46 CON1601.45 U0300.BF5
M_CHA_DQ20: CON1600.58 CON1601.59 U0300.BG2
M_CHA_DQ21: CON1600.62 CON1601.63 U0300.BG1
M_CHA_DQ22: CON1600.59 CON1601.58 U0300.BF1
M_CHA_DQ23: CON1600.63 CON1601.62 U0300.BF2
M_CHA_DQ24: CON1600.67 CON1601.66 U0300.BD2
M_CHA_DQ25: CON1600.71 CON1601.70 U0300.BD1
M_CHA_DQ26: CON1600.84 CON1601.83 U0300.BC4
M_CHA_DQ27: CON1600.80 CON1601.79 U0300.BC5
M_CHA_DQ28: CON1600.66 CON1601.67 U0300.BD5
M_CHA_DQ29: CON1600.70 CON1601.71 U0300.BD4
M_CHA_DQ30: CON1600.79 CON1601.80 U0300.BC1
M_CHA_DQ31: CON1600.83 CON1601.84 U0300.BC2
M_CHA_DQ32: CON1600.187 CON1601.182 U0300.AB1
M_CHA_DQ33: CON1600.183 CON1601.186 U0300.AB2
M_CHA_DQ34: CON1600.169 CON1601.174 U0300.AA4
M_CHA_DQ35: CON1600.173 CON1601.170 U0300.AA5
M_CHA_DQ36: CON1600.174 CON1601.169 U0300.AB5
M_CHA_DQ37: CON1600.170 CON1601.173 U0300.AB4
M_CHA_DQ38: CON1600.182 CON1601.187 U0300.AA2
M_CHA_DQ39: CON1600.186 CON1601.183 U0300.AA1
M_CHA_DQ40: CON1600.190 CON1601.195 U0300.V5
M_CHA_DQ41: CON1600.208 CON1601.207 U0300.V2
M_CHA_DQ42: CON1600.191 CON1601.194 U0300.U1
M_CHA_DQ43: CON1600.207 CON1601.208 U0300.U2
M_CHA_DQ44: CON1600.204 CON1601.203 U0300.V1
M_CHA_DQ45: CON1600.194 CON1601.191 U0300.V4
M_CHA_DQ46: CON1600.195 CON1601.190 U0300.U5
M_CHA_DQ47: CON1600.203 CON1601.204 U0300.U4
M_CHA_DQ48: CON1600.228 CON1601.229 U0300.R2
M_CHA_DQ49: CON1600.216 CON1601.215 U0300.P5
M_CHA_DQ50: CON1600.212 CON1601.211 U0300.R4
M_CHA_DQ51: CON1600.215 CON1601.216 U0300.P4
M_CHA_DQ52: CON1600.225 CON1601.228 U0300.R5
M_CHA_DQ53: CON1600.229 CON1601.224 U0300.P2
M_CHA_DQ54: CON1600.211 CON1601.212 U0300.R1
M_CHA_DQ55: CON1600.224 CON1601.225 U0300.P1
M_CHA_DQ56: CON1600.232 CON1601.233 U0300.M4
M_CHA_DQ57: CON1600.233 CON1601.236 U0300.M1
M_CHA_DQ58: CON1600.249 CON1601.246 U0300.L4
M_CHA_DQ59: CON1600.250 CON1601.249 U0300.L2
M_CHA_DQ60: CON1600.236 CON1601.237 U0300.M5
M_CHA_DQ61: CON1600.237 CON1601.232 U0300.M2
M_CHA_DQ62: CON1600.245 CON1601.250 U0300.L5
M_CHA_DQ63: CON1600.246 CON1601.245 U0300.L1
M_CHA_DQS0: CON1600.13 CON1601.13 U0300.BP5
M_CHA_DQS0#: CON1600.11 CON1601.11 U0300.BR5
M_CHA_DQS1: CON1600.34 CON1601.34 U0300.BK3
M_CHA_DQS1#: CON1600.32 CON1601.32 U0300.BL3
M_CHA_DQS2: CON1600.55 CON1601.55 U0300.BF3
M_CHA_DQS2#: CON1600.53 CON1601.53 U0300.BG3
M_CHA_DQS3: CON1600.76 CON1601.76 U0300.BC3
M_CHA_DQS3#: CON1600.74 CON1601.74 U0300.BD3
M_CHA_DQS4: CON1600.179 CON1601.179 U0300.AB3
M_CHA_DQS4#: CON1600.177 CON1601.177 U0300.AA3
M_CHA_DQS5: CON1600.200 CON1601.200 U0300.V3
M_CHA_DQS5#: CON1600.198 CON1601.198 U0300.U3
M_CHA_DQS6: CON1600.221 CON1601.221 U0300.R3
M_CHA_DQS6#: CON1600.219 CON1601.219 U0300.P3
M_CHA_DQS7: CON1600.242 CON1601.242 U0300.M3
M_CHA_DQS7#: CON1600.240 CON1601.240 U0300.L3
M_CHA_MAA0: CON1600.144 CON1601.144 U0300.AH3
M_CHA_MAA1: CON1600.133 CON1601.133 U0300.AP4
M_CHA_MAA2: CON1600.132 CON1601.132 U0300.AN4
M_CHA_MAA3: CON1600.131 CON1601.131 U0300.AP5
M_CHA_MAA4: CON1600.128 CON1601.128 U0300.AP2
M_CHA_MAA5: CON1600.126 CON1601.126 U0300.AP1
M_CHA_MAA6: CON1600.127 CON1601.127 U0300.AP3
M_CHA_MAA7: CON1600.122 CON1601.122 U0300.AN1
M_CHA_MAA8: CON1600.125 CON1601.125 U0300.AN3
M_CHA_MAA9: CON1600.121 CON1601.121 U0300.AT4
M_CHA_MAA10: CON1600.146 CON1601.146 U0300.AH2
M_CHA_MAA11: CON1600.120 CON1601.120 U0300.AN2
M_CHA_MAA12: CON1600.119 CON1601.119 U0300.AU4
M_CHA_MAA13: CON1600.158 CON1601.158 U0300.AE3
M_CHA_MAA14: CON1600.151 CON1601.151 U0300.AG4
M_CHA_MAA15: CON1600.156 CON1601.156 U0300.AD1
M_CHA_MAA16: CON1600.152 CON1601.152 U0300.AH4
M_CHA_ODT0: CON1600.155 U0300.AD3
M_CHA_ODT1: CON1600.161 U0300.AE4
M_CHA_ODT2: CON1601.155 U0300.AE1
M_CHA_ODT3: CON1601.161 U0300.AD4
M_CHA_PAR: CON1600.143 CON1601.143 U0300.AG3
M_CHB_ACT#: CON1700.114 CON1701.114 U0300.AT9
M_CHB_ALERT#: CON1700.116 CON1701.116 U0300.AR8
M_CHB_BA0: CON1700.150 CON1701.150 U0300.AH8
M_CHB_BA1: CON1700.145 CON1701.145 U0300.AH9
M_CHB_BG0: CON1700.115 CON1701.115 U0300.AR9
M_CHB_BG1: CON1700.113 CON1701.113 U0300.AR7
M_CHB_CKE0: CON1700.109 U0300.AT8
M_CHB_CKE1: CON1700.110 U0300.AT10
M_CHB_CKE2: CON1701.109 U0300.AT7
M_CHB_CKE3: CON1701.110 U0300.AT11
M_CHB_CLK0: CON1700.137 U0300.AM9
M_CHB_CLK0#: CON1700.139 U0300.AN9
M_CHB_CLK1: CON1700.138 U0300.AM7
M_CHB_CLK1#: CON1700.140 U0300.AM8
M_CHB_CLK2: CON1701.137 U0300.AM11
M_CHB_CLK2#: CON1701.139 U0300.AM10
M_CHB_CLK3: CON1701.138 U0300.AJ10
M_CHB_CLK3#: CON1701.140 U0300.AJ11
M_CHB_CS#0: CON1700.149 U0300.AF11
M_CHB_CS#1: CON1700.157 U0300.AE7
M_CHB_CS#2: CON1701.149 U0300.AF10
M_CHB_CS#3: CON1701.157 U0300.AE10
M_CHB_DQ0: CON1700.3 CON1701.8 U0300.BT11
M_CHB_DQ1: CON1700.7 CON1701.4 U0300.BR11
M_CHB_DQ2: CON1700.21 CON1701.16 U0300.BT8
M_CHB_DQ3: CON1700.17 CON1701.20 U0300.BR8
M_CHB_DQ4: CON1700.4 CON1701.7 U0300.BP11
M_CHB_DQ5: CON1700.8 CON1701.3 U0300.BN11
M_CHB_DQ6: CON1700.16 CON1701.21 U0300.BP8
M_CHB_DQ7: CON1700.20 CON1701.17 U0300.BN8
M_CHB_DQ8: CON1700.28 CON1701.25 U0300.BL12
M_CHB_DQ9: CON1700.24 CON1701.29 U0300.BL11
M_CHB_DQ10: CON1700.29 CON1701.24 U0300.BL8
M_CHB_DQ11: CON1700.41 CON1701.38 U0300.BJ8
M_CHB_DQ12: CON1700.42 CON1701.41 U0300.BJ11
M_CHB_DQ13: CON1700.38 CON1701.37 U0300.BJ10
M_CHB_DQ14: CON1700.25 CON1701.28 U0300.BL7
M_CHB_DQ15: CON1700.37 CON1701.42 U0300.BJ7
M_CHB_DQ16: CON1700.50 CON1701.45 U0300.BG11
M_CHB_DQ17: CON1700.46 CON1701.49 U0300.BG10
M_CHB_DQ18: CON1700.49 CON1701.46 U0300.BG8
M_CHB_DQ19: CON1700.63 CON1701.62 U0300.BF8
M_CHB_DQ20: CON1700.58 CON1701.63 U0300.BF11
M_CHB_DQ21: CON1700.62 CON1701.59 U0300.BF10
M_CHB_DQ22: CON1700.45 CON1701.50 U0300.BG7
M_CHB_DQ23: CON1700.59 CON1701.58 U0300.BF7
M_CHB_DQ24: CON1700.79 CON1701.84 U0300.BB11
M_CHB_DQ25: CON1700.70 CON1701.71 U0300.BC11
M_CHB_DQ26: CON1700.84 CON1701.79 U0300.BB8
M_CHB_DQ27: CON1700.71 CON1701.66 U0300.BC8
M_CHB_DQ28: CON1700.66 CON1701.67 U0300.BC10
M_CHB_DQ29: CON1700.83 CON1701.80 U0300.BB10
M_CHB_DQ30: CON1700.67 CON1701.70 U0300.BC7
M_CHB_DQ31: CON1700.80 CON1701.83 U0300.BB7
M_CHB_DQ32: CON1700.183 CON1701.186 U0300.AA11
M_CHB_DQ33: CON1700.187 CON1701.182 U0300.AA10
M_CHB_DQ34: CON1700.173 CON1701.170 U0300.AC11
M_CHB_DQ35: CON1700.169 CON1701.174 U0300.AC10
M_CHB_DQ36: CON1700.182 CON1701.187 U0300.AA7
M_CHB_DQ37: CON1700.186 CON1701.183 U0300.AA8
M_CHB_DQ38: CON1700.170 CON1701.169 U0300.AC8
M_CHB_DQ39: CON1700.174 CON1701.173 U0300.AC7
M_CHB_DQ40: CON1700.195 CON1701.190 U0300.W8
M_CHB_DQ41: CON1700.191 CON1701.194 U0300.W7
M_CHB_DQ42: CON1700.207 CON1701.204 U0300.V10
M_CHB_DQ43: CON1700.203 CON1701.208 U0300.V11
M_CHB_DQ44: CON1700.194 CON1701.191 U0300.W11
M_CHB_DQ45: CON1700.190 CON1701.195 U0300.W10
M_CHB_DQ46: CON1700.204 CON1701.207 U0300.V7
M_CHB_DQ47: CON1700.208 CON1701.203 U0300.V8
M_CHB_DQ48: CON1700.212 CON1701.215 U0300.R11
M_CHB_DQ49: CON1700.225 CON1701.228 U0300.P11
M_CHB_DQ50: CON1700.224 CON1701.229 U0300.P7
M_CHB_DQ51: CON1700.215 CON1701.212 U0300.R8
M_CHB_DQ52: CON1700.216 CON1701.211 U0300.R10
M_CHB_DQ53: CON1700.229 CON1701.224 U0300.P10
M_CHB_DQ54: CON1700.211 CON1701.216 U0300.R7
M_CHB_DQ55: CON1700.228 CON1701.225 U0300.P8
M_CHB_DQ56: CON1700.245 CON1701.250 U0300.L11
M_CHB_DQ57: CON1700.232 CON1701.237 U0300.M11
M_CHB_DQ58: CON1700.246 CON1701.249 U0300.L7
M_CHB_DQ59: CON1700.237 CON1701.232 U0300.M8
M_CHB_DQ60: CON1700.249 CON1701.246 U0300.L10
M_CHB_DQ61: CON1700.236 CON1701.233 U0300.M10
M_CHB_DQ62: CON1700.233 CON1701.236 U0300.M7
M_CHB_DQ63: CON1700.250 CON1701.245 U0300.L8
M_CHB_DQS0: CON1700.13 CON1701.13 U0300.BR9
M_CHB_DQS0#: CON1700.11 CON1701.11 U0300.BP9
M_CHB_DQS1: CON1700.34 CON1701.34 U0300.BJ9
M_CHB_DQS1#: CON1700.32 CON1701.32 U0300.BL9
M_CHB_DQS2: CON1700.55 CON1701.55 U0300.BF9
M_CHB_DQS2#: CON1700.53 CON1701.53 U0300.BG9
M_CHB_DQS3: CON1700.76 CON1701.76 U0300.BB9
M_CHB_DQS3#: CON1700.74 CON1701.74 U0300.BC9
M_CHB_DQS4: CON1700.179 CON1701.179 U0300.AA9
M_CHB_DQS4#: CON1700.177 CON1701.177 U0300.AC9
M_CHB_DQS5: CON1700.200 CON1701.200 U0300.V9
M_CHB_DQS5#: CON1700.198 CON1701.198 U0300.W9
M_CHB_DQS6: CON1700.221 CON1701.221 U0300.P9
M_CHB_DQS6#: CON1700.219 CON1701.219 U0300.R9
M_CHB_DQS7: CON1700.242 CON1701.242 U0300.L9
M_CHB_DQS7#: CON1700.240 CON1701.240 U0300.M9
M_CHB_MAA0: CON1700.144 CON1701.144 U0300.AJ9
M_CHB_MAA1: CON1700.133 CON1701.133 U0300.AK6
M_CHB_MAA2: CON1700.132 CON1701.132 U0300.AK5
M_CHB_MAA3: CON1700.131 CON1701.131 U0300.AL5
M_CHB_MAA4: CON1700.128 CON1701.128 U0300.AL6
M_CHB_MAA5: CON1700.126 CON1701.126 U0300.AM6
M_CHB_MAA6: CON1700.127 CON1701.127 U0300.AN7
M_CHB_MAA7: CON1700.122 CON1701.122 U0300.AN10
M_CHB_MAA8: CON1700.125 CON1701.125 U0300.AN8
M_CHB_MAA9: CON1700.121 CON1701.121 U0300.AR11
M_CHB_MAA10: CON1700.146 CON1701.146 U0300.AH7
M_CHB_MAA11: CON1700.120 CON1701.120 U0300.AN11
M_CHB_MAA12: CON1700.119 CON1701.119 U0300.AR10
M_CHB_MAA13: CON1700.158 CON1701.158 U0300.AF9
M_CHB_MAA14: CON1700.151 CON1701.151 U0300.AH11
M_CHB_MAA15: CON1700.156 CON1701.156 U0300.AF8
M_CHB_MAA16: CON1700.152 CON1701.152 U0300.AH10
M_CHB_ODT0: CON1700.155 U0300.AF7
M_CHB_ODT1: CON1700.161 U0300.AE8
M_CHB_ODT2: CON1701.155 U0300.AE9
M_CHB_ODT3: CON1701.161 U0300.AE11
M_CHB_PAR: CON1700.143 CON1701.143 U0300.AJ7
MB_ID0: R6117.2 R6118.1 U2000.U36
MB_ID1: R6119.2 R6120.1 U2000.P44
MB_ID2: R6101.2 R6102.1 U2000.T45
MB_ID3: R6103.2 R6104.1 U2000.T44
MB_ID4: R6121.2 R6122.1 U2000.R44
MB_ID5: R6123.2 R6124.1 U2000.R43
MCK_BUTTON1#: CON5602.14 U3001.108
MCK_BUTTON1_IO: CON402.14 PCON702.4
MCK_BUTTON2#: CON5602.12 U3001.109
MCK_BUTTON2_IO: CON402.12 PCON702.6
MCK_BUTTON3#: CON5602.10 U3001.35
MCK_BUTTON3_IO: CON402.10 PCON702.8
MCK_BUTTON4#: CON5602.8 U3001.20
MCK_BUTTON4_IO: CON402.8 PCON702.10
MCK_BUTTON5#: CON5602.6 U3001.86
MCK_BUTTON5_IO: CON402.6 PCON702.12
MCK_BUTTON6#: CON5602.2 U3001.88
MCK_BUTTON6_IO: CON402.2 PCON702.16
MCK_LED1: CON5602.15 R3087.2
MCK_LED1_IO: CON402.15 PCON702.3
MCK_LED2: CON5602.13 R3088.2
MCK_LED2_IO: CON402.13 PCON702.5
MCK_LED3: CON5602.11 R3085.2
MCK_LED3_IO: CON402.11 PCON702.7
MCK_LED4: CON5602.9 R3086.2
MCK_LED4_IO: CON402.9 PCON702.9
MCK_LED5: CON5602.7 R3098.2
MCK_LED5_IO: CON402.7 PCON702.11
MCK_LED_B: CON5602.3 R3091.2
MCK_LED_B_IO: CON402.3 PCON702.15
MCK_LED_G: CON5602.4 R3090.2
MCK_LED_G_IO: CON402.4 PCON702.14
MCK_LED_R: CON5602.5 R3089.2
MCK_LED_R_IO: CON402.5 PCON702.13
MCT0: R3400.1 U3401.24
MCT1: R3401.1 U3401.21
MCT2: R3402.1 U3401.18
MCT3: R3403.1 U3401.15
ME_AC_PRESENT: R2442.2 R2459.1 R3037.1 U2000.BB15
MSM_TP: T1001.1 U0300.AW13
N16_REST_BACKUP#: R2465.2 R2481.1 U2000.BD34 U7002.1
NC_B4: R1126.1 U1101.B4
NC_B5: R1127.1 U1101.B5
NC_F19: R1124.2 U1101.F19
NC_G2: R1125.1 U1101.G2
NO_REBOOT_MODE: R2405.2 R2413.1 U2000.BD28
NTC_A: R8081.2 U8000.15
NTC_B: R8031.2 U8000.3
NVDD_GND_SENSE: SR8703.2 SR8707.2 T7002.1 U7000.AW23 U8700.10
NVDD_SENSE: R8715.1 T7001.1 U7000.AY23 U8700.11
OC0#: R2118.2 U2000.AD43 U5200.13
OC1#: CON6700.24 R2117.2 U2000.AD42
OC2#: R2119.2 U2000.AD39 U5501.3
OP_SD#: Q3601.2 R2420.2 U2000.BD24
OPC_RCOMP: R1014.1 U0300.BT29
OPCE_RCOMP: R1015.1 U0300.BR25
OPCE_RCOMP2: R1016.1 U0300.BP25
OUT_AUXN: CON4601.17 R4607.2 U4601.27
OUT_AUXP: CON4601.15 R4608.2 U4601.28
OUT_HPD: CON4601.18 U4601.11
PCBEEP: R2449.2 R2460.2 R3606.2 U2000.BD26 U3001.34
PCH_BATL#: R2444.2 U2000.BD13
PCH_BKLT_EN: R2360.2 R4594.1 U2000.AM44
PCH_C1: T2502.1 U2000.C1
PCH_CPUPWRGD: R2462.1 U2000.AM3
PCH_D1: T2503.1 U2000.D1
PCH_DDIC_CTRCLK: Q4803.2 R4817.2 U1101.Y2
PCH_DDIC_CTRLDATA: Q4802.2 R4818.2 U1101.Y1
PCH_DEVSLP1: R2102.2 R5104.1 U2000.AG43
PCH_DEVSLP4: R2164.2 U2000.AB42
PCH_DEVSLP5: R2124.2 U2000.AB43
PCH_DEVSLP6: R2123.2 U2000.AB36
PCH_DEVSLP7: R2122.2 U2000.AB39
PCH_DGPU_EN: R2407.2 R2427.1 R2495.2 R2496.2 U2000.AL27
PCH_DP_PD#: Q1302.2 R2370.2 U2000.AT43
PCH_DRAM_RESET#: C2402.1 R2452.1 R2478.1 R2485.2 U2000.BC14
PCH_DSW_PWROK: R2476.1 R2492.2 U2000.AV11
PCH_EDP_BKLTCTL: R2140.1 U2000.W36
PCH_EDP_BKLTEN: R2148.1 R2150.1 U2000.W35
PCH_EN_PWR: R2495.1 R2498.1 SR9104.1
PCH_FLASH_DESCRIPTOR: D2301.1 U3001.2
PCH_GPP_F22: R2131.2 U2000.W39
PCH_GPP_F23: R2146.1 U2000.V44
PCH_GSXDIN: R2261.1 U2000.R42
PCH_GSXSLOAD: R2248.2 U2000.R36
PCH_GSXSRST#: R2260.1 U2000.R41
PCH_H_TRST#: R2322.2 U2000.AY5
PCH_HDMI_DDC_CLK: R1148.1 R2128.2 R2156.1
PCH_HDMI_DDC_DATA: R1149.1 R2101.1 R2129.2
PCH_HDMI_PD#: Q1302.5 R2369.2 U2000.AU43
PCH_JTAG_TCK: R2350.1 R4402.2 U2000.AN3
PCH_JTAG_TDI: R2345.2 U2000.AP2
PCH_JTAG_TDO: R2344.1 U2000.AP1
PCH_JTAG_TMS: R2343.2 U2000.AR2
PCH_JTAGX: R2346.1 U2000.AR3
PCH_NMI#: R2205.2 U2000.N43
PCH_OCB4: R2114.2 U2000.Y43
PCH_OCB5: R2113.2 U2000.Y41
PCH_OCB6: R2115.2 U2000.W44
PCH_OCB7: R2116.2 U2000.W43
PCH_PLTRST#: R2457.1 U2000.BB27
PCH_PME_IN#: R2250.2 U2000.BD17
PCH_PWROK: R2475.1 R2493.2 R2494.2 U2000.AW11 U2402.4
PCH_RCIN#: C2200.1 R2202.2 R2218.2 U2000.AT17
PCH_RSMRST#: R2477.1 R2488.1 R2492.1 U2000.BA11
PCH_SATALED#: D5601.1 R2106.2 U2000.AD44
PCH_SCLOCK: R2136.2 U2000.AB33
PCH_SDATAO0: R2133.2 R2145.1 U2000.AA44
PCH_SDATAO1: R2134.2 U2000.AA45
PCH_SLOAD: R2135.2 U2000.AB35
PCH_SLP_S3#: R2438.1 T2407.1 U2000.AW15
PCH_SLP_S4#: R2439.1 T2406.1 U2000.BD15
PCH_SLP_S5#: R2440.1 T2405.1 U2000.BA13
PCH_SLP_WLAN#: R2441.1 T2403.1 U2000.AV13
PCH_SML2ALERT#: R2464.2 R2484.2 U2000.BD35
PCH_SRCCLKREQ1#: R2410.2 U2000.AW24
PCH_SRCCLKREQ2#: R2411.2 U2000.AT24
PCH_SRCCLKREQ4#: R2422.2 U2000.BB24
PCH_SRCCLKREQ5#: R2423.2 U2000.BE25
PCH_SRCCLKREQ6#: R2428.2 U2000.AT33
PCH_SRCCLKREQ11#: R2433.2 U2000.BC33
PCH_SUSACK#: T2205.1 U2000.BB19
PCH_SYS_PWROK: R2479.1 R2489.2 R2491.2 U2000.AY1 U2403.4
PCH_TGR_L900MIL: R2326.1 U2000.AL2
PCH_THMTRIP#_R: R2454.1 U2000.AJ3
PCH_VR_ICC_THROTTLING: R2408.2 U2000.BD23
PCH_VSS_AB10: R2701.1 U2000.AB10
PCH_VSS_AB11: R2700.1 U2000.AB11
PCHXDP_OBSDATA_A0_R: R2107.2 R2111.1 U2000.AG35
PCHXDP_OBSDATA_A1_R: R2108.2 R2112.1 U2000.AG39
PCHXDP_OBSDATA_A2_R: R2100.2 U2000.AF41
PCHXDP_OBSDATA_B1_R: R2103.2 U2000.AE45
PCHXDP_OBSDATA_B2_R: R2104.2 U2000.AE44
PCHXDP_PRDY#: R2325.1 U2000.AT4
PCHXDP_PREQ_R#: R4403.2 U2000.AT3
PCI_IRQA: R2206.2 R2225.2 U2000.AW17
PCIE_CLK_N_GPU: R2519.2 U7000.BC20
PCIE_CLK_N_GPU_R: R2519.1 U2000.N3
PCIE_CLK_P_GPU: R2518.2 U7000.BD20
PCIE_CLK_P_GPU_R: R2518.1 U2000.N2
PCIE_LAN_TXN: C2013.2 U2000.B21
PCIE_LAN_TXP: C2012.2 U2000.A21
PCIE_RCOMPN: R2516.2 U2000.B18
PCIE_RCOMPP: R2516.1 U2000.C17
PCIE_RXN7_WLAN: CON5300.43 U2000.L17
PCIE_RXP7_WLAN: CON5300.41 U2000.K17
PCIE_SATA_PEDET: CON5103.69 T5103.1
PCIE_SATA_RXN0: CON5102.43 U2000.G31
PCIE_SATA_RXN1: CON5102.29 U2000.G29
PCIE_SATA_RXN2: CON5102.17 U2000.L31
PCIE_SATA_RXN3: CON5102.5 U2000.G33
PCIE_SATA_RXP0: CON5102.41 U2000.H31
PCIE_SATA_RXP1: CON5102.31 U2000.E29
PCIE_SATA_RXP2: CON5102.19 U2000.K31
PCIE_SATA_RXP3: CON5102.7 U2000.H33
PCIE_SATA_TXN0: C5131.1 U2000.C31
PCIE_SATA_TXN0_C: C5131.2 CON5102.47
PCIE_SATA_TXN1: C5150.1 U2000.C32
PCIE_SATA_TXN1_C: C5150.2 CON5102.35
PCIE_SATA_TXN2: C5155.1 U2000.C33
PCIE_SATA_TXN2_C: C5155.2 CON5102.23
PCIE_SATA_TXN3: C5158.1 U2000.B35
PCIE_SATA_TXN3_C: C5158.2 CON5102.11
PCIE_SATA_TXP0: C5132.1 U2000.B31
PCIE_SATA_TXP0_C: C5132.2 CON5102.49
PCIE_SATA_TXP1: C5151.1 U2000.B32
PCIE_SATA_TXP1_C: C5151.2 CON5102.37
PCIE_SATA_TXP2: C5154.1 U2000.B33
PCIE_SATA_TXP2_C: C5154.2 CON5102.25
PCIE_SATA_TXP3: C5159.1 U2000.A35
PCIE_SATA_TXP3_C: C5159.2 CON5102.13
PCIE_TXN7_WLAN: C2021.1 CON5300.37
PCIE_TXN7_WLAN_C: C2021.2 U2000.B20
PCIE_TXP7_WLAN: C2020.1 CON5300.35
PCIE_TXP7_WLAN_C: C2020.2 U2000.C20
PCIEGPU_WAKE#_R: T7000.1 U7000.BJ21
PDB: D3601.1 Q3602.3 R3608.2 R3702.1 U3600.47
PECI_PCH: C2201.1 R0746.1 R2235.1 U2000.AL3
PEG_RCOMP: R0600.2 U0300.G2
PEG_RXN_0: C0631.2 U0300.E10
PEG_RXN_1: C0629.2 U0300.E11
PEG_RXN_2: C0627.2 U0300.E12
PEG_RXN_3: C0625.2 U0300.E13
PEG_RXN_4: C0623.2 U0300.E14
PEG_RXN_5: C0621.2 U0300.E15
PEG_RXN_6: C0619.2 U0300.E16
PEG_RXN_7: C0617.2 U0300.E17
PEG_RXN_8: C0615.2 U0300.F18
PEG_RXN_9: C0613.2 U0300.D19
PEG_RXN_10: C0611.2 U0300.F20
PEG_RXN_11: C0605.2 U0300.D21
PEG_RXN_12: C0609.2 U0300.F22
PEG_RXN_13: C0608.2 U0300.D23
PEG_RXN_14: C0602.2 U0300.F24
PEG_RXN_15: C0600.2 U0300.D25
PEG_RXP_0: C0630.2 U0300.F10
PEG_RXP_1: C0628.2 U0300.D11
PEG_RXP_2: C0626.2 U0300.F12
PEG_RXP_3: C0624.2 U0300.D13
PEG_RXP_4: C0622.2 U0300.F14
PEG_RXP_5: C0620.2 U0300.D15
PEG_RXP_6: C0618.2 U0300.F16
PEG_RXP_7: C0616.2 U0300.D17
PEG_RXP_8: C0614.2 U0300.E18
PEG_RXP_9: C0612.2 U0300.E19
PEG_RXP_10: C0606.2 U0300.E20
PEG_RXP_11: C0610.2 U0300.E21
PEG_RXP_12: C0604.2 U0300.E22
PEG_RXP_13: C0603.2 U0300.E23
PEG_RXP_14: C0601.2 U0300.E24
PEG_RXP_15: C0607.2 U0300.E25
PET0_N: C1102.2 U1101.V22
PET0_P: C1101.2 U1101.V23
PET1_N: C1104.2 U1101.P22
PET1_P: C1103.2 U1101.P23
PET2_N: C1106.2 U1101.K22
PET2_P: C1105.2 U1101.K23
PET3_N: C1108.2 U1101.F22
PET3_P: C1107.2 U1101.F23
PEX_CLKREQ#: Q7000.3 R2431.2 R7010.2 U2000.BC32
PEX_CLKREQ#_Q: Q7000.2 R7001.2 U7000.BB20
PEX_PLLVDD_1: C7045.1 C7046.1 C7047.1 R7007.1 U7000.AW26
PEX_RST#: D7001.3 Q7403.1 Q7404.1 R7000.1 U7000.BE20
PEX_TERMP: R7009.1 U7000.BJ38
PEX_TSTCLK_OUT: R7006.1 U7000.BH38
PEX_TSTCLK_OUT#: R7006.2 U7000.BG38
PH1_A: JP8050.2 L8000.1 R8053.2 T8050.1 U8001.16 U8001.17 U8001.18 U8001.19 U8001.20 U8001.21 U8001.22 U8001.23 U8001.24 U8001.25 U8001.26
PH1_B: JP8058.2 L8003.1 R8073.2 T8054.1 U8006.16 U8006.17 U8006.18 U8006.19 U8006.20 U8006.21 U8006.22 U8006.23 U8006.24 U8006.25 U8006.26
PH2_A: JP8052.2 L8001.1 R8054.2 T8051.1 U8002.16 U8002.17 U8002.18 U8002.19 U8002.20 U8002.21 U8002.22 U8002.23 U8002.24 U8002.25 U8002.26
PH2_B: JP8059.2 L8004.1 R8072.2 T8055.1 U8004.16 U8004.17 U8004.18 U8004.19 U8004.20 U8004.21 U8004.22 U8004.23 U8004.24 U8004.25 U8004.26
PH3_A: JP8054.2 L8002.1 R8055.2 T8052.1 U8003.16 U8003.17 U8003.18 U8003.19 U8003.20 U8003.21 U8003.22 U8003.23 U8003.24 U8003.25 U8003.26
PH_C: C8086.2 JP8056.2 L8005.1 Q8001.5 Q8002.1 Q8002.2 Q8002.3 R8070.2 T8053.1 U8005.8
PLT_RST#_R: CON5300.52 R5309.1
PLTRST#: R2457.2 R3137.2 R5123.1 U2401.1 U2401.2 U3001.22 U6200.16
PLTRST#_BUF: R1150.2 R3308.2 R5309.2 R7002.1 U2401.4
PLTRST_CPU#: R2474.1 R4418.2 U0300.BP35 U2000.AK2
PM_CLKRUN#: R2251.2 U2000.AW22 U3001.93 U6200.15
PM_DOWN: R0731.1 U2000.AH2
PM_PWRBTN#: C2400.1 R2447.2 R4415.2 U2000.AT13 U3001.87
PM_RSMRST#: R2488.2 R3066.2 R4406.2 U3001.112
PM_SUSB#: R0749.1 R1153.2 R2438.2 R2491.1 R3062.2 R3074.1 U2403.2 U3001.18
PM_SUSC#: R2439.2 R3063.2 R3075.1 R3164.1 U3001.21
PM_SYNC: R2228.2 U0300.BM34
PM_SYNC_R: R2228.1 U2000.AJ4
PROC_AUDIO_CLK: R2311.1 U0300.G27
PROC_AUDIO_SDI: R2307.1 U0300.G25
PROC_AUDIO_SDO: R0302.2 U2000.AN2
PROCHOT#: Q0702.3 R0706.1 R0727.1 R8003.2 R8822.2 R80150.2
PROCHOT#_R: R0727.2 U0300.BR30
PROG1: R8028.1 U8000.40
PROG2: R8041.1 U8000.39
PROG3: R8046.1 U8000.38
PROG4: R8087.1 U8000.37
PROG5: R8085.1 U8000.36
PSI: R8902.2 R8903.1 U8900.4
PSYS: C8010.2 R8021.2 U8000.1
PU_HDA_MODE: R2125.2 U2000.AB41
PV: R8739.1 U8702.10
PWM1_A: U8000.25 U8001.1
PWM1_B: U8000.12 U8006.1
PWM2_A: U8000.26 U8002.1
PWM2_B: U8000.13 U8004.1
PWM3_A: U8000.27 U8003.1
PWM_C: U8000.35 U8005.3
PWR_LED: CON5602.17 U3001.24
PWR_LED_IO: CON402.17 PCON700.4 PD701.1 PQ700.1
PWR_LED_LED: CON1.5 LC800.1 LQ800.1
PWRBTN#: CON5602.16 JP5601.1 R3053.2 U3001.125
PWRBTN#_IO: CON402.16 PD700.1 PSW1700.4
R303_D8: D2801.2 R2811.2
R_DMIC-CLK: R3611.2 U3600.3
R_DMIC-DATA: R3610.2 U3600.2
RCIN#: R2218.1 U3001.4
RL_XTAL1: C3324.1 U3300.7 Y3300.1
RL_XTAL2: C3325.1 U3300.8 Y3300.3
ROM_S0: R7305.2 R7313.1 U7000.BA4 U7401.2
ROM_SCLK: R7306.1 R7314.1 R7403.1 U7000.BA2
ROM_SI: R7304.2 R7312.2 R7402.1 U7000.BA5
RPD_G1: R1202.2 U1201.K9
RPD_G2: R1204.2 U1201.K10
RST#: R3307.2 R3308.1 U3300.2
RST#_DP: C1412.1 R1407.2 U1401.35
RST#_DP2: C4613.2 R4621.2 U4601.35
RST#_HDMI: C1303.1 R1302.2 U1301.35
RSVD19: R1004.1 U0300.BL22
RSVD28: R1005.2 U0300.BM22
RSVD30: R1010.2 U0300.BN16
RSVD34: R1009.1 U0300.BP17
RSVD_TP0: T0708.1 U0300.BJ13
RSVD_TP1: T0707.1 U0300.BJ14
RSVD_TP2: T0717.1 U0300.BJ16
RSVD_TP3: T0724.1 U0300.BJ24
RSVD_TP4: T0734.1 U0300.BJ33
RSVD_TP5: T0732.1 U0300.BJ34
RSVD_TP6: T0719.1 U0300.BK16
RSVD_TP7: T0722.1 U0300.BK24
RSVD_TP8: T0714.1 U0300.BL33
RSVD_TP9: T0703.1 U0300.BM33
RSVD_TP10: T0709.1 U0300.BR1
RSVD_TP11: T0710.1 U0300.BT2
RSVD_TP12: T0702.1 U0300.D1
RSVD_TP13: T0704.1 U0300.E1
RSVD_TP14: T0706.1 U0300.E2
RSVD_TP15: T0705.1 U0300.E3
RSVD_TP36: T0730.1 U0300.BR17
RSVD_TP40: T0729.1 U0300.BT17
RTCRST#: C2828.1 R2812.2 U2000.BC10
RTCX1_NO_IO: C2500.1 R2523.1 R2525.1 U2000.BC9
RTCX2_NO_IO: C2501.1 R2523.2 U2000.BD10 Y2500.4
RTD3_CIO_PWR_EN: R1130.1 U1101.F1
RTD3_USB_PWR_EN: R1134.1 U1101.D4
RTN_A: R8005.2 U8000.18
RTN_B: R8027.2 U8000.6
S3: C8319.1 D8300.1 R8305.2 U8300.7
S5: C8322.1 D8301.1 R8307.2 U8300.8
SATA_DEVSLP0: R2157.2 R5106.1 U2000.AG42
SATA_LED#: CON5602.24 D5601.3 R5603.2
SATA_LED#_IO: CON402.24 PCON700.7
SATA_LED#_LED: CON1.2 LC803.1 LQ803.2
SATA_LED_LED: LQ803.5 LQ803.6 LR804.2
SATA_ODD_DA#: R2209.2 R5109.2 U2000.U41
SATA_ODD_PRSNT#_CON: R5108.2 U5102.2
SATA_RXN1: C5122.1 U2000.D39
SATA_RXN2: C5102.1 U2000.F41
SATA_RXN2_C: C5102.2 CON5100.16
SATA_RXN3: C5142.1 U2000.D43
SATA_RXN3_C: C5142.2 CON5101.S5
SATA_RXN4_C: C5122.2 CON5103.43
SATA_RXP1: C5121.1 U2000.E37
SATA_RXP2: C5103.1 U2000.E41
SATA_RXP2_C: C5103.2 CON5100.15
SATA_RXP3: C5143.1 U2000.E42
SATA_RXP3_C: C5143.2 CON5101.S6
SATA_RXP4_C: C5121.2 CON5103.41
SATA_SSD_LED#: D5601.2 R5126.1
SATA_TXN1: C5123.1 U2000.B38
SATA_TXN2: C5101.1 U2000.B39
SATA_TXN2_C: C5101.2 CON5100.18
SATA_TXN3: C5141.1 U2000.A41
SATA_TXN3_C: C5141.2 CON5101.S3
SATA_TXN4_C: C5123.2 CON5103.47
SATA_TXP1: C5124.1 U2000.C38
SATA_TXP2: C5100.1 U2000.A39
SATA_TXP2_C: C5100.2 CON5100.19
SATA_TXP3: C5140.1 U2000.A40
SATA_TXP3_C: C5140.2 CON5101.S2
SATA_TXP4_C: C5124.2 CON5103.49
SBU1: CON1201.A8 R1219.2 U1207.2
SBU2: CON1201.B8 R1220.2 U1207.8
SCLK: R8012.1 U8000.45
SDA: R8014.1 U8000.43
SDATA_IN_R: R3613.2 U3600.8
SLP_S5#: Q5301.1 R2440.2
SLP_WLAN#: Q5302.1 R2441.2
SM_RCOMP0: R0504.2 U0300.G1
SM_RCOMP1: R0506.2 U0300.H1
SM_RCOMP2: R0507.1 U0300.J2
SMB0_CLK: D6002.1 D6005.3 R3032.2 R3071.2 R6003.2 SR8802.1
SMB0_DAT: D6003.1 D6006.3 R3033.2 R3070.2 R6004.2 SR8801.1
SMB1_CLK: CON6700.14 Q1202.2 Q7401.3 R3034.1 R3138.2 R5001.2 R5803.1 U5000.8
SMB1_DAT: CON6700.13 Q1201.2 Q7402.3 R3035.1 R3139.2 R5002.2 R5804.1 U5000.7
SMB_CLK_MAIN: CON1600.253 CON1601.253 CON1700.253 CON1701.253 Q3102.2 R1623.2 R3105.2 R3110.2 R4421.1
SMB_CLK_RESUME: C2304.1 Q3102.3 R2327.2 R3110.1 U2000.AW44
SMB_DATA_MAIN: CON1600.254 CON1601.254 CON1700.254 CON1701.254 Q3100.2 R1624.2 R3104.2 R3108.2 R4420.1
SMB_DATA_RESUME: C2305.1 Q3100.3 R2328.2 R3108.1 U2000.BB43
SMBALERT#_PCHHOT#: R2335.2 R2349.2 U2000.AT27
SMBALERT#_TLS: R2334.2 R2348.2 U2000.BB41
SMBCLKCPUXDP: R4421.2 XDP4400.53
SMBDATACPUXDP: R4420.2 XDP4400.51
SMCLK0: R3032.1 U3001.110
SMDAT0: R3033.1 U3001.111
SML0_DATA: C2307.1 R2330.2 U2000.BB39
SML1_CLK: R3034.2 U3001.115
SML1_DATA: R3035.2 U3001.116
SPI_CLK: C2204.1 CON4402.7 R2232.1 R3043.1 R3157.2
SPI_CLK_L500MIL: R2232.2 U2000.BC31
SPI_CS0#: CON4402.5 R2229.1 R3041.1 U3101.1
SPI_CS0#_L500MIL: R2229.2 U2000.BD31
SPI_IO2: R2234.1 R3159.1 R4425.2
SPI_IO2_L500MIL: R2234.2 U2000.BC29
SPI_IO3: CON4402.10 R2233.1 R3158.2
SPI_IO3_L500MIL: R2233.2 U2000.BD30
SPI_MISO: CON4402.6 R2231.1 R3160.1 U3001.103
SPI_MISO_L500MIL: R2231.2 U2000.BE30
SPI_MOSI: CON4402.8 R2230.1 R3044.1 R3156.2 R4414.2
SPI_MOSI_L500MIL: R2230.2 U2000.BB29
SRTCRST#: C2827.1 R2810.2 U2000.BB10
SSD_PRESENT: CON5103.1 T5102.1
STRAP0: R7307.2 R7315.1 U7000.BA6
STRAP1: R7308.2 R7316.1 U7000.AW8
STRAP2: R7309.2 R7317.1 U7000.BA7
STRAP3: R7310.2 R7318.1 U7000.BA8
STRAP4: R7311.2 R7319.1 U7000.BB6
SURGE_IN_C: C3400.1 U3401.1 U3401.4 U3401.7 U3401.10
SURGE_OUT_C: C3401.1 R3400.2 R3401.2 R3402.2 R3403.2
SUS_PWRGD: D9200.2 R9202.2 R9213.2 T9205.1 U3001.67 U8100.7
SUSB#_PWR: D9400.2 JP9301.2 Q9102.2 R8304.1 R8402.1 R9104.1 R9106.1 R9109.1 R9403.1 SR9101.2 T9108.1 T9301.1
SUSB_EC#: D9201.2 R3029.1 R3074.2 R3079.2 R9204.1 SR9101.1 U2404.2
SUSC#_PWR: D8301.2 D9500.1 JP9302.2 Q9103.2 R8307.1 R9100.1 R9105.1 R9112.1 R9503.1 SR9103.2 T9111.1 T9302.1
SUSC_EC#: R3030.1 R3075.2 R3080.2 SR9103.1
SUSWARN#: R2263.1 T2206.1 U2000.BD19
SW_3PIN: PR700.1 PSW1700.3
SYS_PEX_RST_MON#: D7001.1 R7441.1 R7443.2 U7000.AW2 U7002.4
SYS_PWROK: R2489.1 R3076.1 U2403.1
SYS_RESET#: R2451.2 R4419.2 U2000.AW1
TBT_BATLOW_N: R1132.1 U1101.F2
TBT_CIO_PLUG_EVENT_N: R1146.1 R1152.2 R2247.2 R2257.1 U2000.R39
TBT_CIO_PLUG_EVENT_N_R: R1152.1 U1101.W2
TBT_CLKREQ_N: R1111.1 R2483.2 U1101.AC5
TBT_EE_CLK: U1101.AB4 U1103.6 U1201.A3
TBT_EE_CS_N: R1105.1 U1101.AC3 U1103.1 U1201.B3
TBT_EE_DI: U1101.AB3 U1103.5 U1201.B4
TBT_EE_DO: R1104.1 U1101.AC4 U1103.2 U1201.A4
TBT_EE_WP_N: R1103.1 U1101.V1 U1103.3
TBT_FORCE_PWR: R1133.1 R1151.2 R2259.2 U2000.P43
TBT_FORCE_PWR_R: R1151.1 U1101.H4
TBT_HOLD_N: R1106.1 U1103.7
TBT_I2C_SCL: R1141.1 U1101.U2 U1201.D2
TBT_I2C_SDA: R1140.1 U1101.U1 U1201.D1
TBT_MRESET: R1222.1 R3092.2 U1201.E11
TBT_PCIE_RX0_N: C1102.1 U2000.K19
TBT_PCIE_RX0_P: C1101.1 U2000.L19
TBT_PCIE_RX1_N: C1104.1 U2000.G22
TBT_PCIE_RX1_P: C1103.1 U2000.E22
TBT_PCIE_RX2_N: C1106.1 U2000.L22
TBT_PCIE_RX2_P: C1105.1 U2000.K22
TBT_PCIE_RX3_N: C1108.1 U2000.K24
TBT_PCIE_RX3_P: C1107.1 U2000.L24
TBT_PCIE_TX0_N: C2001.1 U1101.Y22
TBT_PCIE_TX0_N_C: C2001.2 U2000.D22
TBT_PCIE_TX0_P: C2000.1 U1101.Y23
TBT_PCIE_TX0_P_C: C2000.2 U2000.C22
TBT_PCIE_TX1_N: C2014.1 U1101.T22
TBT_PCIE_TX1_N_C: C2014.2 U2000.B22
TBT_PCIE_TX1_P: C2015.1 U1101.T23
TBT_PCIE_TX1_P_C: C2015.2 U2000.A23
TBT_PCIE_TX2_N: C2016.1 U1101.M22
TBT_PCIE_TX2_N_C: C2016.2 U2000.C23
TBT_PCIE_TX2_P: C2017.1 U1101.M23
TBT_PCIE_TX2_P_C: C2017.2 U2000.B23
TBT_PCIE_TX3_N: C2018.1 U1101.H22
TBT_PCIE_TX3_N_C: C2018.2 U2000.C24
TBT_PCIE_TX3_P: C2019.1 U1101.H23
TBT_PCIE_TX3_P_C: C2019.2 U2000.B24
TBT_PCIE_WAKE_N: R1138.1 R2443.1 U1101.W1
TBT_RBIAS: R1107.2 U1101.H6
TBT_REFCLK_100_N: R2528.2 U1101.T19
TBT_REFCLK_100_N_R: R2528.1 U2000.E5
TBT_REFCLK_100_P: R2527.2 U1101.V19
TBT_REFCLK_100_P_R: R2527.1 U2000.G4
TBT_RESET_N: R1162.2 U1201.F11
TBT_RSENSE: R1107.1 U1101.J6
TBT_SLP_S3_N: R1131.1 R1153.1 U1101.D2
TBT_SNK0_DDC_AUXN: C1190.2 U1101.W11
TBT_SNK0_DDC_AUXP: C1189.2 U1101.Y11
TBT_SNK0_DDC_CLK: R1109.1 R1148.2 U1101.Y5
TBT_SNK0_DDC_DATA: R1110.1 R1149.2 U1101.R4
TBT_SNK1_DDC_CLK: R1143.1 U1101.Y8
TBT_SNK1_DDC_DATA: R1144.1 U1101.N4
TBT_SRC_HPD: R1147.1 R4800.2 R4816.1 U1101.G1
TBT_SRC_ML0_N: C1193.1 C4805.1 U1101.R1
TBT_SRC_ML0_P: C1193.2 C4804.1 U1101.R2
TBT_SRC_ML1_N: C1194.1 C4803.1 U1101.N1
TBT_SRC_ML1_P: C1194.2 C4802.1 U1101.N2
TBT_SRC_ML2_N: C1195.1 C4801.1 U1101.L1
TBT_SRC_ML2_P: C1195.2 C4800.1 U1101.L2
TBT_SRC_ML3_N: C1196.1 C4808.1 U1101.J1
TBT_SRC_ML3_P: C1196.2 C4807.1 U1101.J2
TBT_TCK: R1114.2 T1103.1 U1101.T4
TBT_TDI: R1112.2 T1101.1 U1101.Y4
TBT_TDO: R1115.2 T1104.1 U1101.W4
TBT_TEST_EN: R1128.1 U1101.E1
TBT_TEST_PWG: R1129.1 U1101.AB5
TBT_TMS: R1113.2 T1102.1 U1101.V4
TBT_TMU_CLK_OUT: R1139.1 U1101.V2
TBT_XTAL_25_IN: C1130.1 U1101.D22 X1101.1
TBT_XTAL_25_OUT: C1131.1 U1101.D23 X1101.3
TBTA_AUX_N: C1136.2 U1101.W15
TBTA_AUX_P: C1137.2 U1101.Y15
TBTA_CA2HD_0_N_CON: CON1201.B10 D1204.1 U1101.A21
TBTA_CA2HD_0_P_CON: CON1201.B11 D1203.1 U1101.B21
TBTA_CA2HD_1_N_CON: CON1201.A10 D1208.1 U1101.B15
TBTA_CA2HD_1_P_CON: CON1201.A11 D1207.1 U1101.A15
TBTA_DPSRC_AUX_N: C1136.1 R1155.1 U1201.J2
TBTA_DPSRC_AUX_P: C1137.1 R1154.1 U1201.J1
TBTA_HD2CA_0_N_CON: C1135.2 CON1201.A3 D1201.1
TBTA_HD2CA_0_P_CON: C1134.2 CON1201.A2 D1202.1
TBTA_HD2CA_1_N_CON: C1133.2 CON1201.B3 D1205.1
TBTA_HD2CA_1_P_CON: C1132.2 CON1201.B2 D1206.1
TBTA_HPD: R1120.1 R1121.1 U1201.C10
TBTA_I2C_INT: R1145.1 U1101.J4 U1201.C1
TBTA_LSRX: R1122.1 U1101.A4 U1201.K4
TBTA_LSTX: R1118.1 U1101.A5 U1201.L4
TBTA_TX0_N: C1135.1 U1101.B19
TBTA_TX0_P: C1134.1 U1101.A19
TBTA_TX1_N: C1133.1 U1101.B17
TBTA_TX1_P: C1132.1 U1101.A17
TBTA_USB2_D_N: U1101.D20 U1201.K5
TBTA_USB2_D_P: U1101.E20 U1201.L5
TBTA_USB2_RBIAS: R1123.2 U1101.H19
TBTB_I2C_INT: R1135.1 U1101.E2
TC: R8736.1 U8702.13
TESTMODE: R7008.1 U7000.BA23
THRO_CPU: Q0702.1 U3001.123
TOUCHPANEL_EN: CON4301.15 R2471.2 U2000.BA35
TOUCHPANEL_INT#: CON4301.12 R2470.2 U2000.BC35
TOUCHPANEL_RST#: CON4301.11 R2467.2 U2000.BB36
TP_ATTN#: CON3104.11 Q2301.2 R2310.2 R2363.2 R2382.2
TP_ATTN#_Q: Q2301.3 R2381.2 R2382.1 U2000.AH43
TP_BL_EN: Q3107.1 R2435.2 U2000.AW33
TP_BTN#: CON3104.4 R3081.2 U3001.128
TP_CHA_XMM3_S2: CON1600.162 CON1601.162 T1601.1 T1602.1
TP_CHA_XMM3_S3: CON1600.165 CON1601.165 T1600.1 T1603.1
TP_CHB_XMM1_S2: CON1700.162 CON1701.162 T1702.1 T1703.1
TP_CHB_XMM1_S3: CON1700.165 CON1701.165 T1700.1 T1701.1
TP_CK_48M_USB_SEVR_ONLY: T2204.1 U2000.AR17
TP_CLK_I2C: R2313.2 R3151.2 U2301.3
TP_CLK_I2C_PCH: R2379.2 U2000.AR38 U2301.4
TP_DATA_I2C: R2312.2 R3150.2 U2301.6
TP_DATA_I2C_PCH: R2380.2 U2000.AT42 U2301.1
TP_EXIT_HOLDOFF#: R2262.1 T2203.1 U2000.BB17
TP_GPD7_RSVD: T2410.1 U2000.BD14
TP_GPP_A17_ISH_GP7: R2240.2 U2000.BC19
TP_GPP_A20_ISH_GP2: R2241.2 U2000.BD22
TP_GPP_A23_ISH_GP5: R2242.2 U2000.BC22
TP_GPP_B11: T2400.1 U2000.AN24
TP_GPP_G0_TACH0: R2207.2 U2000.U43
TP_GPP_H_18: R2473.2 U2000.BC36
TP_LANPHYPC: T2409.1 U2000.AR15
TP_LED_BLUE: CON3104.5 R2437.2 U2000.BD33
TP_LED_RED: CON3104.6 R2436.2 U2000.BB33
TP_PCH_RSVD_BD1: T2500.1 U2000.BD1
TP_PCH_RSVD_BE2: T2501.1 U2000.BE2
TP_PS2_CLK: C3103.1 CON3104.7 D3102.1 R3073.2 U3001.89
TP_PS2_DAT: C3102.1 CON3104.8 D3101.1 R3072.2 U3001.90
TP_SENSOR: CON3104.12 R2434.2 U2000.BA33
TP_SPI0_CS1#: T2202.1 U2000.AW31
TP_SPI0_CS2#: T2201.1 U2000.AT31
TS1#: CON6000.5 JP9000.2 R6001.2
TS_I2C_CLK: CON4301.14 R2315.2 U2000.AR41
TS_I2C_DATA: CON4301.13 R2314.2 U2000.AR44
UART0_DEBUG_RXD: CON4402.4 U2000.BA41
UART0_DEBUG_TXD: CON4402.2 U2000.AV44
USB2_COMP: R2526.2 U2000.AG3
USB2_ID: R2001.2 U2000.AG2
USB2_VBUSSENSE: R2000.1 U2000.AD10
USB3_RX_H_N1: CON5500.5 L5500.3 RN5500.2 U5500.1 U5500.10
USB3_RX_H_N2: CON5501.5 L5503.3 RN5503.2 U5502.1 U5502.10
USB3_RX_H_P1: CON5500.6 L5500.2 RN5500.4 U5500.2 U5500.9
USB3_RX_H_P2: CON5501.6 L5503.2 RN5503.4 U5502.2 U5502.9
USB3_RX_N1: L5500.4 RN5500.1 U2000.G13
USB3_RX_N2: L5503.4 RN5503.1 U2000.C8
USB3_RX_N3: CON6700.34 U2000.B10
USB3_RX_N4: CON6700.43 U2000.E11
USB3_RX_N5: C4304.1 U2000.H15
USB3_RX_N6: CON6700.5 U2000.K15
USB3_RX_P1: L5500.1 RN5500.3 U2000.H13
USB3_RX_P2: L5503.1 RN5503.3 U2000.B8
USB3_RX_P3: CON6700.33 U2000.A9
USB3_RX_P4: CON6700.42 U2000.G11
USB3_RX_P5: C4303.1 U2000.G15
USB3_RX_P6: CON6700.6 U2000.K13
USB3_TX_H_N1: CON5500.8 L5502.3 RN5502.2 U5500.4 U5500.7
USB3_TX_H_N2: CON5501.8 L5505.3 RN5505.2 U5502.4 U5502.7
USB3_TX_H_P1: CON5500.9 L5502.2 RN5502.4 U5500.5 U5500.6
USB3_TX_H_P2: CON5501.9 L5505.2 RN5505.4 U5502.5 U5502.6
USB3_TX_N1: C2003.2 L5502.4 RN5502.1
USB3_TX_N1_C: C2003.1 U2000.B14
USB3_TX_N2: C2005.2 L5505.4 RN5505.1
USB3_TX_N2_C: C2005.1 U2000.B12
USB3_TX_N3: C2007.2 CON6700.31
USB3_TX_N3_C: C2007.1 U2000.C13
USB3_TX_N4: C2011.2 CON6700.40
USB3_TX_N4_C: C2011.1 U2000.A14
USB3_TX_N5: C4311.1 U2000.A16
USB3_TX_N6: CON6700.8 U2000.B15
USB3_TX_P1: C2002.2 L5502.1 RN5502.3
USB3_TX_P1_C: C2002.1 U2000.C14
USB3_TX_P2: C2004.2 L5505.1 RN5505.3
USB3_TX_P2_C: C2004.1 U2000.A12
USB3_TX_P3: C2006.2 CON6700.30
USB3_TX_P3_C: C2006.1 U2000.D13
USB3_TX_P4: C2009.2 CON6700.39
USB3_TX_P4_C: C2009.1 U2000.B13
USB3_TX_P5: C4312.1 U2000.B16
USB3_TX_P6: CON6700.9 U2000.C15
USB5_3DCAM_A_DE0: R4311.2 U4301.16
USB5_3DCAM_A_DE1: R4310.2 U4301.18
USB5_3DCAM_A_EQ0: R4309.2 U4301.17
USB5_3DCAM_A_EQ1: R4306.2 U4301.15
USB5_3DCAM_B_DE0: R4307.2 U4301.3
USB5_3DCAM_B_DE1: R4304.2 U4301.6
USB5_3DCAM_B_EQ0: R4302.2 U4301.2
USB5_3DCAM_B_EQ1: R4303.2 U4301.4
USB5_3DCAM_PD#: R2361.2 R4301.1 U2000.AJ44
USB5_3DCAM_PD#_R: R4301.2 U4301.5
USB5_3DCAM_REXT: R4312.1 U4301.7
USB5_3DCAM_RXN1_C: C4304.2 U4301.23
USB5_3DCAM_RXN1_CON: CON4301.2 L4302.2 RN4302.1 U4302.5 U4302.6
USB5_3DCAM_RXN1_CON_C: L4302.1 RN4302.2 U4301.8
USB5_3DCAM_RXP1_C: C4303.2 U4301.22
USB5_3DCAM_RXP1_CON: CON4301.3 L4302.3 RN4302.3 U4302.4 U4302.7
USB5_3DCAM_RXP1_CON_C: L4302.4 RN4302.4 U4301.9
USB5_3DCAM_TEST: R4305.2 U4301.14
USB5_3DCAM_TXN1_C: C4311.2 U4301.20
USB5_3DCAM_TXN1_CON: CON4301.5 L4301.4 RN4301.1 U4302.2 U4302.9
USB5_3DCAM_TXN1_CON_C: C4310.2 L4301.3 RN4301.2
USB5_3DCAM_TXN1_Q: C4310.1 U4301.11
USB5_3DCAM_TXP1_C: C4312.2 U4301.19
USB5_3DCAM_TXP1_CON: CON4301.6 L4301.1 RN4301.3 U4302.1 U4302.10
USB5_3DCAM_TXP1_CON_C: C4305.2 L4301.2 RN4301.4
USB5_3DCAM_TXP1_Q: C4305.1 U4301.12
USB_CHG_CTL1: R5202.1 U3001.106
USB_CHG_CTL2: R5203.1 R5209.2 R5210.1
USB_CHG_CTL3: R5204.1 U3001.81
USB_CHG_EN: T5201.1 U3001.107 U5200.5
USB_PWEN: CON6700.25 R5501.2 U3001.80 U5501.4
USBN1: U2000.AF5 U5200.2
USBN1_CHARGE: L5501.4 RN5501.1 U5200.11
USBN2: L5504.4 RN5504.1 U2000.AD5
USBN3: CON6700.37 U2000.AG8
USBN4: CON6700.28 U2000.AE1
USBN7: L5301.2 RN5301.4 U2000.AB3
USBN7_C: CON5300.5 L5301.1 RN5301.3
USBN8: CON4301.20 U2000.AL8
USBN9: L4500.1 RN4500.3 U2000.AA1
USBN10: CON6700.2 U2000.AJ8
USBP1: U2000.AG7 U5200.3
USBP1_CHARGE: L5501.1 RN5501.3 U5200.10
USBP2: L5504.1 RN5504.3 U2000.AD7
USBP3: CON6700.36 U2000.AG10
USBP4: CON6700.27 U2000.AE2
USBP7: L5301.3 RN5301.2 U2000.AB2
USBP7_C: CON5300.3 L5301.4 RN5301.1
USBP8: CON4301.19 U2000.AL7
USBP9: L4500.4 RN4500.1 U2000.AA2
USBP10: CON6700.3 U2000.AJ7
V_SA0_DIMM0_CHA: CON1600.256 R1604.2 R1613.1
V_SA0_DIMM0_CHB: CON1701.256 R1704.2 R1715.1
V_SA0_DIMM1_CHA: CON1601.256 R1607.2 R1617.1
V_SA0_DIMM1_CHB: CON1700.256 R1707.2 R1712.1
V_SA1_DIMM0_CHA: CON1600.260 R1605.2 R1614.1
V_SA1_DIMM0_CHB: CON1701.260 R1705.2 R1716.1
V_SA1_DIMM1_CHA: CON1601.260 R1608.2 R1618.1
V_SA1_DIMM1_CHB: CON1700.260 R1708.2 R1713.1
V_SA2_DIMM0_CHA: CON1600.166 R1606.2 R1615.1
V_SA2_DIMM0_CHB: CON1701.166 R1706.2 R1717.1
V_SA2_DIMM1_CHA: CON1601.166 R1609.2 R1619.1
V_SA2_DIMM1_CHB: CON1700.166 R1709.2 R1719.1
VCLK: C8120.2 C8122.1 T8119.1 U8100.19
VCORE_VCCSENSE: C8000.1 C8025.1 R8004.1 R80112.2 U0300.AG37
VCORE_VSSSENSE: C8002.1 C8025.2 R8000.1 R8005.1 U0300.AG38
VGA_BST1: R8709.1 U8700.1
VGA_BST1_R: C8706.1 R8709.2
VGA_BST2: R8721.1 U8700.18
VGA_BST2_R: C8733.1 R8721.2
VGA_BST3: R8726.1 U8701.4
VGA_BST3_R: C8736.1 R8726.2
VGA_DDR_BST1: SR8901.1 U8900.1
VGA_DDR_BST1_R: C8903.1 SR8901.2
VGA_DDR_HG1: SR8909.1 U8900.2
VGA_DDR_HG1_R: Q8900.1 Q8901.1 SR8909.2
VGA_DDR_LG1: Q8900.8 Q8901.8 R8911.2 U8900.19
VGA_DDR_LX1: C8903.2 L8900.1 Q8900.9 Q8901.9 R8904.1 T8900.1 U8900.20
VGA_DDR_PG: R9208.1 SR8908.1 T9211.1
VGA_DDR_PG_R: SR8908.2 U8900.13
VGA_DDR_RC1: C8906.1 R8904.2
VGA_DDR_REFIN: C8909.1 R8900.2 R8901.2 U8900.7
VGA_DDR_TON: R8907.1 R8910.1 U8900.9
VGA_DDR_VCCP: C8910.1 R8905.2 U8900.18
VGA_DDR_VREF: C8908.1 R8900.1 U8900.8
VGA_DDR_VRON: C8904.1 D8900.1 SR8903.2 U8900.3
VGA_HG1: SR8704.1 U8700.2
VGA_HG1_R: Q8701.4 SR8704.2
VGA_HG2: SR8705.1 U8700.17
VGA_HG2_R: Q8705.4 SR8705.2
VGA_HG3: SR8706.1 U8701.3
VGA_HG3_R: Q8709.4 SR8706.2
VGA_LG1: Q8703.4 Q8704.4 R8717.2 U8700.23
VGA_LG2: Q8707.4 Q8708.4 U8700.20
VGA_LG3: Q8711.4 Q8712.4 U8701.7
VGA_LX1: C8706.2 L8700.1 Q8701.1 Q8701.2 Q8701.3 Q8703.5 Q8704.5 R8711.1 R8718.1 T8703.1 U8700.24
VGA_LX2: C8733.2 L8701.1 Q8705.1 Q8705.2 Q8705.3 Q8707.5 Q8708.5 R8719.1 R8723.1 T8704.1 U8700.19
VGA_LX3: C8736.2 L8702.1 Q8709.1 Q8709.2 Q8709.3 Q8711.5 Q8712.5 R8720.1 R8727.1 T8714.1 U8701.2
VGA_PSI#: R7439.2 R8706.1 R8707.1 SR8700.1 U7000.AT1
VGA_PWM: R8716.1 R8725.1 U8700.22
VGA_PWRON: R5706.1 R7419.2 SR9102.1 U7000.AW1
VGA_REFADJ: C8709.1 R8700.1 U8700.6
VGA_REFIN: C8726.1 R8702.2 R8704.2 T8700.1 U8700.7
VGA_VDD: C8727.1 R8714.1 U8700.21
VGA_VID: SR8701.1 U7000.AT9
VGA_VREF: C8725.1 R8701.1 U8700.8
VGA_VRON: C8707.1 D8700.1 R8710.2 T8702.1 U8700.3
VIDALERT#: R0708.1 R0717.2 R8013.2 R80148.2
VIDSCLK: R0747.2 R8012.2 R80149.2 U0300.BH32
VIDSOUT: R0707.2 R8014.2 R80147.2 U0300.BH29
VLDOIN: C8308.1 SR8300.2 U8300.19
VR_ENABLE: R8017.1 R80151.1 U8000.48
VR_HOT#: R8003.1 U8000.46
VREF_CA_RC: C0501.2 R0510.1
VREF_DQ: C0500.1 R0502.2 T0500.1 U0300.BP13
VRM_PWRGD: D9202.1 R2493.1 R4417.2 R9203.2 SR9206.2 T9207.1 U2402.1 U8000.47 U9201.1
VSUS_ON: D8200.2 JP9303.2 Q8106.6 R3061.2 R3064.2 R8108.1 R8110.1 R8111.2 R8201.1 T9303.1 U3001.19
VSUS_ON_EN: C8118.1 Q8106.3 R8109.1 R8110.2 SR8103.1
WAKE#: R3303.1 U3300.3
WARNING: R7438.2 R7447.2 R8738.1 U8702.8
WLAN_DISABLE#: CON5300.56 R5308.2 U2000.AB44
XCLK_BIASREF: R2512.1 U2000.E1
XDP1_JTAG_TCK: R4402.1 XDP4400.55
XDP1_PIN60: R4425.1 R4426.1 XDP4400.60
XDP_PCUDEBUG3: R4422.1 R4424.2 XDP4400.1
XTAL24_IN_NO_IO: C2503.1 R2522.2 R2524.2 Y2501.3
XTAL24_IN_R: R2522.1 U2000.A6
XTAL24_OUT_NO_IO: C2502.1 R2524.1 U2000.A5 Y2501.1
Y5_R: R2525.2 Y2500.1
ZVM_TP: T1000.1 U0300.AT13
N17740100: R8102.1 U8100.1
N17742210: R8103.1 U8100.5
N21115423: C8814.2 R8805.1 R8807.2 U8800.6
N21533547: C8310.1 R8300.2 U8300.9
N23400012: D9200.1 R9200.2 R9206.2 R9207.2 R9208.2 R9209.2 R9210.2 R9211.2 R9212.2 SR9204.2 U9200.1 U9200.2
N25316574: Q9200.5 SR9205.1 SR9206.1 U9201.4
N59712038: SR8800.2 U8800.7
N59900925: D9201.1 R9205.2
N60195343: SR8900.1 SR8902.2 SR8903.1
N60195449: C8907.1 SR8906.2 SR8910.2 T8907.1 U8900.10
N60195463: C8915.1 R8907.2 R8912.1
N60195527: C8912.1 U8900.11
N60250597: C9118.1 R9105.2 U9102.3
N60250604: C9120.1 R9106.2 U9102.5
N60250715: C9124.1 U9102.12
N60250719: C9123.1 U9102.10
N60253878: C9100.1 R9100.2 U9100.3
N60253885: C9103.1 R9112.2 U9100.5
N60253996: C9109.1 U9100.12
N60254000: C9108.1 U9100.10
N60314877: C9111.1 R9104.2 U9101.3 U9101.5
N60314934: C9117.1 U9101.12
N60315047: C9116.1 U9101.10
N60322557: C8400.2 R8401.2 R8403.1 U8400.2
N60425076: C9505.1 L9500.2 R9501.2 R9502.2 T9500.1 U9500.8 U9500.9 U9500.15 U9500.16
N60425117: C9513.1 JP9501.1 R9505.1
N60425130: C9513.2 R9502.1 R9504.2
N60425240: C9512.1 R9501.1
N60425541: C9505.2 R9500.1
N60425619: C9504.1 U9500.11
N60690738: C8708.1 R8711.2
N60690747: C8735.1 R8723.2
N60690916: C8724.1 U8700.12
N60691002: C8700.2 R8700.2 R8701.2 R8702.1
N60691151: SR8700.2 U8700.4
N60691188: SR8701.2 U8700.5
N60691282: R8712.1 U8700.9
N60691292: C8723.1 R8712.2 R8741.1
N60691324: SR8702.2 U8700.16
N60691573: R8704.1 R8705.2
N60725232: C9104.1 Q9100.1 R9102.1
N60725234: Q9101.2 SR9100.2
N60725315: Q9101.4 R9102.2 R9103.1 T9103.1
N65022721: SR8802.2 U8800.9
N65022884: C8824.1 R8811.1 R8813.2 U8800.10
N65023456: C8806.1 R8801.1
N65023505: SR8801.2 U8800.8
N65979211: Q8800.4 R8814.2
N68998160: Q8805.1 R8816.1 R8817.2
N68998162: C8827.1 Q8805.3 R8815.2 SR8807.1
N125017610: T0301.1 U0300.A33
N125017656: R0300.2 U0300.D37
N125020990: R0900.1 U0300.AF29 U0300.AF30 U0300.AF31 U0300.AF32 U0300.AF33 U0300.AF34 U0300.AG13 U0300.AG14 U0300.AG31 U0300.AG32 U0300.AG33 U0300.AG34 U0300.AG35 U0300.AG36 U0300.AH13 U0300.AH14 U0300.AH29 U0300.AH30 U0300.AH31 U0300.AH32 U0300.AJ13 U0300.AJ14
N125034509: R1000.2 U0300.BJ17 U0300.BJ19 U0300.BJ20 U0300.BK17 U0300.BK19 U0300.BK20 U0300.BL16 U0300.BL17 U0300.BL18 U0300.BL19 U0300.BL20 U0300.BL21 U0300.BM17 U0300.BN17
N125034565: R1002.2 U0300.BJ23 U0300.BJ26 U0300.BJ27 U0300.BK23 U0300.BK26 U0300.BK27 U0300.BL23 U0300.BL24 U0300.BL25 U0300.BL26 U0300.BL27 U0300.BL28 U0300.BM24
N126015045: C0503.2 R0500.2 R0501.1 R0503.1
N126015147: C0504.2 C0505.2 R0501.2 R0502.1
N126050534: R2132.2 U2000.Y44
N126050588: R2120.2 R2121.1 U2000.AC44
N126051766: R2142.1 U2000.AD38
N126053407: R2249.2 R2258.1 U2000.N44
N126053413: R2208.2 U2000.U42
N126053497: R2243.2 U2000.U35
N126053501: R2244.2 R2255.1 U2000.L44
N126053508: R2245.2 R2256.1 U2000.L43
N126053667: R2201.1 R2204.2 U2000.M45
N126061466: C2306.1 R2329.2 U2000.AY44
N126061486: R2333.2 R2347.2 U2000.BA40
N126061517: C2308.1 R2331.2 U2000.AW42
N126061523: C2309.1 R2332.2 U2000.AW45
N126061775: R2302.2 U2000.AL39
N126061781: R2303.2 U2000.AN38
N126061784: R2304.2 U2000.AN41
N126061787: R2305.2 U2000.AG44
N126071044: R2472.2 U2000.AW35
N126071761: R2429.2 U2000.AR31
N126071784: R2412.2 R2483.1 U2000.BD25
N126071872: R2445.2 U2000.BD11
N126071895: C2401.1 R2448.2 U2000.BE11
N126072312: R2406.2 R2426.1 R2499.1 U2000.AR27
N126072357: T2408.1 U2000.BC26
N126072385: T2404.1 U2000.BC15
N126072389: T2402.1 U2000.AV15
N126072391: T2401.1 U2000.BB13
N126075660: R2616.1 R2619.1 U2000.BE41 U2000.BE42 U2000.BE43
N126076532: R2617.1 U2000.BA24 U2000.W15
N126076879: C2602.1 C2603.1 C2604.1 R2615.1 U2000.AD41 U2000.AJ41 U2000.AL41 U2000.BC42 U2000.BD40
N126150154: R0302.1 U0300.G29
N126154000: R0743.2 U0300.J23
N126183850: R0734.2 U0300.BN1
N126215700: R0901.1 U0300.AH35 U0300.AH36
N126273757: R1011.2 U0300.BL14 U0300.BM14
N126273866: R1013.1 U0300.AY13
N126273877: R1013.2 U0300.AU13
N126385512: Q5704.1 R5706.2
N126462372: C1000.1 R1001.1 U0300.Y12
