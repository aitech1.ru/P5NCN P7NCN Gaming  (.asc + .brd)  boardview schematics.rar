# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_RXN_C: length 3.2
  TOP w0.114: 223.75,92.22 223.11,92.22 C3314.1 ; 223.75,92.22 v1(223.75,92.45) ; 223.75,92.22 223.84,92.22 224.27,91.79 224.9,91.79 225.06,91.96 U3300.29
LAN_RXP: length 122.7
  TOP w0.114: 220.43,90.82 220.43,90.41 v2(220.74,90.1) ; 220.43,90.82 v1(220.65,90.82) ; 220.43,90.82 220.43,91.53 220.75,91.86 221.72,91.86 221.72,91.86 222,91.58 C3313.2
  IN4 w0.089: v2(162.87,54.35) 162.59,54.62 162.59,54.85 162.41,55.03 160.05,55.03 158.8,56.28 156.71,56.28 156.07,55.63 154.79,55.63 154.2,55.03 145.26,55.03 144.83,55.46 144.83,56.89 145.29,57.36 147.48,57.36 148.08,57.96 151.33,57.96 158.54,65.17 162.1,65.17 165.3,68.37 165.3,71.62 165.79,72.1 165.79,72.79 167.36,74.37 174.27,74.37 174.7,74.8 176.56,74.8 177.66,73.69 186.66,73.69 187.38,74.41 188.7,74.41 193.8,79.52 193.99,79.7 208.83,79.7 209.51,80.38 217.39,80.38 218.62,81.6 218.62,85.59 220.83,87.8 220.83,89.02 220.28,89.57 220.28,89.69 220.4,89.81 220.62,89.81 220.74,89.92 v2(220.74,90.1)
  BOTTOM w0.114: U2000.G19 162.44,53.92 v2(162.87,54.35)
LAN_RXP_C: length 3.3
  TOP w0.114: U3300.30 224.38,91.56 ; 224.38,91.56 v1(224.38,91.31) ; 224.38,91.56 224.17,91.56 223.75,91.98 223.13,91.98 222.86,91.71 C3313.1
LAN_TXN: length 121.6
  TOP w0.114: 227.73,89.54 228.01,89.82 228.01,90.49 228.09,90.57 U3300.36 ; 227.73,89.54 v1(227.89,89.37) ; 227.73,89.54 226.07,87.88 223.06,87.88 221.86,89.07 221.86,90.65 221.76,90.76 221.54,90.76 v2(221.33,90.55)
  IN4 w0.089: v2(144.22,55.06) 144.22,57.17 145.04,57.99 147.06,57.99 147.72,58.65 151.21,58.65 158.45,65.89 161.98,65.89 164.69,68.6 164.69,72.03 165.2,72.53 165.2,73.02 167.2,75.02 173.65,75.02 174.34,75.71 181.86,75.71 182.55,75.02 187.7,75.02 192.95,80.27 208.6,80.27 209.28,80.95 210.88,80.95 211.43,81.5 212.85,81.5 213.29,81.07 216.15,81.07 217.27,82.19 217.27,87.82 220.43,90.98 220.94,90.98 221.03,90.89 221.03,90.85 v2(221.33,90.55)
  BOTTOM w0.114: C2013.1 149.25,49.07 149.16,49.07 149.06,49.17 146.23,49.17 143.94,51.45 143.94,54.78 v2(144.22,55.06)
LAN_TXP: length 121.7
  TOP w0.114: U3300.35 227.69,90.57 227.77,90.49 227.77,89.91 225.97,88.11 223.16,88.11 222.83,88.44 ; 222.83,88.44 222.1,89.17 222.1,90.75 221.85,90.99 221.5,90.99 v2(221.33,91.15) ; 222.83,88.44 v1(222.99,88.59)
  IN4 w0.089: v2(221.33,91.15) 220.36,91.15 217.09,87.89 217.09,82.26 216.08,81.24 213.36,81.24 212.93,81.68 211.35,81.68 210.81,81.13 209.21,81.13 208.52,80.45 192.88,80.45 187.62,75.2 182.63,75.2 181.94,75.89 174.27,75.89 173.58,75.2 167.13,75.2 165.02,73.09 165.02,72.61 164.52,72.1 164.52,68.67 161.9,66.06 158.37,66.06 151.13,58.82 147.64,58.82 146.99,58.17 144.97,58.17 144.04,57.25 144.04,55.77 v2(143.8,55.53)
  BOTTOM w0.114: v2(143.8,55.53) 143.8,54.97 143.71,54.88 143.71,51.36 146.13,48.93 148.96,48.93 149.06,48.83 149.3,48.83 C2012.1
LAN_WAKE#: length 132.7
  TOP w0.102: v2(207.97,36.69) 207.69,36.41 207.69,35.54 206.8,34.65 203.73,34.65 203.15,35.23 203.15,36.01 200.63,38.52 200.63,42.09 199.54,43.18 199.54,44.05 198.85,44.74 198.54,44.74 197.74,45.54 197.74,49.13 196.4,50.46 v1(195.94,50.46) 195.94,51.15 193.78,53.31 193.78,57.64 193.01,58.41 191.84,58.41 v2(191.41,58.84) ; v2(236.29,88.27) 236.27,88.29 R3303.2
  IN2 w0.102: v2(236.29,88.27) 236.29,90.4 235.5,91.18 234.04,91.18 233.73,91.49 230.61,91.49 227.95,88.83 227.95,87.39 227.39,86.83 218.45,86.83 217.85,86.23 216.01,86.23 213.1,83.31 213.1,80.21 213.45,79.86 213.45,68.6 217.21,64.84 217.21,62.16 215.16,60.11 215.16,57.62 216.06,56.72 216.06,56.16 214.32,54.42 214.32,51.82 212.5,50 212.5,48.87 211.22,47.58 211.22,46.48 210.79,46.06 210.79,42.51 207.97,39.69 v2(207.97,36.69)
  BOTTOM w0.089: U2000.BC13 180.75,57.36 181.14,57.36 181.19,57.3 181.96,57.3 182.16,57.5 182.64,57.5 184.11,58.97 184.11,59.49 184.33,59.7 184.71,59.7
  BOTTOM w0.102: 184.71,59.7 187.58,59.7 R2446.2 188.26,59.53 R2443.2 190.75,59.04 190.96,58.84 v2(191.41,58.84)
LCD_BKLTEN_EC: length 281.9
  TOP w0.102: v2(29.95,181.22) 30.28,181.55 30.28,184.08 30.5,184.3 35.44,184.3 36.19,183.55 36.19,182.74 36.46,182.47 D4503.2 37.23,183.48 v1(36.76,183.95) 36.8,183.99 R4593.2 ; v2(122.27,39.43) 122.27,39.45 122.53,39.72 125.51,39.72 125.67,39.55 U3001.118
  IN2 w0.102: v2(122.27,39.43) 121.71,38.87 115.99,38.87 115.03,37.91 111.86,37.91 111.18,38.6 58.62,38.6 57.73,39.49 55.11,39.49 54.68,39.07 43.13,39.07 39.19,43.01 37.14,43.01 29.57,50.58 29.57,54.72 25.76,58.53 25.76,60.4 22.54,63.62 20.31,63.62 19.8,64.13 13.26,64.13 8.94,68.45 8.23,68.45 7.75,68.93 7.75,73.26 10.03,75.54 10.03,86.45 9.93,86.56 9.93,89.09 8.93,90.09 8.93,99.58 9.27,99.93 9.27,119.36 8.51,120.13 8.51,123.3 7.75,124.06 7.75,125.02 8.53,125.81 8.53,142.5 9.6,143.57 9.6,162.03 11.82,164.25 13.1,164.25 15.09,166.25 15.09,173.29 14.1,174.28 14.1,174.98 15.13,176.01 15.77,176.01 16.87,177.11 16.87,177.49 19.28,179.9 23.06,179.9 24.27,181.1 29.83,181.1 v2(29.95,181.22)
LED2_1PIN: length 13.8
  TOP w0.254: v1(200.58,175.99) 199.55,175.99 PR703.1 199.51,176.68 v2(199.27,176.92)
  IN1 w0.254: v2(199.27,176.92) 199.31,176.88 206.81,176.88 v2(209.11,179.18)
  BOTTOM w0.254: PLED702.1 v2(209.11,179.18)
LED_1PIN: length 12.8
  TOP w0.254: v2(178.99,174.74) 179.23,174.97 v1(179.76,174.97) 179.88,174.85 PR701.1
  BOTTOM w0.254: PLED701.1 173.01,176.72 174.99,174.74 v2(178.99,174.74)
LED_2PIN: length 46
  TOP w0.127: v2(200.43,174.94) PQ700.3 v1(202.09,173.81)
  BOTTOM w0.254: PLED702.2 200.62,174.75 v2(200.43,174.94) 200.43,182.67 199.03,184.07 PLED701.2
LFRAME#_ESPI_CS0#: length 10.1
  BOTTOM w0.089: 184.71,57.67 184.32,57.67 183.45,56.8 183.45,56.03 182.87,55.46 U2000.BE16
  BOTTOM w0.114: v1(189.6,57.59) 189.24,57.59 188.99,57.84 188.03,57.84 187.83,57.65 R2223.2 187.68,57.42 187.44,57.67 184.71,57.67
LG_C: length 16.5
  BOTTOM w0.508: v1(80.82,163.49) 81.59,164.25 Q8001.4 81.02,165.09 79.78,163.85 76.84,163.85 76.15,164.53 71.83,164.53 71.17,165.2 71.17,168.29
LGF_LED_ON: length 298.9
  TOP w0.102: R3084.2 133.91,31.74 134.18,32.02 v2(134.29,32.02)
  IN2 w0.102: v2(49.45,182.85) 49,182.39 47.58,182.39 47.35,182.63 40.28,182.63 39.14,181.49 39.14,181.34 37.14,179.34 35.72,179.34 34.4,178.03 32.2,178.03 31.82,177.65 27.08,177.65 25.46,176.03 25.46,175.6 22.88,173.02 22.18,173.02 21.56,172.41 21.56,168.19 23.22,166.54 23.22,165.36 21.9,164.05 21.9,157.22 16.84,152.16 16.84,148.86 16.36,148.38 16.01,148.38 15.57,147.94 15.57,147.51 15.14,147.08 15.14,146.19 14.16,145.21 14.16,143.67 14.48,143.35 14.48,140.97 14.13,140.62 14.13,138.11 12.46,136.44 12.46,133.29 14.2,131.55 14.2,125.3 12.85,123.95 12.85,118.7 18.44,113.11 18.44,89.74 26.64,81.54 26.64,70.39 29.14,67.89 29.14,62.3 29.21,62.23 29.21,60.74 33.74,56.21 35.18,56.21 39.65,51.74 40.74,51.74 45.68,46.8 47.67,46.8 49.16,45.31 67.19,45.31 68,44.49 72.11,44.49 v2(72.63,43.97) ; v2(134.29,32.02) 134.29,32.13 133.79,32.63 123.17,32.63 121.82,31.28 120.19,31.28 118.77,32.71 115.52,32.71 114.78,33.44 114.78,33.87 114.48,34.18 113.64,34.18 113.59,34.13 98.16,34.13 97.45,34.84 76.42,34.84 75.76,35.5 70.58,35.5 v2(69.77,34.69)
  BOTTOM w0.102: v2(49.45,182.85) 49.33,182.73 49.33,180.88 48.56,180.1 48.56,178.55 49.07,178.04 49.07,175.98 47.39,174.3 Q4501.1 ; v2(69.77,34.69) 73.72,38.64 v1(73.72,42.25) 73.72,42.88 v2(72.63,43.97)
LGF_LED_ON#: length 16.2
  TOP w0.102: CON4500.36 52.75,182.13 52.86,182.25 v2(52.86,182.28)
  BOTTOM w0.102: v2(52.86,182.28) 52.87,182.27 52.87,181.7 52.74,181.58 51.74,181.58 51.36,181.2 51.36,176.55 52.06,175.85 52.06,173.16 v1(50.88,171.98) 50.06,171.16 Q4501.3
LID_SW#: length 248.3
  TOP w0.102: D4502.2 42.74,180.83 v2(41.68,179.77) 42.01,179.44 R4592.2 43.02,178.66 v1(43.08,178.72) ; U3001.17 v2(118.72,44.05)
  IN2 w0.102: v2(41.68,179.77) 40.61,179.77 39.91,179.08 39.61,179.08 38.65,178.11 36.27,178.11 34.95,176.8 32.7,176.8 32.33,176.42 27.59,176.42 26.69,175.52 26.69,172.27 23.95,169.53 23.95,167.55 24.57,166.92 24.57,157.9 18.21,151.54 18.21,150.29 18.64,149.86 18.64,147.65 17.61,146.62 17.61,146.27 18.22,145.66 18.22,143.65 18.5,143.38 18.5,137.65 18.04,137.19 18.04,132.96 15.56,130.48 15.56,124.48 17.02,123.02 17.02,122.27 19.66,119.63 19.66,90.25 27.9,82.01 27.9,70.86 30.36,68.4 30.36,66.64 34.61,62.39 34.61,61.83 35.24,61.21 35.24,58.06 40.21,53.08 46.66,53.08 47.76,51.99 47.76,50.51 50.86,47.41 53.74,47.41 54.3,47.97 60.88,47.97 61.7,47.15 64.89,47.15 64.91,47.17 71.86,47.17 73.56,45.47 100.3,45.47 102.01,43.76 109.86,43.76 110.73,42.89 115.22,42.89 116.83,44.5 118.27,44.5 v2(118.72,44.05)
  BOTTOM w0.102: CON5602.25 41.75,178.83 41.89,178.97 41.89,179.56 v2(41.68,179.77)
LID_SW#_IO: length 39.8
  TOP w0.114: v2(210,172.02) PR702.1 PD702.1 v2(210,174.3) ; v1(183.44,174.97) v2(183.44,175.99) 183.2,176.23 CON402.25
  IN1 w0.102: v2(210,172.02) 208.37,173.64 185.79,173.64 v2(183.44,175.99)
  BOTTOM w0.114: v2(210,174.3) 210,175.62 208.3,177.32 PU701.2
LINE1_JD#: length 13.9
  TOP w0.203: v2(20.12,75.45) 20.17,75.4 R3624.2
  TOP w0.254: v1(10.69,71.59) 10.69,72.31 v2(10.69,72.31)
  IN4 w0.203: v2(10.69,72.31) 11.67,72.31 12.45,73.09 14.12,73.09 15.19,74.16 15.19,74.84 16.26,75.91 18.64,75.91 19.1,75.45 v2(20.12,75.45)
  BOTTOM w0.203: v2(10.69,72.31) 10.63,72.25 CON6700.22
LINE1_L: length 11
  TOP w0.203: C3639.2 16.71,77.71 v2(16.69,77.74)
  IN1 w0.254: v2(16.69,77.74) 16.69,76.85 14.63,74.79 v2(14.63,71.26)
  BOTTOM w0.203: R6737.2 14.27,70.67 14.27,70.89 v2(14.63,71.26) 14.72,71.35 v1(14.72,71.9) L6701.1
LINE1_R: length 14.1
  TOP w0.203: C3640.2 18.11,77.44 17.84,77.7 v2(17.32,77.7)
  IN1 w0.254: v2(17.32,77.7) 17.32,76.85 15.01,74.54 15.01,72.11 15.23,71.9 v2(15.23,71.12)
  BOTTOM w0.203: L6700.1 14.32,73.29 14.66,73.63 v1(15.24,73.63) 15.28,73.59 15.28,71.17 v2(15.23,71.12) 14.91,70.81 R6738.2
LINE1_VREFO_L: length 5.2
  TOP w0.203: v2(13.26,69.48) 14.05,69.48 14.23,69.31 U3600.31
  BOTTOM w0.203: R6737.1 13.64,69.56 13.56,69.48 v2(13.26,69.48) 13.26,69.3 v1(12.61,68.65)
LINE1_VREFO_R: length 3.5
  TOP w0.203: U3600.30 15.83,69.71 v2(15.67,69.86)
  BOTTOM w0.203: R6738.1 15.21,69.86 v2(15.67,69.86)
  BOTTOM w0.254: v2(15.67,69.86) 15.67,70.03 16.21,70.56 v1(16.21,71.37)
LP9+: length 9.7
  TOP w0.089: v2(54.64,182.89) 54.6,182.85 54.6,182.03 54.75,181.89 CON4500.32
  BOTTOM w0.114: v2(54.64,182.89) 54.64,182.86 54.23,182.44 54.23,181.87 53.72,181.36 53.72,181.03 U4501.3 53.72,180.55 53.72,179.66 54.45,178.94 54.45,176.4 54.68,176.17 RN4500.2
LP9-: length 9.7
  TOP w0.089: CON4500.33 54.25,181.88 54.39,182.03 54.39,182.43 v2(53.93,182.89)
  BOTTOM w0.114: v2(53.93,182.89) 53.99,182.83 53.99,181.97 53.48,181.46 53.48,179.56 54.2,178.85 54.2,178.13 U4501.4 54.21,177.64 54.21,176.43 53.88,176.1 RN4500.4
LPC_AD0: length 238.4
  TOP w0.114: R3016.1 122.68,51.6 122.68,51.98 122.94,52.24 123.97,52.24 v2(124.38,51.83) ; v2(192.58,53.86) 192.17,53.45 191.78,53.45 191.61,53.62 190.2,53.62 189.84,53.25 189.13,53.25 188.86,53.52 187.21,53.52 186.97,53.76 186.72,53.76 186.62,53.86 R2219.1 ; v2(186.23,25.82) 186.72,25.34 U6200.26
  IN1 w0.076: v2(192.58,53.86) 192.01,53.29 192.01,51.44 191.44,50.87 191.44,41.88 191.12,41.56 191.12,30.66 190.23,29.77 190.23,27.98 188.08,25.82 v2(186.23,25.82)
  IN4 w0.076: v2(186.23,25.82) 186.23,26.12 184.82,27.54 177.3,27.54 176.72,26.96 166.4,26.96 166.14,27.21 156.96,27.21 154.59,29.57 135.19,29.57 134.47,30.29 128.49,30.29 123.82,34.96 106.94,34.96 106.16,35.74 93.16,35.74 92.27,34.85 77.54,34.85 76.9,35.49 72.26,35.49 v2(71.86,35.09)
  BOTTOM w0.114: CON4400.11 70.13,31.16 71.31,32.34 71.31,34.54 v2(71.86,35.09) 72.87,36.1 75.8,36.1 78.51,33.4 98.06,33.4 98.75,34.09 98.75,36.08 100.36,37.69 100.36,40.84 101.14,41.62 101.14,43.53 v1(101.91,44.29) 103.81,46.19 104.4,46.19 111.44,53.23 122.98,53.23 v2(124.38,51.83)
LPC_AD1: length 228.6
  TOP w0.114: R3015.1 123.06,51.78 v2(123.11,51.83) ; R2220.1 188.92,53.76 189.09,53.76 189.36,53.49 189.74,53.49 190.1,53.86 v2(191.95,53.86) ; U6200.23 184.77,25.68 v2(184.91,25.82)
  IN1 w0.076: v2(191.95,53.86) 191.95,53.57 191.81,53.43 191.81,51.54 191.57,51.3 191.57,51.28 191.24,50.95 191.24,42.05 190.92,41.74 190.92,30.75 190.03,29.86 190.03,28.06 188.22,26.26 185.34,26.26 v2(184.91,25.82)
  IN4 w0.076: v2(71.88,34.43) 72.74,35.29 76.81,35.29 77.46,34.65 92.36,34.65 92.55,34.84 99.21,34.84 99.29,34.76 123.74,34.76 128.41,30.09 134.38,30.09 135.1,29.37 154.51,29.37 156.87,27.01 166.01,27.01 166.27,26.75 176.81,26.75 177.39,27.34 183.4,27.34 v2(184.91,25.82)
  BOTTOM w0.114: CON4400.9 71.13,31.53 71.55,31.95 71.55,34.1 v2(71.88,34.43) 73.31,35.86 75.7,35.86 78.41,33.16 98.16,33.16 98.99,33.99 98.99,35.98 100.6,37.59 100.6,40.58 101.52,41.5 101.52,42.89 v1(103.68,45.05) 103.68,45.14 111.54,52.99 121.95,52.99 v2(123.11,51.83)
LPC_AD2: length 234.4
  TOP w0.114: v2(181.5,25.94) 181.5,24.87 182.82,23.55 U6200.20 ; v2(123.75,51.83) 123.95,51.63 R3014.1 ; v2(192.58,54.75) 192.15,55.19 189.31,55.19 189.05,54.93 186.23,54.93 R2221.1
  IN1 w0.076: v2(181.5,25.94) 182.01,25.43 187.97,25.43 190.44,27.89 190.44,29.69 191.33,30.58 191.33,41.38 193.03,43.08 193.03,46.51 192.6,46.94 192.6,51.59 192.21,51.97 192.21,52.94 192.98,53.7 192.98,54.36 v2(192.58,54.75)
  IN4 w0.076: v2(73.1,34.9) 73.76,34.24 92.52,34.24 92.71,34.43 99.05,34.43 99.53,33.95 113.34,33.95 113.91,33.38 118.34,33.38 119.31,34.34 123.58,34.34 128.24,29.68 134.21,29.68 134.93,28.96 154.34,28.96 156.7,26.6 165.8,26.6 166.05,26.35 176.97,26.35 177.56,26.93 180.52,26.93 v2(181.5,25.94)
  BOTTOM w0.114: v2(123.75,51.83) 123.34,51.42 122.94,51.42 122.7,51.66 122.7,51.84 121.79,52.75 111.64,52.75 105.66,46.78 105.66,46.02 v1(102.03,42.38) 101.98,42.34 101.98,41.45 100.84,40.31 100.84,37.49 99.24,35.88 99.24,33.89 98.26,32.91 78.31,32.91 75.69,35.53 73.73,35.53 v2(73.1,34.9) 72.13,33.93 CON4400.7
LPC_AD3: length 240.8
  TOP w0.114: U6200.17 180.87,23.74 180.24,24.37 v2(180.24,25.73) ; v2(122.12,51.83) 122.78,52.49 124.31,52.49 124.8,52 124.8,51.69 124.78,51.67 R3020.1
  IN1 w0.076: v2(180.24,25.73) 180.78,25.19 192.25,25.19 192.49,25.43 192.49,25.76 191.05,27.21 191.05,29.42 191.94,30.31 191.94,41.06 193.64,42.76 193.64,46.76 193.21,47.19 193.21,51.84 192.82,52.22 192.82,52.68 193.59,53.45 193.59,55.7 192.51,56.78 191.57,56.78 190.64,57.71 187.27,57.71 v2(186.61,57.05)
  IN4 w0.076: v2(73.06,34.23) 73.25,34.04 92.61,34.04 92.8,34.23 98.96,34.23 99.44,33.75 113.26,33.75 113.93,33.08 118.33,33.08 119.39,34.14 123.5,34.14 128.16,29.48 134.13,29.48 134.85,28.76 154.25,28.76 156.62,26.4 165.7,26.4 165.95,26.14 177.06,26.14 177.64,26.73 179.25,26.73 v2(180.24,25.73)
  BOTTOM w0.114: R2222.1 186.55,57.11 v2(186.61,57.05) ; v2(122.12,51.83) 121.44,52.51 111.74,52.51 105.91,46.68 105.91,45.37 v1(103.81,43.27) 102.41,41.88 102.41,41.17 101.09,39.84 101.09,37.39 99.48,35.78 99.48,33.79 98.36,32.67 78.21,32.67 75.64,35.24 74.34,35.24 73.33,34.23 v2(73.06,34.23) 73.06,32.3 73.13,32.23 CON4400.5
LPC_FRAME#: length 229.1
  TOP w0.114: v2(121.49,51.83) 122.38,52.73 124.41,52.73 125.04,52.1 125.04,51.72 R3018.1 ; v2(182.72,25.92) 182.72,25.07 184.12,23.67 U6200.22
  IN1 w0.076: v2(187.25,57.04) 187.72,57.51 190.16,57.51 191.06,56.61 191.06,51.91 190.97,51.82 190.97,51.49 191.06,51.4 191.06,51.06 191.03,51.04 191.03,42.14 190.72,41.82 190.72,30.83 189.83,29.94 189.83,28.2 188.09,26.46 184.68,26.46 184.15,25.92 v2(182.72,25.92)
  IN4 w0.076: v2(182.72,25.92) 182.72,26.19 181.78,27.13 177.47,27.13 176.89,26.55 166.15,26.55 165.9,26.8 156.79,26.8 154.42,29.17 135.02,29.17 134.3,29.89 128.32,29.89 123.65,34.56 99.21,34.56 99.13,34.64 92.63,34.64 92.44,34.44 75.73,34.44 v2(75.4,34.78)
  BOTTOM w0.114: v2(187.25,57.04) 187.31,56.97 188.58,56.97 188.7,57.09 R2223.1 ; CON4400.3 74.13,33.51 v2(75.4,34.78) 77.75,32.43 98.46,32.43 99.72,33.69 99.72,35.68 101.33,37.29 101.33,39.27 v1(102.03,39.97) 106.15,44.09 106.15,46.58 111.84,52.27 121.05,52.27 v2(121.49,51.83)
LPCPD#: length 43
  TOP w0.114: v1(188.29,20.16) 188.02,20.43 U6200.28 188.02,23.47 188.76,24.22 190.72,24.22 v2(192.1,25.6)
  IN1 w0.076: v2(192.1,25.6) 190.84,26.85 190.84,29.52 191.73,30.41 191.73,41.21 193.43,42.91 193.43,46.68 193,47.11 193,51.76 192.62,52.14 192.62,52.77 193.38,53.53 193.38,55.35 v2(192.71,56.02)
  BOTTOM w0.114: v2(192.71,56.02) 192.26,55.57 191.9,55.57 191.58,55.89 R2226.1
M2_SSD_PEDET: length 146.1
  TOP w0.102: v2(168.95,31.34) 169.53,31.92 170.76,31.92 171.29,32.44 171.29,33.68 R2110.1 170.45,34.52 170.45,36.35 R2105.2 170.87,38.73 172.1,39.96 172.1,40.64 v1(172.65,41.19) 172.85,41.4 172.85,44.33 173.26,44.73 173.26,45.24 v2(172.84,45.66) ; v2(59.5,33.84) 59.5,33.26 57.29,31.05 56.73,31.05 55.1,29.41 55.1,27.21 R5115.2
  IN1 w0.102: v2(59.5,33.84) 59.5,33.84 59.86,34.2 67.49,34.2 68.48,33.21 82.04,33.21 85.14,36.31 105.79,36.31 110.72,31.39 116.1,31.39 117.56,29.93 129.92,29.93 130.77,30.78 151.41,30.78 152.18,31.54 163.97,31.54 164.3,31.21 165.75,31.21 165.95,31.02 168.34,31.02 168.66,31.34 v2(168.95,31.34)
  BOTTOM w0.089: U2000.AG36 v2(172.84,45.66)
  BOTTOM w0.102: v2(59.5,33.84) 59.65,34 59.65,35.25 59.55,35.35 CON5102.69
M_CHA_ACT#: length 79.6
  TOP w0.222: CON1600.114 61.88,76.19 61,75.32 61,74.51 60.19,73.7 59.36,73.7 58.8,73.15 58.8,72.66 59.16,72.3 v2(59.37,72.3)
  IN1 w0.152: v2(59.37,72.3) 59.3,72.3 58.87,72.73 58.87,73.14 59.59,73.87 59.59,74.66 55.87,78.38 55.87,79.99 40.92,94.94 40.92,95.99 38.89,98.02 37.84,98.02 36.93,98.93 36.93,98.93 32.46,103.4 32.46,119.22 33.53,120.29 33.53,122.21 v6(33.99,122.67)
  BOTTOM w0.076: v6(33.99,122.67) 33.86,122.55 v1(32.99,122.55) 32.99,123.08 34.37,124.46 34.37,125.67 34.89,126.19 U0300.AU3
  BOTTOM w0.222: v2(59.37,72.3) 59.37,70.83 59.88,70.32 CON1601.114
M_CHA_ALERT#: length 76.8
  TOP w0.178: v2(61.22,72.56) 61.22,73.05 61.7,73.53 61.7,75.4 62.38,76.08 CON1600.116 ; v6(34.48,127.37) 34.48,127.49 v1(34.06,127.91)
  IN1 w0.121: v2(61.22,72.56) 61.13,72.65 61.13,75.29 57.82,78.6 57.82,81.39 42.77,96.44 42.77,96.76 34.48,105.05 34.48,114.48 34.04,114.92 34.04,119.47 34.87,120.3 34.87,126.98 v6(34.48,127.37)
  BOTTOM w0.076: U0300.AU5 34.75,127.55 34.66,127.55 v6(34.48,127.37)
  BOTTOM w0.178: v2(61.22,72.56) 60.38,71.71 CON1601.116
M_CHA_BA0: length 84.3
  TOP w0.222: CON1600.150 72.88,76.32 72.44,75.88 72.11,75.88 70.91,74.69 v2(70.91,72.99) ; v1(41.25,127.25) 41.45,127.25 v6(41.97,126.72)
  IN1 w0.076: 45.36,115.2 45.36,116.24 42.22,119.39 42.22,120.95 42.4,121.14 42.4,124.64 42.23,124.82 41.62,124.82 41.53,124.91 41.53,125.31 41.58,125.37 42.52,125.37 42.82,125.67 42.82,126.23 42.9,126.31 43.1,126.31 43.15,126.36 43.15,126.61 43.06,126.71 42.49,126.71 42.39,126.61 42.39,125.87 42.34,125.82 41.63,125.82 41.53,125.93 41.53,126.1 41.61,126.18 41.92,126.18 41.97,126.23 v6(41.97,126.72)
  IN1 w0.152: v2(70.91,72.99) 71.21,73.29 71.21,76.66 71.01,76.86 71.01,81.44 70.6,81.85 70.6,84.24 67.5,87.33 66.71,87.33 48.79,105.26 48.79,106.42 45.36,109.85 45.36,115.2
  BOTTOM w0.076: U0300.AH5 41.97,127.23 v6(41.97,126.72)
  BOTTOM w0.222: v2(70.91,72.99) 71.17,72.99 71.48,72.68 71.48,72.13 70.49,71.13 70.49,70.45 70.88,70.06 CON1601.150
M_CHA_BA1: length 80.4
  TOP w0.222: CON1600.145 71.63,69.94 70.92,70.65 70.92,71.17 69.78,72.31 69.78,73.63 v2(69.67,73.74)
  IN1 w0.152: v2(69.67,73.74) 69.89,73.74 69.89,73.74 70.08,73.74 70.22,73.88 70.22,76.25 70.02,76.45 70.02,81.03 69.3,81.74 69.3,82.28 69.61,82.58 69.61,83.82 69.47,83.96 69.19,83.96 69.09,84.07 69.09,84.35 68.51,84.93 67.72,84.93 67.51,85.13 67.51,85.31 67.74,85.54 67.74,85.69 67.56,85.87 67.34,85.87 67.13,85.67 66.98,85.67 47.8,104.85 47.8,106.01 44.37,109.44 44.37,116.6 41.83,119.13 v6(41.83,122.02)
  BOTTOM w0.076: U0300.AH1 42.43,125.35 42.49,125.41 42.77,125.41 42.85,125.34 42.85,124.58 42.8,124.53 42.49,124.53 42.43,124.46 42.43,124.27 42.48,124.22 42.67,124.22 42.72,124.17 42.72,123.98 42.67,123.93 42.51,123.93 42.43,123.85 42.43,123.65 42.49,123.59 42.67,123.59 42.72,123.54 42.72,123.32 42.67,123.27 42.51,123.27 42.43,123.19 42.43,123.01 42.49,122.95 42.67,122.95 42.75,122.87 42.75,122.67 42.67,122.6 42.29,122.6 42.22,122.52 42.22,122.34 42.27,122.29 42.52,122.29 42.6,122.21 42.6,122.04 42.52,121.96 42.34,121.96 42.26,121.88 42.26,121.44 42.17,121.34 v1(42.05,121.34) 41.93,121.34 41.52,121.75 41.52,121.95 41.59,122.02 v6(41.83,122.02)
  BOTTOM w0.222: CON1601.145 69.63,76.43 70.25,75.81 70.25,74.12 69.87,73.74 v2(69.67,73.74)
M_CHA_BG0: length 79.7
  TOP w0.222: v2(59.37,72.94) 59.74,72.94 59.99,72.68 59.99,71.6 60.66,70.93 61.58,70.93 62.13,70.39 CON1600.115
  IN1 w0.152: v6(33.99,122.06) 33.99,120.3 32.96,119.28 32.96,113.89 33.42,113.43 33.42,111.32 32.96,110.86 32.96,103.6 35.63,100.93 35.83,100.93 36.15,101.25 36.36,101.25 36.5,101.11 36.5,100.9 36.18,100.58 36.18,100.38 36.33,100.23 36.53,100.23 36.85,100.55 37.06,100.55 37.2,100.41 37.2,100.2 36.88,99.88 36.88,99.67 37.03,99.53 37.23,99.53 37.55,99.85 37.76,99.85 41.48,96.13 41.48,95.08 55.95,80.61 56.47,80.61 56.78,80.3 56.78,78.17 60.09,74.86 60.09,72.7 59.95,72.56 59.74,72.56 v2(59.37,72.94)
  BOTTOM w0.076: v1(34.85,122.9) 34.89,122.94 U0300.AU1
  BOTTOM w0.222: CON1601.115 60.13,76.09 59.37,75.33 v2(59.37,72.94) ; v1(34.85,122.9) 34.01,122.06 v6(33.99,122.06)
M_CHA_BG1: length 79.5
  TOP w0.222: v2(58.57,71.84) 58.81,71.84 59.11,71.54 59.43,71.54 60.42,70.55 61.16,70.55 61.63,70.09 CON1600.113
  IN1 w0.152: v2(58.57,71.84) 58.57,72.33 58.37,72.53 58.37,73.35 58.66,73.64 59.1,74.07 59.1,74.45 55.38,78.18 55.38,79.78 40.31,94.85 40.31,95.85 40.01,96.16 39.79,96.16 39.5,95.86 39.29,95.86 39.15,96.01 39.15,96.21 39.47,96.53 39.47,96.74 39.32,96.88 39.12,96.88 38.8,96.56 38.59,96.56 31.97,103.19 31.97,119.22 33.22,120.48 33.22,122.75 33.81,123.33 v7(33.99,123.33)
  BOTTOM w0.076: U0300.AU2 34.57,125.42 34.57,124.36 33.99,123.78 v7(33.99,123.33)
  BOTTOM w0.222: v2(58.57,71.84) 58.78,72.04 58.78,75.29 59.63,76.14 CON1601.113
M_CHA_CKE0: length 78.8
  TOP w0.178: CON1600.109 60.63,70.04 60.49,70.18 60.03,70.18 59.21,71 58.77,71 v2(58.57,71.2) ; v6(36.04,124.58) 36.04,124.58 v1(35.33,124.58)
  IN1 w0.121: v2(58.57,71.2) 58.3,71.2 58.09,71.41 58.09,72.13 57.89,72.33 57.89,73.55 58.16,73.81 58.16,74.71 54.9,77.98 54.9,79.58 53.28,81.2 53,81.2 52.61,81.59 52.61,81.87 31.49,102.99 31.49,119.36 32.35,120.23 32.35,120.4 32.33,120.42 32.33,120.59 32.46,120.72 32.63,120.72 32.65,120.7 32.83,120.7 32.94,120.82 32.94,123.3 33.73,124.09 33.73,127.17 34.32,127.76 34.77,127.76 35.24,127.29 35.24,125.38 v6(36.04,124.58)
  BOTTOM w0.076: v6(36.04,124.58) 36.04,124.67 U0300.AT1
M_CHA_CKE1: length 78.1
  TOP w0.178: v2(56.96,73.94) 57.76,73.94 58.75,74.92 59.89,74.92 60.88,75.91 CON1600.110
  IN1 w0.121: v6(36.08,125.41) 35.45,126.04 35.45,127.38 34.85,127.97 34.23,127.97 33.52,127.26 33.52,124.17 32.61,123.27 32.61,121.48 31.06,119.93 31.06,102.82 51.28,82.6 51.28,80.99 52.29,79.98 53.9,79.98 54.47,79.41 54.47,77.8 57.58,74.69 57.58,74.26 57.26,73.94 v2(56.96,73.94)
  BOTTOM w0.076: v6(36.08,125.41) 35.95,125.41 U0300.AT2
M_CHA_CKE2: length 77.1
  IN1 w0.121: v2(56.96,74.55) 56.54,74.55 55.93,75.15 55.93,75.74 50.86,80.81 50.86,82.42 30.64,102.64 30.64,120.21 31.22,120.8 31.22,120.97 31.14,121.05 31.14,121.22 31.27,121.35 31.44,121.35 31.52,121.27 31.69,121.27 32.3,121.87 32.3,123.25 33.31,124.26 33.31,127.35 34.15,128.18 34.94,128.18 35.66,127.46 35.66,126.51 v6(36.09,126.08)
  BOTTOM w0.076: U0300.AT3 35.78,126.39 v6(36.09,126.08)
  BOTTOM w0.178: CON1601.109 58.63,76.17 58.23,75.78 58.23,73.92 58.12,73.8 57.71,73.8 57.63,73.88 57.63,74.94 57.51,75.07 57.12,75.07 56.96,74.9 v2(56.96,74.55)
M_CHA_CKE3: length 76
  IN1 w0.121: v2(56.96,73.32) 55.48,74.8 55.48,75.59 50.43,80.64 50.43,82.24 30.21,102.46 30.21,121.54 32.87,124.2 32.87,127.2 34.06,128.39 35.03,128.39 v6(36.05,127.37)
  BOTTOM w0.076: U0300.AT5 35.73,127.69 v6(36.05,127.37)
  BOTTOM w0.178: v2(56.96,73.32) 56.96,73.31 56.97,73.32 57.33,73.32 57.91,72.74 57.91,71.19 58.88,70.23 CON1601.110
M_CHA_CLK0: length 83.3
  TOP w0.114: CON1600.137 67.63,70.24 67.45,70.41 67.45,73.1 v2(67.87,73.52)
  IN1 w0.083: v7(39.08,118.01) 39.35,117.74 39.5,117.74 39.72,117.52 39.72,116.49 40.18,116.04 40.18,108.17 42.26,106.08 42.26,105.53 64.48,83.32 64.48,82.19 66.15,80.52 66.15,78.33 66.96,77.51 66.96,73.73 66.75,73.51 66.75,71.87 66.32,71.45 65.1,71.45 64.97,71.32 64.97,70.33 65.1,70.2 67.28,70.2 67.35,70.28 67.35,71.71 67.27,71.8 67.27,73.24 67.41,73.38 67.72,73.38 v2(67.87,73.52)
  BOTTOM w0.076: 42.81,121.68 42.81,122.18 42.91,122.28 42.91,124.17 43.51,124.77 43.51,125.23 43.41,125.33 43.23,125.33 43.17,125.26 U0300.AG1
  BOTTOM w0.114: 42.81,121.68 42.81,118.84 42.13,118.15 40.14,118.15 39.73,117.74 39.4,117.74 39.31,117.83 39.26,117.83 v7(39.08,118.01)
M_CHA_CLK0#: length 83.3
  TOP w0.114: v2(67.87,72.91) 67.71,72.75 67.71,70.52 68.13,70.11 CON1600.139
  IN1 w0.083: v2(67.87,72.91) 67.58,73.21 67.48,73.21 67.44,73.17 67.44,71.87 67.52,71.78 67.52,70.21 67.35,70.03 65.02,70.03 64.8,70.26 64.8,71.39 65.02,71.62 66.25,71.62 66.58,71.94 66.58,73.58 66.79,73.8 66.79,77.44 65.98,78.26 65.98,80.44 64.3,82.12 64.3,83.24 42.09,105.46 42.09,106.01 40.01,108.1 40.01,115.97 39.55,116.42 39.55,117.45 39.43,117.57 39.31,117.57 v2(39.06,117.32)
  BOTTOM w0.076: U0300.AG2 43.17,125.6 43.27,125.49 43.48,125.49 43.68,125.3 43.68,124.7 43.08,124.1 43.08,122.21 43.07,122.21 43.07,121.68
  BOTTOM w0.114: 43.07,121.68 43.07,118.73 42.23,117.89 40.25,117.89 39.83,117.47 39.21,117.47 v2(39.06,117.32)
M_CHA_CLK1: length 87.1
  TOP w0.114: CON1600.138 67.88,76.37 67.24,75.74 67.24,74.82 v2(67.89,74.18)
  IN1 w0.083: v2(67.89,74.18) 67.87,74.18 67.45,74.6 67.45,78.03 67.21,78.28 66.89,78.28 66.64,78.53 66.64,79.05 66.82,79.23 67.06,79.23 67.14,79.31 67.14,79.64 67.06,79.72 66.82,79.72 66.64,79.9 66.64,80.72 65.92,81.44 65.92,82 66.22,82.3 66.22,82.62 66.1,82.75 65.98,82.75 65.58,82.35 65.32,82.35 65.04,82.63 65.04,83.45 52.51,95.97 52.51,96.53 52.21,96.83 51.65,96.83 51.25,97.24 51.25,97.79 50.94,98.09 50.39,98.09 49.98,98.5 49.98,99.05 49.68,99.36 49.12,99.36 48.72,99.76 48.72,100.32 48.42,100.62 47.86,100.62 47.46,101.03 47.46,101.58 47.15,101.88 46.6,101.88 46.14,102.34 46.14,102.62 45.69,103.07 45.41,103.07 44.95,103.53 44.95,103.82 44.53,104.24 44.24,104.24 43.73,104.75 43.73,105.04 43.31,105.46 43.02,105.46 42.75,105.73 42.75,106.29 41.26,107.78 41.26,110.76 41.13,110.9 40.9,110.9 40.67,111.13 40.67,111.61 40.85,111.8 41.77,111.8 41.86,111.88 41.86,112.2 41.77,112.29 40.94,112.29 40.75,112.47 40.75,112.94 40.94,113.12 41.77,113.12 41.86,113.2 41.86,113.52 41.77,113.61 40.9,113.61 40.72,113.79 40.72,114.26 40.9,114.44 41.77,114.44 41.86,114.52 41.86,114.85 41.77,114.93 40.9,114.93 40.72,115.11 40.72,115.58 40.9,115.76 41.77,115.76 41.86,115.84 41.86,116.76 41.73,116.88 41.22,116.88 41.1,116.76 41.1,116.58 40.93,116.41 40.33,116.41 40.04,116.7 40.04,117.65 40.27,117.88 40.27,118.68 40.05,118.89 39.51,118.89 v2(39.08,119.32)
  BOTTOM w0.076: U0300.AK2 41.02,125.37 41.02,121.72
  BOTTOM w0.114: v2(39.08,119.32) 39.63,119.32 39.7,119.25 39.7,119.06 39.99,118.77 40.95,118.77 41.85,119.68 ; 41.85,119.68 v1(42.02,119.51) ; 41.85,119.68 42.22,120.04 42.22,120.41 41.81,120.82 41.4,120.82 40.85,120.26 40.69,120.26 40.39,120.56 40.39,120.81 41.02,121.44 41.02,121.72
M_CHA_CLK1#: length 87
  TOP w0.114: CON1600.140 68.38,76.01 68.28,75.91 68.15,75.91 68.04,76.01 67.89,76.01 67.5,75.63 67.5,74.93 67.62,74.82 v2(67.89,74.82)
  IN1 w0.083: v2(39.09,119.94) 39.37,120.21 39.52,120.21 39.73,120.01 39.73,119.78 39.5,119.55 39.5,119.19 39.63,119.06 40.12,119.06 40.44,118.75 40.44,117.81 40.21,117.58 40.21,116.77 40.4,116.58 40.85,116.58 40.93,116.65 40.93,116.83 41.15,117.05 41.8,117.05 42.03,116.83 42.03,115.77 41.84,115.59 40.97,115.59 40.89,115.51 40.89,115.18 40.97,115.1 41.84,115.1 42.03,114.92 42.03,114.45 41.84,114.27 40.97,114.27 40.89,114.18 40.89,113.86 40.97,113.78 41.84,113.78 42.03,113.6 42.03,113.13 41.84,112.95 41.01,112.95 40.93,112.86 40.93,112.54 41.01,112.46 41.84,112.46 42.03,112.27 42.03,111.81 41.84,111.63 40.92,111.63 40.84,111.54 40.84,111.2 40.97,111.07 41.2,111.07 41.43,110.84 41.43,107.85 42.92,106.36 42.92,105.8 43.09,105.63 43.38,105.63 43.9,105.11 43.9,104.83 44.32,104.41 44.6,104.41 45.12,103.89 45.12,103.6 45.48,103.24 45.76,103.24 46.31,102.69 46.31,102.41 46.67,102.06 47.22,102.06 47.63,101.65 47.63,101.1 47.93,100.79 48.49,100.79 48.89,100.39 48.89,99.83 49.2,99.53 49.75,99.53 50.16,99.12 50.16,98.57 50.46,98.27 51.01,98.27 51.42,97.86 51.42,97.31 51.72,97 52.28,97 52.68,96.6 52.68,96.04 65.21,83.52 65.21,82.7 65.39,82.52 65.51,82.52 65.91,82.92 66.17,82.92 66.4,82.69 66.4,82.23 66.09,81.93 66.09,81.51 66.81,80.79 66.81,79.98 66.89,79.89 67.13,79.89 67.31,79.71 67.31,79.24 67.13,79.06 66.89,79.06 66.81,78.98 66.81,78.6 66.96,78.45 67.28,78.45 67.62,78.11 67.62,74.92 67.73,74.82 v2(67.89,74.82)
  BOTTOM w0.076: 40.76,121.65 40.84,121.73 40.84,121.8 40.86,121.82 40.86,124.88 U0300.AK1
  BOTTOM w0.114: v2(39.09,119.94) 39.34,119.94 39.42,119.85 39.42,119.65 39.49,119.58 39.74,119.58 39.96,119.36 39.96,119.17 40.1,119.03 40.45,119.03 ; 40.76,121.65 40.76,121.55 40.13,120.92 40.13,120.46 40.58,120 40.96,120 41.51,120.56 41.7,120.56 41.95,120.3 41.95,120.15 40.84,119.03 40.45,119.03 ; 40.45,119.03 v1(40.45,119.26)
M_CHA_CLK2: length 86.6
  IN1 w0.083: v2(69.67,74.36) 69.38,74.65 69.38,74.72 69.04,75.06 69.04,75.29 68.82,75.51 68.82,80.54 67.89,81.47 67.89,83.07 42.66,108.3 42.66,110.52 43.18,111.04 43.18,116.84 41.18,118.84 41.18,121.31 40.82,121.67 40.82,122.46 41.18,122.82 41.18,125.41 41.11,125.47 40.84,125.47 40.49,125.82 40.49,126.32 40.77,126.6 41.28,126.6 41.38,126.7 41.38,127.14 41.58,127.34 42.19,127.34 42.38,127.52 42.38,128.47 42.25,128.59 40.25,128.59 40.13,128.47 40.13,127.2 39.74,126.82 39.74,123.79 39.07,123.12 v6(39.07,123.12)
  BOTTOM w0.076: U0300.AL3 39.92,126.26 39.55,125.89 39.55,124.8 39.93,124.41 39.93,123.87 39.65,123.59 39.54,123.59 v6(39.07,123.12)
  BOTTOM w0.114: v2(69.67,74.36) 69.37,74.36 69.3,74.42 69.05,74.42 68.14,75.33 66.5,75.33 65.63,76.21 CON1601.137
M_CHA_CLK2#: length 86.6
  IN1 w0.083: v7(39.06,123.8) 39.51,123.8 39.57,123.87 39.57,126.89 39.95,127.27 39.95,128.54 40.18,128.76 42.32,128.76 42.55,128.54 42.55,127.45 42.27,127.17 41.65,127.17 41.55,127.07 41.55,126.63 41.35,126.43 40.84,126.43 40.67,126.25 40.67,125.89 40.91,125.64 41.19,125.64 41.35,125.48 41.35,122.75 40.99,122.39 40.99,121.74 41.35,121.38 41.35,118.91 43.35,116.91 43.35,110.97 42.83,110.45 42.83,108.37 68.07,83.14 68.07,81.54 69,80.61 69,75.58 69.21,75.37 69.21,75.13 69.32,75.02 v2(69.67,75.02)
  BOTTOM w0.076: U0300.AK3 40.51,126.39 40.18,126.71 39.79,126.71 39.57,126.49 39.57,126.15 39.38,125.96 39.38,124.73 39.77,124.34 39.77,123.94 39.63,123.8 v7(39.06,123.8)
  BOTTOM w0.114: v2(69.67,75.02) 69.33,74.68 69.15,74.68 68.25,75.59 66.61,75.59 66.13,76.07 CON1601.139
M_CHA_CLK3: length 85.2
  IN1 w0.083: v2(39.08,121.18) 39.33,121.43 39.52,121.43 39.8,121.7 39.8,123.11 39.9,123.21 40.02,123.21 40.23,123.42 40.23,124.86 40.3,124.94 40.65,124.94 40.74,124.84 40.74,123.02 40.42,122.69 40.42,121.38 40.72,121.08 40.72,120.84 40.63,120.74 40.26,120.74 40.08,120.56 40.08,119.93 40.26,119.75 40.44,119.75 40.72,119.47 40.72,118.58 42.52,116.79 42.52,111.39 42,110.88 42,107.97 66.9,83.07 66.9,81.53 68.16,80.27 68.16,75.23 68.37,75.02 68.37,73.58 68.58,73.37 69.06,73.37 69.38,73.05 69.6,73.05 69.72,72.93 69.72,71.42 69.59,71.29 69.31,71.29 69.18,71.42 69.18,72.41 68.96,72.63 68.55,72.63 68.35,72.43 68.35,72.25 v2(68.12,72.02)
  BOTTOM w0.076: v2(39.08,121.18) 39.61,121.18 40.44,122.01 40.44,124.61 40.34,124.71 40.34,124.9 40.23,125 40.23,125.26 39.92,125.57 U0300.AL2
  BOTTOM w0.114: CON1601.138 65.88,69.97 66.11,70.21 66.36,70.46 66.77,70.46 67.71,71.4 67.71,71.61 v2(68.12,72.02)
M_CHA_CLK3#: length 85.1
  IN1 w0.083: v2(68.12,71.39) 68.48,71.39 68.52,71.43 68.52,72.18 68.52,72.18 68.52,72.36 68.63,72.46 68.89,72.46 69.01,72.34 69.01,71.35 69.24,71.12 69.66,71.12 69.89,71.35 69.89,73 69.67,73.22 69.46,73.22 69.13,73.54 68.65,73.54 68.55,73.65 68.55,75.09 68.34,75.3 68.34,80.34 67.08,81.6 67.08,83.14 42.17,108.04 42.17,110.8 42.69,111.32 42.69,116.86 40.89,118.65 40.89,119.54 40.51,119.92 40.33,119.92 40.25,120 40.25,120.49 40.33,120.57 40.7,120.57 40.89,120.77 40.89,121.15 40.59,121.45 40.59,122.62 40.91,122.94 40.91,124.91 40.72,125.11 40.23,125.11 40.06,124.93 40.06,123.49 39.95,123.38 39.83,123.38 39.62,123.18 39.62,121.77 39.46,121.61 39.34,121.61 v7(39.08,121.87)
  BOTTOM w0.076: U0300.AL1 40.17,124.83 40.17,124.64 40.27,124.54 40.27,122.08 39.75,121.56 39.62,121.56 39.5,121.68 39.5,121.99 39.37,122.12 39.21,122.12 39.08,121.99 v7(39.08,121.87)
  BOTTOM w0.114: CON1601.140 66.38,70.1 66.47,70.2 66.88,70.2 68.07,71.39 v2(68.12,71.39)
M_CHA_CS#0: length 82.2
  TOP w0.178: v2(72.16,71.13) 72.63,70.67 CON1600.149
  IN1 w0.076: 50.85,116.19 50.65,116.4 50.65,116.57 45.2,122.02 45.2,125.12 45.71,125.63 45.71,126.97 v6(46.1,127.36)
  IN1 w0.121: v2(72.16,71.13) 74.28,71.13 74.93,70.48 75.87,70.48 76.18,70.79 76.18,71.37 76.42,71.61 76.42,72.81 76.33,72.9 76.33,73.34 76.21,73.46 76.08,73.46 75.96,73.58 75.96,73.82 76.08,73.94 76.21,73.94 76.33,74.06 76.33,77.38 76.68,77.73 76.68,78.25 76.81,78.38 77.1,78.38 77.23,78.5 77.23,81.11 77.09,81.24 76.73,81.24 76.61,81.36 76.61,83.2 76.93,83.52 76.93,86.48 65.25,98.16 64.23,98.16 56.62,105.78 56.45,105.78 56.42,105.75 56.25,105.75 56.11,105.88 56.11,106.05 56.15,106.08 56.15,106.25 50.78,111.62 50.78,111.72 50.66,111.84 50.56,111.84 50.44,111.96 50.44,112.14 50.56,112.26 50.66,112.26 50.78,112.38 50.78,112.57 50.66,112.69 50.56,112.69 50.44,112.81 50.44,112.99 50.56,113.11 50.66,113.11 50.78,113.23 50.78,113.42 50.66,113.54 50.56,113.54 50.44,113.66 50.44,113.84 50.56,113.96 50.66,113.96 50.78,114.08 50.78,114.27 50.66,114.39 50.56,114.39 50.44,114.51 50.44,114.69 50.56,114.81 50.66,114.81 50.78,114.94 50.78,115.15 50.62,115.31 50.42,115.31 50.29,115.43 50.29,115.76 50.39,115.86 50.7,115.86 50.85,116.01 50.85,116.19
  BOTTOM w0.076: v6(46.1,127.36) 45.77,127.69 U0300.AD5
M_CHA_CS#1: length 85.4
  TOP w0.178: v2(74.65,71.44) 74.66,71.43 74.97,71.43 75.14,71.26 75.14,70.78 74.63,70.26 CON1600.157
  IN1 w0.076: v7(44.04,121.91) 44.4,121.56 44.4,121.07
  IN1 w0.121: v2(74.65,71.44) 75.16,70.93 75.69,70.93 75.76,71 75.76,71.52 75.54,71.73 74.99,71.73 74.86,71.87 74.47,71.87 74.16,71.56 72.93,71.56 72.83,71.67 72.83,71.96 72.95,72.07 74.04,72.07 74.63,72.66 74.63,78.08 74.91,78.36 74.91,84.09 74.82,84.17 74.82,84.66 74.96,84.8 75.1,84.8 75.23,84.92 75.23,85.59 74.93,85.88 74.76,86.05 73.74,86.05 63.34,96.46 62.37,96.46 52.17,106.66 52.17,107.82 48.74,111.25 48.74,115.23 48.13,115.84 48.13,115.97 48.41,116.25 48.41,116.37 48.29,116.5 48.13,116.5 47.88,116.25 47.73,116.25 47.57,116.41 47.57,116.58 47.76,116.77 47.76,116.94 47.63,117.07 47.46,117.07 47.27,116.88 47.09,116.88 46.96,117.01 46.96,117.18 47.19,117.4 47.19,117.58 47.06,117.7 46.89,117.7 46.66,117.48 46.49,117.48 46.36,117.61 46.36,117.78 46.6,118.01 46.6,118.19 46.47,118.32 46.3,118.32 46.06,118.08 45.89,118.08 45.76,118.21 45.76,118.38 46.02,118.64 46.02,118.82 45.9,118.94 45.72,118.94 45.46,118.68 45.29,118.68 45.16,118.81 45.16,118.98 45.36,119.18 45.36,119.35 45.23,119.48 45.06,119.48 44.86,119.29 44.69,119.29 44.39,119.58 44.39,119.87 44.45,119.93 44.78,119.93 44.86,120 44.86,120.33 45.15,120.63 45.15,120.78 45.04,120.89 44.81,120.89 44.7,120.79 44.5,120.79 44.4,120.89 44.4,121.07
  BOTTOM w0.076: v7(44.04,121.91) 44.45,121.91 45.52,122.98 45.52,124.58 45.32,124.78 45.32,125.37 U0300.AE2
M_CHA_CS#2: length 88.2
  IN1 w0.121: v2(74.17,74.09) 74.17,78.23 74.48,78.55 74.48,78.7 74.34,78.84 74.34,79.16 74.48,79.3 74.48,79.56 74.36,79.69 74.09,79.69 73.96,79.82 73.96,80.08 74.09,80.21 74.36,80.21 74.48,80.33 74.48,80.51 74.36,80.63 74.09,80.63 73.97,80.76 73.97,80.94 74.09,81.06 74.36,81.06 74.48,81.18 74.48,81.36 74.36,81.49 74.09,81.49 73.97,81.61 73.97,81.79 74.09,81.91 74.36,81.91 74.48,82.04 74.48,82.21 74.36,82.34 74.09,82.34 73.97,82.46 73.97,82.64 74.09,82.76 74.36,82.76 74.48,82.89 74.48,83.06 74.36,83.19 74.09,83.19 73.96,83.31 73.96,83.49 74.09,83.61 74.37,83.61 74.48,83.73 74.48,83.89 74.37,84 74.05,84 73.96,84.09 73.96,84.32 74.06,84.42 74.26,84.42 74.37,84.53 74.37,84.7 74.26,84.81 74.09,84.81 73.97,84.93 73.97,85.1 74.09,85.22 74.53,85.22 74.65,85.34 74.65,85.51 74.53,85.63 73.57,85.63 68.69,90.5 67.73,90.5 66.91,91.32 66.91,91.49 67.21,91.79 67.21,91.94 66.93,92.22 66.78,92.22 66.48,91.92 66.31,91.92 66.05,92.18 66.05,92.35 66.31,92.61 66.31,92.79 66.06,93.04 65.89,93.04 65.62,92.78 65.45,92.78 65.19,93.03 65.19,93.2 65.46,93.47 65.46,93.64 65.2,93.9 65.03,93.9 64.77,93.63 64.6,93.63 64.34,93.89 64.34,94.06 64.61,94.32 64.61,94.49 64.35,94.75 64.18,94.75 63.91,94.48 63.74,94.48 63.49,94.74 63.49,94.91 63.75,95.18 63.75,95.35 63.5,95.6 63.33,95.6 63.06,95.34 62.89,95.34 51.74,106.48 51.74,107.65 48.31,111.08 48.31,115.26 44.04,119.53 v2(44.04,120.09)
  BOTTOM w0.076: U0300.AD2 46.03,125.39 46.03,121.68
  BOTTOM w0.178: v2(44.04,120.09) 44.04,119.35 v1(44.21,119.18) 44.22,119.17 46.65,119.17 46.98,119.5 46.98,120.19 46.03,121.13 46.03,121.68 ; v2(74.17,74.09) 73.67,74.09 72.8,73.23 72.31,73.23 72.11,73.43 72.11,74.17 71.72,74.57 71.01,74.57 70.82,74.76 70.82,75.94 70.63,76.13 CON1601.149
M_CHA_CS#3: length 86.4
  IN1 w0.121: v2(75.9,74.56) 75.9,77.55 76.18,77.83 76.18,79.91 76.35,80.08 76.68,80.08 76.8,80.2 76.8,80.57 76.18,81.19 76.18,83.38 76.5,83.7 76.5,86.31 65.07,97.74 62.9,97.74 53.44,107.19 53.44,108.35 50.02,111.78 50.02,116.94 45,121.96 45,125.21 45.42,125.63 45.42,127.6 45.62,127.8 45.62,128.41 45.49,128.54 45.03,128.54 44.93,128.64 44.93,128.84 45.02,128.93 45.53,128.93 45.85,129.25 45.85,130.16 45.95,130.27 46.66,130.27 46.82,130.11 46.82,129.16 47.11,128.87 48.29,128.87 48.39,128.77 48.39,128.49 48.31,128.41 46.56,128.41 46.48,128.49 46.48,128.87 46.41,128.95 46.18,128.95 46.08,128.84 46.08,128.06 v6(46.13,128.01)
  BOTTOM w0.076: U0300.AE5 44.95,127.69 45.27,128.01 46.13,128.01 v6(46.13,128.01)
  BOTTOM w0.178: CON1601.157 72.63,76.33 73.88,75.07 74.77,75.07 75.28,74.56 v2(75.9,74.56)
M_CHA_DQ0: length 86.1
  TOP w0.159: CON1600.8 35.38,76.48 35.29,76.4 35.29,76.4 35.25,76.35 35.24,76.35 33.54,74.65 v2(30.88,74.65)
  IN1 w0.108: v6(20.31,128.23) 19.04,128.23 18.3,127.49 14.88,127.49 12.18,124.78 12.18,112.75 12.86,112.07 12.86,109.26 13.49,108.63 13.49,108.27 13.38,108.16 13.09,108.16 12.98,108.05 12.98,107.84 13.09,107.73 13.38,107.73 13.49,107.62 13.49,107.4 13.38,107.3 13.09,107.3 12.98,107.19 12.98,106.97 13.09,106.86 13.38,106.86 13.49,106.76 13.49,106.54 13.38,106.43 13.09,106.43 12.98,106.32 12.98,106.11 13.09,106 13.38,106 13.49,105.89 13.49,105.68 13.38,105.57 13.09,105.57 12.98,105.46 12.98,105.24 13.09,105.14 13.38,105.14 13.49,105.03 13.49,100.1 14.57,99.02 14.57,92.38 30.19,76.75 30.19,74.77 30.3,74.65 v2(30.88,74.65)
  BOTTOM w0.076: v6(20.31,128.23) 20.43,128.35 21.13,128.35 21.27,128.21 21.8,128.21 21.87,128.28 U0300.BR6
  BOTTOM w0.159: v2(30.88,74.65) 31.13,74.41 32.22,74.41 32.33,74.52 32.33,75.24 32.44,75.35 32.61,75.35 32.72,75.24 32.72,74.52 32.83,74.41 33.07,74.41 33.45,74.78 33.45,75.43 33.13,75.75 CON1601.7
M_CHA_DQ1: length 86
  TOP w0.159: v6(18.79,126.69) 18.87,126.61 v1(18.87,125.65) ; v2(32.39,71.75) 32.53,71.89 34.09,71.89 35.13,70.86 CON1600.7
  IN1 w0.108: v2(32.39,71.75) 32.78,71.75 33.75,72.72 33.75,73.68 32.19,75.24 32.19,75.71 15.24,92.65 15.24,99.29 14.16,100.37 14.16,108.91 13.54,109.53 13.54,116.62 13.43,116.72 13.15,116.72 13.05,116.83 13.05,117.05 13.15,117.16 13.43,117.16 13.54,117.26 13.54,117.48 13.43,117.59 13.15,117.59 13.05,117.7 13.05,117.91 13.15,118.02 13.43,118.02 13.54,118.13 13.54,118.33 12.85,119.02 12.85,123.53 16,126.69 v6(18.79,126.69)
  BOTTOM w0.076: v6(18.79,126.69) 18.97,126.87 18.97,127.84 19.91,128.77 21.49,128.77 U0300.BT6
  BOTTOM w0.159: v2(32.39,71.75) 32.65,72 34.49,72 34.67,71.82 34.67,71.34 33.38,70.04 CON1601.8
M_CHA_DQ2: length 82.3
  TOP w0.159: CON1600.17 37.63,70.12 37.74,70.24 37.74,70.4 37.56,70.59 36.94,70.59 v2(36.87,70.66)
  IN1 w0.076: v7(20.47,125.72) 20.47,125.17 18.79,123.49
  IN1 w0.108: 18.79,123.49 17.45,123.49 16.74,122.78 16.74,101.51 17.82,100.43 17.82,93.73 36.7,74.85 36.7,72.15 37.39,71.47 37.39,70.58 37.51,70.46 38.22,70.46 38.34,70.34 38.34,70.18 38.22,70.07 37.46,70.07 37.39,70 37.39,69.81 37.49,69.71 38.25,69.71 38.32,69.63 38.32,69.41 38.25,69.33 37.45,69.33 37.39,69.27 37.39,69 37.29,68.9 36.98,68.9 36.87,69.02 v2(36.87,70.66)
  BOTTOM w0.076: v7(20.47,125.72) 20.47,126.27 20.78,126.58 21.03,126.58 21.2,126.75 22.07,126.75 22.11,126.79 22.66,126.79 U0300.BP3
  BOTTOM w0.159: CON1601.16 35.38,70.47 36.07,71.16 36.37,71.16 36.47,71.05 36.47,70.76 36.57,70.66 v2(36.87,70.66)
M_CHA_DQ3: length 86.3
  TOP w0.159: CON1600.20 38.38,76.46 36.5,74.59 36.5,74.38 v2(35.85,73.73)
  IN1 w0.108: v6(19.96,125.25) 18.96,125.25 18.75,125.04 16.5,125.04 15.6,124.14 15.6,123.91 15.82,123.69 15.82,122.71 15.7,122.59 14.7,122.59 14.55,122.45 14.55,122.04 14.68,121.91 14.68,121.66 14.18,121.17 14.18,120.81 14.35,120.64 14.91,120.64 15.05,120.5 15.05,117.99 15.22,117.82 15.56,117.82 15.66,117.71 15.66,117.5 15.56,117.39 15.22,117.39 15.11,117.28 15.11,117.07 15.22,116.96 15.56,116.96 15.66,116.85 15.66,116.63 15.56,116.53 15.22,116.53 15.11,116.42 15.11,116.2 15.22,116.1 15.56,116.1 15.66,115.99 15.66,115.77 15.56,115.66 15.22,115.66 15.11,115.56 15.11,115.28 15.24,115.16 15.41,115.16 15.52,115.04 15.52,114.89 15.41,114.77 15.24,114.77 15.11,114.65 15.11,114.48 15.22,114.37 15.56,114.37 15.66,114.26 15.66,114.04 15.56,113.94 15.22,113.94 15.11,113.83 15.11,113.48 15.73,112.86 15.73,101.09 16.81,100.01 16.81,93.31 33.79,76.33 33.79,75.87 33.92,75.74 34.05,75.74 34.14,75.83 34.29,75.83 34.45,75.68 34.45,75.52 34.37,75.45 34.37,75.29 34.6,75.06 34.75,75.06 34.82,75.14 34.97,75.14 35.13,74.98 35.13,74.83 35.05,74.76 35.05,74.61 35.33,74.33 35.33,73.48 35.39,73.42 35.53,73.42 v2(35.85,73.73)
  BOTTOM w0.076: U0300.BR3 21.76,126 21.33,126 20.58,125.25 v6(19.96,125.25)
  BOTTOM w0.159: v1(18.62,124.9) 18.97,125.25 v6(19.96,125.25) ; v2(35.85,73.73) 37.01,73.73 37.11,73.83 37.11,74.16 37.01,74.26 36.55,74.26 36.4,74.41 36.4,74.61 36.55,74.77 36.83,74.77 37.06,75 37.06,75.6 36.63,76.03 36.63,77.3 CON1601.21
M_CHA_DQ4: length 83.4
  TOP w0.159: v2(32.39,71.13) 33.18,71.13 34.13,70.19 CON1600.3
  IN1 w0.108: v2(32.39,71.13) 32.97,71.13 33.35,71.52 33.35,71.7 34.09,72.44 34.09,73.82 32.55,75.35 32.55,75.82 15.58,92.79 15.58,99.43 14.5,100.51 14.5,109.05 13.87,109.67 13.87,119.29 13.23,119.93 13.23,123.36 15.99,126.12 v6(18.46,126.12)
  BOTTOM w0.076: v6(18.46,126.12) 18.46,126.49 18.42,126.54 18.42,127.16 v1(18.55,127.3) 18.55,127.66 19.84,128.94 21.25,128.94 21.34,129.03 21.7,129.03 21.94,128.79 22.97,128.79 23.25,128.51 23.25,128.01 U0300.BN5
  BOTTOM w0.159: CON1601.4 32.38,70.14 32.49,70.25 33.03,70.25 33.4,70.62 33.4,70.83 33.25,70.99 33.05,70.99 32.77,70.71 32.49,70.71 32.39,70.81 v2(32.39,71.13)
M_CHA_DQ5: length 85.4
  TOP w0.159: CON1600.4 34.38,76.48 33.82,75.92 v2(30.78,75.92) ; v6(19.86,127.78) 20.14,127.5 v1(20.42,127.5)
  IN1 w0.108: v6(19.86,127.78) 19.86,127.78 19.33,127.78 18.7,127.14 15.33,127.14 14.23,126.04 14.23,125.68 12.51,123.96 12.51,116.89 13.2,116.2 13.2,115.89 13.09,115.78 12.75,115.78 12.64,115.67 12.64,115.45 12.75,115.35 13.09,115.35 13.2,115.24 13.2,115.02 13.09,114.91 12.75,114.91 12.64,114.81 12.64,114.59 12.75,114.48 13.09,114.48 13.2,114.37 13.2,114.16 13.09,114.05 12.75,114.05 12.64,113.94 12.64,113.73 12.75,113.62 13.09,113.62 13.2,113.51 13.2,113.3 13.09,113.19 12.75,113.19 12.64,113.08 12.64,112.86 12.75,112.76 13.09,112.76 13.2,112.65 13.2,109.39 13.82,108.77 13.82,100.24 14.9,99.15 14.9,92.52 31.85,75.57 31.85,75.4 31.67,75.22 31.48,75.22 v2(30.78,75.92)
  BOTTOM w0.076: v6(19.86,127.78) 19.86,128.33 20.13,128.61 21.11,128.61 21.34,128.37 21.73,128.37 21.95,128.6 22.39,128.6 22.6,128.38 U0300.BP6
  BOTTOM w0.159: v2(30.78,75.92) 29.86,75.92 29.74,76.04 29.74,76.47 29.85,76.57 31.01,76.57 31.66,75.92 31.89,75.92 32.13,76.16 CON1601.3
M_CHA_DQ6: length 84.4
  TOP w0.159: v6(19.13,124.39) 19.43,124.1 v1(19.43,123.77) ; v2(36.87,71.3) 37.19,70.98 37.85,70.98 38.63,70.2 CON1600.21
  IN1 w0.108: v6(19.13,124.39) 19.13,124.13 18.68,123.69 17.26,123.69 16.41,122.83 16.41,121.36 16.3,121.25 16.1,121.25 15.99,121.14 15.99,120.93 16.1,120.82 16.3,120.82 16.41,120.71 16.41,101.37 17.49,100.29 17.49,93.59 36.37,74.71 36.37,72.11 33.89,69.63 33.89,69.4 34.08,69.22 34.24,69.22 36.31,71.3 v2(36.87,71.3)
  BOTTOM w0.076: v6(19.13,124.39) 19.4,124.12 22.05,124.12 22.53,124.6 22.53,125.51 U0300.BP2
  BOTTOM w0.159: CON1601.20 36.38,69.92 36.65,70.2 37.03,70.2 37.44,70.61 37.44,71.72 37.29,71.87 37.01,71.87 36.87,71.73 v2(36.87,71.3)
M_CHA_DQ7: length 86.2
  TOP w0.159: v6(19.55,124.84) 18.39,124.84 v1(17.73,124.17) ; v2(35.85,74.39) 35.85,74.59 37.38,76.12 CON1600.16
  IN1 w0.108: v6(19.55,124.84) 18.98,124.84 18.8,124.66 18.55,124.66 18.49,124.6 18.49,124.05 18.4,123.96 18.17,123.96 18.06,124.07 18.06,124.61 17.95,124.71 17.73,124.71 17.63,124.61 17.63,124.07 17.53,123.96 17.31,123.96 17.19,124.08 17.19,124.61 17.09,124.71 16.87,124.71 16.76,124.61 16.76,124.3 16.69,124.23 16.23,124.23 16.07,124.06 16.07,123.93 16.18,123.82 16.55,123.82 16.66,123.71 16.66,123.5 16.55,123.39 16.18,123.39 16.07,123.28 16.07,121.99 15.35,121.27 14.89,121.27 14.8,121.18 14.8,121.01 14.91,120.9 15.27,120.9 15.37,120.79 15.37,120.71 15.5,120.58 15.7,120.58 15.81,120.48 15.81,120.33 15.7,120.22 15.5,120.22 15.37,120.09 15.37,119.88 15.44,119.81 15.81,119.81 15.91,119.71 15.91,119.46 15.8,119.34 15.47,119.34 15.4,119.27 15.4,119 15.47,118.92 15.92,118.92 16.02,118.81 16.02,118.65 15.91,118.54 15.52,118.54 15.41,118.43 15.41,118.26 15.52,118.15 15.98,118.15 16.07,118.06 16.07,101.23 17.15,100.15 17.15,93.45 35.85,74.75 v2(35.85,74.39)
  BOTTOM w0.076: U0300.BN3 23.36,126.23 22.61,126.23 22.51,126.14 22.15,126.14 21.95,125.94 21.93,125.91 21.93,125.56 21.93,125.5 21.93,125.35 21.53,124.95 21.53,124.73 21.4,124.61 20.98,124.61 20.63,124.96 20.23,124.96 20.01,124.75 20.01,124.39 19.95,124.33 19.66,124.33 19.6,124.39 19.6,124.79 v6(19.55,124.84)
  BOTTOM w0.159: v2(35.85,74.39) 35.1,74.39 34.95,74.54 34.95,74.84 35.05,74.94 35.87,74.94 35.99,75.07 35.99,75.35 35.89,75.45 35.74,75.45 35.63,75.57 CON1601.17
M_CHA_DQ8: length 80.4
  TOP w0.159: v2(37.83,74.46) 37.3,74.46 37.19,74.57 37.19,74.72 37.44,74.97 38.05,74.97 38.19,75.11 38.19,75.35 38.32,75.48 38.48,75.48 38.6,75.36 38.76,75.36 38.87,75.47 38.87,75.63 38.66,75.85 38.66,76.02 38.77,76.13 38.92,76.13 39.17,75.88 39.33,75.88 39.55,76.1 39.55,76.3 39.38,76.48 CON1600.24
  IN1 w0.108: v6(25.22,127.36) 24.61,126.75 24.61,126.32 24.28,125.99 24.14,125.99 23.93,126.19 23.93,126.32 24.02,126.4 24.02,126.56 23.91,126.66 23.68,126.66 23.35,126.33 23.35,126.18 23.81,125.72 23.81,125.59 23.69,125.47 23.56,125.47 23.11,125.92 22.94,125.92 22.84,125.82 22.84,125.66 23.23,125.27 23.23,125.13 23.07,124.98 22.93,124.98 22.49,125.42 22.32,125.42 20.89,123.99 19.84,123.99 18.95,123.1 18.28,123.1 17.9,122.72 17.9,121.64 17.42,121.15 17.42,101.79 18.5,100.71 18.5,94 37.38,75.13 37.38,74.21 37.45,74.13 37.59,74.13 37.83,74.38 v2(37.83,74.46)
  BOTTOM w0.076: U0300.BL4 25.15,127.36 v6(25.22,127.36)
  BOTTOM w0.159: CON1601.25 37.63,76.3 37.83,76.09 v2(37.83,74.46)
M_CHA_DQ9: length 82.1
  TOP w0.159: v1(24.46,127.96) 25.15,127.96 v6(25.21,128.02) ; CON1600.28 40.38,76.32 38.59,74.53 38.59,73.73 38,73.14 37.34,73.14 37.13,73.35 37.13,73.62 37.31,73.8 v2(37.83,73.8)
  IN1 w0.108: v6(25.21,128.02) 24.64,128.02 20.81,124.18 19.76,124.18 18.87,123.29 17.64,123.29 17.05,122.7 17.05,122.1 17.14,122 17.39,122 17.49,121.9 17.49,121.7 17.38,121.59 17.14,121.59 17.08,121.54 17.08,101.65 18.16,100.57 18.16,93.87 37.04,74.99 37.04,73.51 37.29,73.26 37.72,73.26 37.83,73.38 v2(37.83,73.8)
  BOTTOM w0.076: U0300.BL5 25.16,128.02 v6(25.21,128.02)
  BOTTOM w0.159: CON1601.29 38.63,74.6 v2(37.83,73.8)
M_CHA_DQ10: length 80.2
  TOP w0.159: v2(41.4,70.37) 41.86,70.37 41.96,70.47 41.96,71.26 42.06,71.36 42.23,71.36 43,70.59 43,70.37 42.9,70.27 42.72,70.27 42.63,70.17 CON1600.37 ; v1(23.22,124.81) 23.22,123.95 v6(22.93,123.66)
  IN1 w0.108: v6(22.93,123.66) 22.35,123.66 22.1,123.42 21.68,123.42 21.38,123.12 20.31,123.12 19.33,122.13 19.33,102.58 20.41,101.5 20.41,94.8 33.11,82.1 34.98,82.1 36.83,80.25 36.83,78.51 38.89,76.45 38.9,76.45 39.82,75.54 39.82,73.34 40.54,72.62 40.54,68.92 40.74,68.71 41.2,68.71 41.4,68.92 v2(41.4,70.37)
  BOTTOM w0.076: v6(22.93,123.66) 23,123.73 23,123.73 23.16,123.88 23.16,124.02 24.03,124.9 24.03,124.95 24.03,124.95 24.03,125.17 24.6,125.74 U0300.BL2
  BOTTOM w0.159: v2(41.4,70.37) 41.12,70.37 40.88,70.13 CON1601.38
M_CHA_DQ11: length 80.4
  TOP w0.159: v2(41.4,70.98) 41.4,71.79 41.5,71.9 42.24,71.9 43.63,70.51 CON1600.41 ; v6(22.58,123.22) 22.85,122.95 v1(23.44,122.95)
  IN1 w0.108: v2(41.4,70.98) 41,70.98 40.88,71.11 40.88,71.4 40.95,71.47 42.04,71.47 42.11,71.39 42.11,70.85 42.23,70.74 42.39,70.74 42.5,70.85 42.5,71.74 42.4,71.85 41,71.85 40.88,71.97 40.88,72.76 40.15,73.48 40.15,75.67 37.67,78.16 37.67,80.05 35.28,82.44 33.25,82.44 20.75,94.94 20.75,101.64 19.66,102.72 19.66,122.19 20.39,122.92 21.46,122.92 21.76,123.22 v6(22.58,123.22)
  BOTTOM w0.076: U0300.BM1 24.2,124.88 24.2,124.83 23.32,123.96 23.32,123.48 23.06,123.22 v6(22.58,123.22)
  BOTTOM w0.159: CON1601.42 41.88,70.66 41.55,70.98 v2(41.4,70.98)
M_CHA_DQ12: length 82.1
  TOP w0.159: CON1600.29 40.63,71.1 40.51,71.21 40.11,71.21 39.98,71.08 39.98,70.8 39.85,70.68 39.49,70.68 39.29,70.87 39.29,71.67 39.17,71.79 38.84,71.79 38.7,71.93 38.7,72.54 38.57,72.67 v2(37.83,72.67) ; v6(25.22,126.72) 24.92,126.41 v1(24.46,126.41)
  IN1 w0.076: v6(25.22,126.72) 25.22,126.47 23.49,124.74 21.98,124.74 21.05,123.81 19.98,123.81 19.09,122.91 18.4,122.91 18.17,122.68
  IN1 w0.108: v2(37.83,72.67) 38.24,73.08 38.24,74.74 34.75,78.23 34.75,78.38 34.85,78.48 35.18,78.48 35.26,78.56 35.26,78.96 35.21,79.01 35.03,79.01 34.93,79.11 34.93,79.49 34.66,79.75 34.17,79.75 34.04,79.62 34.04,79.37 33.93,79.27 33.78,79.27 33.68,79.37 33.68,79.65 33.63,79.7 33.28,79.7 18.83,94.14 18.83,100.85 17.75,101.93 17.75,121.17 18.17,121.59 18.17,122.68
  BOTTOM w0.076: U0300.BK4 25.29,126.72 v6(25.22,126.72)
  BOTTOM w0.159: CON1601.28 38.38,72.13 v2(37.83,72.67)
