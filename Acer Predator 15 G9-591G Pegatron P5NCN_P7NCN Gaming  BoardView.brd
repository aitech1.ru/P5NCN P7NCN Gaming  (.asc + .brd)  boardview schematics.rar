# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ59: length 104
  TOP w0.159: v2(92.38,60.59) 94.21,58.77 94.21,58.36 94.63,57.94 CON1700.237
  IN4 w0.076: v6(55.38,129.97) 55.4,129.97 55,129.57 55,129.21 55.24,128.97 55.48,128.97 55.99,128.46 56.2,128.46 56.56,128.1 56.56,126.07 59.17,123.46 59.41,123.46
  IN4 w0.108: 59.41,123.46 64.23,123.46 69.57,118.12 69.57,114.28 95.82,88.03 95.82,86.22 96.1,85.93 96.1,81.44 96.68,80.86 96.68,77.98 96.58,77.89 96.31,77.89 96.22,77.79 96.22,77.65 96.31,77.55 96.58,77.55 96.68,77.45 96.68,75.82 96.58,75.72 96.21,75.72 96.11,75.62 96.11,75.48 96.21,75.38 96.58,75.38 96.68,75.29 96.68,74.89 96.28,74.49 96.28,71.72 96.4,71.6 96.4,70.06 95.79,69.45 95.79,65.35 92.92,62.48 92.92,62.3 92.82,62.2 92.55,62.2 92.46,62.1 92.46,61.96 92.55,61.86 92.82,61.86 92.92,61.76 92.92,61.62 92.82,61.52 92.55,61.52 92.46,61.43 92.46,61.29 92.55,61.19 92.82,61.19 92.92,61.09 92.92,60.7 92.81,60.59 v2(92.38,60.59)
  BOTTOM w0.076: v6(55.38,129.97) 55.31,129.97 U0300.M8
  BOTTOM w0.159: CON1701.232 91.38,59.59 v2(92.38,60.59)
M_CHB_DQ60: length 104.3
  TOP w0.159: v2(95.37,59.72) 95.57,59.91 96.55,59.91 97.63,58.84 CON1700.249
  IN4 w0.076: v6(56.33,131.27) 56.69,130.9 56.69,130.24 58.93,128 58.93,126.06 59.76,125.22 60.05,125.22
  IN4 w0.108: 60.05,125.22 60.56,125.22 60.93,124.86 65.85,124.86 65.95,124.75 67.24,124.75 67.65,124.34 67.65,123.87 73.24,118.29 73.24,113.79 98.07,88.96 98.07,88.01 99.51,86.56 99.51,74.55 98.53,73.56 98.53,72.84 98.7,72.66 98.7,69.94 98.82,69.82 98.82,67.6 99.14,67.28 99.14,65.41 97.56,63.83 97.56,63.27 95.76,61.47 95.76,60.45 95.37,60.06 v2(95.37,59.72)
  BOTTOM w0.076: U0300.L10 56.22,131.27 v6(56.33,131.27)
  BOTTOM w0.159: CON1701.246 94.88,58.33 94.54,58.67 94.54,59.43 94.83,59.72 v2(95.37,59.72)
M_CHB_DQ61: length 103.7
  TOP w0.159: v2(92.51,62.75) 93.02,62.75 94.38,64.11 CON1700.236
  IN4 w0.076: 59.34,123.26 59.13,123.26 57.05,125.34 56.31,125.34 55.78,125.88 55.78,128.2 54.83,129.14 54.83,130.11 55.08,130.35 55.08,130.91 v6(55.44,131.27)
  IN4 w0.108: 59.34,123.26 63.79,123.26 69.23,117.82 69.23,114.14 94.65,88.72 94.65,87.23 94.95,86.93 95.2,86.93 95.48,86.65 95.48,85.98 95.77,85.69 95.77,81.3 96.34,80.73 96.34,78.4 95.29,77.35 95.29,77.18 95.38,77.08 96.07,77.08 96.16,76.98 96.16,76.84 96.07,76.74 95.38,76.74 95.29,76.65 95.29,76.51 95.38,76.41 96.07,76.41 96.16,76.31 96.16,76.17 96.07,76.07 95.38,76.07 95.29,75.97 95.29,74.43 95.94,73.78 95.94,71.59 96.07,71.46 96.07,70.2 95.46,69.59 95.46,69.44 95.36,69.34 94.97,69.34 94.87,69.24 94.87,69.1 94.97,69 95.36,69 95.46,68.91 95.46,68.77 95.36,68.67 94.97,68.67 94.87,68.57 94.87,68.43 94.97,68.33 95.36,68.33 95.46,68.23 95.46,65.49 92.72,62.75 v2(92.51,62.75)
  BOTTOM w0.076: U0300.M10 55.31,131.27 v6(55.44,131.27)
  BOTTOM w0.159: CON1701.233 91.63,63.63 v2(92.51,62.75)
M_CHB_DQ62: length 103
  TOP w0.159: v2(92.38,59.96) 92.38,59.44 92.69,59.13 93.21,59.13 93.63,58.71 CON1700.233
  IN4 w0.076: 59.45,123.66 59.2,123.66 56.72,126.14 56.72,128.17 56.27,128.63 56.06,128.63 55.39,129.29 v6(55.39,129.34)
  IN4 w0.108: 59.45,123.66 64.37,123.66 66.09,121.93 66.25,121.93 69.91,118.27 69.91,114.42 72.72,111.6 96.15,88.17 96.15,87.21 97.43,85.94 97.43,79.31 97.12,79 97.12,74.86 96.61,74.35 96.61,71.86 96.74,71.74 96.74,69.92 96.13,69.31 96.13,65.21 93.26,62.34 93.26,58.43 93.12,58.28 92.48,58.28 92.38,58.38 v2(92.38,59.96)
  BOTTOM w0.076: U0300.M7 55.32,129.34 v6(55.39,129.34)
  BOTTOM w0.159: CON1701.236 92.38,57.1 v2(92.38,59.96)
M_CHB_DQ63: length 103.6
  TOP w0.159: v2(96.57,63.06) 96.57,62.73 96.72,62.58 97,62.58 97.56,63.14 97.56,63.86 97.88,64.17 CON1700.250
  IN4 w0.076: v6(56.33,129.97) 56.72,129.58 56.72,129.11 57.13,128.7 58,128.7 58.76,127.94 58.76,125.99 60.18,124.58
  IN4 w0.108: 60.18,124.58 65.51,124.58 66.58,123.51 67.54,123.51 71.74,119.32 71.74,119.18 71.5,118.95 71.5,118.81 71.6,118.71 71.74,118.71 71.97,118.94 72.11,118.94 72.91,118.15 72.91,117.87 72.81,117.77 72.67,117.77 72.57,117.67 72.57,117.53 72.67,117.43 72.81,117.43 72.91,117.33 72.91,117.2 72.81,117.1 72.67,117.1 72.57,117 72.57,116.86 72.67,116.76 72.81,116.76 72.91,116.66 72.91,116.52 72.81,116.42 72.67,116.42 72.57,116.33 72.57,116.19 72.67,116.09 72.81,116.09 72.91,115.99 72.91,115.85 72.81,115.75 72.67,115.75 72.57,115.65 72.57,115.51 72.67,115.41 72.81,115.41 72.91,115.32 72.91,115.04 72.81,114.94 71.96,114.94 71.86,114.85 71.86,114.71 71.96,114.61 72.81,114.61 72.91,114.51 72.91,113.65 97.73,88.82 97.73,87.87 99.18,86.42 99.18,74.69 98.19,73.7 98.19,72.7 98.37,72.52 98.37,68.64 98.49,68.52 98.49,68.16 98.37,68.05 98.16,68.05 98.06,67.95 98.06,67.73 98.15,67.65 98.39,67.65 98.49,67.55 98.49,67.25 98.22,66.98 98.22,66.08 98.49,65.81 98.49,65.3 97.21,64.02 97.21,63.57 96.7,63.06 v2(96.57,63.06)
  BOTTOM w0.076: U0300.L8 56.2,129.97 v6(56.33,129.97)
  BOTTOM w0.159: CON1701.245 94.63,64.13 95.7,63.06 v2(96.57,63.06)
M_CHB_DQS0: length 95.5
  TOP w0.159: v2(34.62,60.34) 34.94,60.34 35.06,60.22 35.06,60.01 34.94,59.89 34.64,59.89 34.56,59.81 34.56,59.65 34.78,59.43 35.89,59.43 36.2,59.12 36.2,58.45 36.63,58.02 CON1700.13
  IN4 w0.076: 16.59,127.65 16.59,127.66 16.59,127.69 16.68,127.77 16.71,127.77 17.06,128.12 17.06,128.44 19.15,130.53 19.94,130.53 20.7,131.29 22.41,131.29 v6(22.56,131.14)
  IN4 w0.114: v2(34.62,60.34) 34.9,60.34 35.08,60.52 35.08,61.16 34.82,61.41 34.82,62.11 33.9,63.03 33.9,63.31 31.67,65.53 31.67,70.2 31.39,70.48 29.34,72.53 29.34,80.88 15.48,94.75 15.48,120.32 16.31,121.15 16.31,127.37 16.59,127.65
  BOTTOM w0.159: CON1701.13 34.63,62.61 35.27,61.96 35.27,60.99 35.06,60.78 35.06,60.77 34.8,60.52 34.79,60.52 v2(34.62,60.34) ; U0300.BR9 22.56,131.07 v6(22.56,131.14)
M_CHB_DQS0#: length 95.5
  TOP w0.159: CON1700.11 36.13,58.15 35.93,58.34 35.93,59.02 35.78,59.17 34.67,59.17 34.19,59.66 34.19,60.52 34.44,60.78 34.45,60.78 v2(34.62,60.95)
  IN4 w0.076: 16.44,127.8 16.47,127.8 16.61,127.94 16.64,127.94 16.89,128.19 16.89,128.51 19.08,130.7 19.87,130.7 20.63,131.46 22.33,131.46 22.38,131.51 22.84,131.51 v6(23.21,131.14)
  IN4 w0.114: 16.44,127.8 16.1,127.46 16.1,121.23 15.28,120.41 15.28,94.66 29.14,80.8 29.14,72.44 31.18,70.4 31.47,70.11 31.47,65.45 33.7,63.22 33.7,62.94 34.62,62.02 v2(34.62,60.95)
  BOTTOM w0.159: v6(23.21,131.14) 23.21,131.07 U0300.BP9 ; CON1701.11 34.13,64.42 34.36,64.18 34.36,62.5 35.01,61.85 35.01,61.6 34.87,61.46 34.44,61.46 34.32,61.33 34.32,61.05 34.42,60.95 v2(34.62,60.95)
M_CHB_DQS1: length 94.3
  TOP w0.159: v2(39.8,61.99) 39.53,62.27 39.53,62.41 40.48,63.36 40.86,63.36 41.4,63.9 41.55,63.9 41.71,63.75 41.88,63.75 42.06,63.92 42.06,64.08 41.88,64.26 CON1700.34
  IN4 w0.076: v6(25.33,130.62) 25.53,130.42 25.53,130.31 25.46,130.24 25.12,130.24 25.05,130.17 25.05,129.34 24.72,129.01 23.47,129.01 21.92,127.47 21.92,127.4 21.92,125.27 20.58,123.93 20.24,123.93 19.58,123.27 19.57,123.27 19.56,123.26
  IN4 w0.114: v2(39.8,61.99) 39.46,61.65 39.31,61.65 39.19,61.78 39.19,62.01 39.69,62.51 39.69,62.63 39.59,62.73 39.47,62.73 39.34,62.6 39.24,62.6 39.19,62.66 39.19,63.45 37.07,65.56 37.07,65.57 36.4,66.25 36.4,69.2 37.07,69.87 37.48,70.28 37.48,71.56 37.32,71.72 37.32,75.28 33.82,78.78 33.82,82.03 19.42,96.42 19.42,123.12 19.56,123.26
  BOTTOM w0.076: v6(25.33,130.62) 25.4,130.62 U0300.BJ9
  BOTTOM w0.159: CON1701.34 39.88,59.82 40.28,60.23 40.28,61.51 v2(39.8,61.99)
M_CHB_DQS1#: length 94.4
  TOP w0.159: v2(39.8,61.36) 39.27,61.89 39.27,62.52 40.37,63.62 40.75,63.62 41.38,64.24 CON1700.32
  IN4 w0.076: 19.47,123.46 19.54,123.46 20.18,124.09 20.51,124.09 21.75,125.34 21.75,127.34 21.75,127.54 23.4,129.18 24.65,129.18 24.88,129.41 24.88,130.87 v6(25.29,131.27)
  IN4 w0.114: 19.47,123.46 19.22,123.2 19.22,96.34 33.61,81.94 33.61,78.7 37.11,75.2 37.11,71.64 37.28,71.47 37.28,70.37 36.87,69.95 36.2,69.28 36.2,66.16 36.87,65.49 36.87,65.48 38.98,63.36 38.98,61.69 39.32,61.36 v2(39.8,61.36)
  BOTTOM w0.076: v6(25.29,131.27) 25.29,131.2 U0300.BL9
  BOTTOM w0.159: v2(39.8,61.36) 39.55,61.36 39.45,61.26 39.45,60.91 39.56,60.8 39.93,60.8 40.02,60.71 40.02,60.34 39.61,59.93 39.61,58.38 39.38,58.14 CON1701.32
M_CHB_DQS2: length 93.4
  TOP w0.159: v2(44.9,61.24) 45.38,60.76 45.38,60.49 47.13,58.74 CON1700.55
  IN4 w0.076: v6(28.92,130.62) 28.72,130.82 28.58,130.82 28.45,130.7 28.45,130.49 28.54,130.4 28.54,129.07 27.42,127.94 27.42,126.46 26.92,125.96 26.28,125.96 25.11,124.79 25.11,123.84 23.57,122.3 23.57,116.91
  IN4 w0.114: v2(44.9,61.24) 44.66,61.48 44.66,63.06 43.8,63.92 43.8,69.74 41.8,71.74 41.8,75.72 41.48,76.04 41.48,80.25 40.58,81.15 40.25,81.15 40.07,80.97 39.91,80.97 39.7,81.18 39.7,81.34 39.88,81.52 39.88,81.85 32.26,89.47 32.26,89.92 23.19,98.99 23.19,106.64 23.57,107.02 23.57,116.91
  BOTTOM w0.076: U0300.BF9 28.47,130.56 28.52,130.62 v6(28.92,130.62)
  BOTTOM w0.159: v2(44.9,61.24) 44.61,61.54 44.61,61.93 44.89,62.21 44.89,63.54 45.01,63.67 45.39,63.67 45.54,63.82 45.54,64.07 45.42,64.2 45.21,64.2 45.13,64.29 CON1701.55
M_CHB_DQS2#: length 93.4
  TOP w0.159: CON1700.53 46.63,58.08 46.5,58.21 46.25,58.21 46.13,58.33 46.13,58.49 46.23,58.59 46.58,58.59 46.69,58.69 46.69,58.82 44.9,60.6 v2(44.9,60.61)
  IN4 w0.076: v6(28.01,130.62) 28.38,130.25 28.38,129.13 27.25,128.01 27.25,126.53 26.85,126.13 26.21,126.13 24.94,124.86 24.94,123.91 23.4,122.37 23.4,117.01 23.37,116.97
  IN4 w0.114: 23.37,116.97 23.37,107.1 22.99,106.72 22.99,98.9 32.06,89.83 32.06,89.39 39.68,81.77 39.68,81.6 39.5,81.42 39.5,81.09 39.82,80.77 40.15,80.77 40.33,80.95 40.5,80.95 41.28,80.17 41.28,75.96 41.6,75.64 41.6,71.65 43.59,69.66 43.59,63.84 44.46,62.97 44.46,61.05 v2(44.9,60.61)
  BOTTOM w0.076: U0300.BG9 27.88,130.62 v6(28.01,130.62)
  BOTTOM w0.159: CON1701.53 44.63,62.32 44.3,61.99 44.3,61.21 v2(44.9,60.61)
M_CHB_DQS3: length 93
  TOP w0.159: CON1700.76 52.38,63.81 49.79,61.22 49.73,61.22 v2(49.45,60.94)
  IN4 w0.076: 27.46,117.59 27.46,119.47 29.98,121.99 29.98,125.73 30.33,126.07 30.33,128.34 30.84,128.85 30.96,128.85 31.29,129.19 31.29,130.25 v6(31.67,130.62)
  IN4 w0.114: v2(49.45,60.94) 49.77,60.94 49.86,61.03 49.86,63.02 49.12,63.76 49.12,68.6 48.57,69.15 48.57,73.62 46.4,75.79 46.4,77.74 46.03,78.1 46.03,83.5 27.8,101.74 27.8,114.89 27.46,115.23 27.46,117.59
  BOTTOM w0.076: v6(31.67,130.62) 31.53,130.62 U0300.BB9
  BOTTOM w0.159: CON1701.76 50.38,58.12 50.14,58.36 50.14,58.59 50.24,58.69 50.24,59.2 49.89,59.56 49.26,59.56 49.16,59.66 49.16,60.3 49.25,60.39 49.43,60.39 49.52,60.3 49.72,60.3 49.81,60.39 49.81,60.58 v2(49.45,60.94)
M_CHB_DQS3#: length 92.9
  TOP w0.159: CON1700.74 51.88,64.48 52.11,64.24 52.11,63.91 50.04,61.84 49.86,61.84 49.68,62.02 49.48,62.02 49.35,61.89 49.35,61.71 v2(49.45,61.61)
  IN4 w0.076: v6(30.75,130.62) 31.06,130.93 31.22,130.93 31.29,130.85 31.29,130.48 31.13,130.32 31.13,129.26 30.89,129.02 30.78,129.02 30.16,128.4 30.16,126.14 29.82,125.8 29.82,122.06 27.29,119.53 27.29,117.69 27.27,117.67 27.27,117.62 27.25,117.6 27.25,117.59
  IN4 w0.114: 27.25,117.59 27.25,115.15 27.59,114.81 27.59,101.65 45.83,83.42 45.83,78.02 46.2,77.65 46.2,75.71 48.37,73.54 48.37,69.07 48.92,68.51 48.92,63.68 49.66,62.94 49.66,61.82 v2(49.45,61.61)
  BOTTOM w0.076: U0300.BC9 30.29,130.51 30.4,130.62 v6(30.75,130.62)
  BOTTOM w0.159: CON1701.74 49.88,58.69 49.98,58.8 49.98,59.09 49.78,59.3 49.15,59.3 48.9,59.55 48.9,61.06 v2(49.45,61.61)
M_CHB_DQS4: length 101.1
  TOP w0.159: v2(80.7,62.18) 81.14,61.75 81.14,61.07 80,59.94 80,58.84 80.13,58.72 CON1700.179
  IN4 w0.076: v6(48.12,130.62) 47.7,130.62 47.63,130.55 47.63,130.44 47.74,130.32 47.74,129.06 48.26,128.54 48.26,122.49 53.13,117.62 53.13,117.04 53.14,117.03 53.14,115.13 53.94,114.33
  IN4 w0.114: v2(80.7,62.18) 80.52,62.01 80.32,62.01 80.18,62.15 80.18,64.38 82.19,66.38 82.19,68.11 84.05,69.97 84.05,71.96 83.53,72.47 83.53,77.05 82.57,78.01 82.57,79.93 82.74,80.1 82.74,84 79.65,87.09 79.65,88.62 69.43,98.84 69.23,98.84 68.92,98.53 68.75,98.53 68.55,98.73 68.55,98.9 68.82,99.17 68.82,99.45 68.51,99.76 68.1,99.76 67.89,99.55 67.73,99.55 67.52,99.76 67.52,99.92 67.83,100.23 67.83,100.44 65.03,103.24 64.19,103.24 63.28,104.15 63.28,104.99 53.94,114.33
  BOTTOM w0.076: U0300.AA9 47.99,130.62 v6(48.12,130.62)
  BOTTOM w0.159: CON1701.179 78.13,64.48 77.89,64.24 77.89,63.94 78.19,63.63 78.65,63.63 79.07,63.21 79.07,62.75 79.61,62.21 79.93,62.21 80.01,62.29 80.01,62.48 80.11,62.58 80.43,62.58 80.52,62.49 80.52,62.37 v2(80.7,62.18)
M_CHB_DQS4#: length 101.1
  TOP w0.159: v2(80.7,61.55) 80.88,61.37 80.88,61.18 80.78,61.08 80.39,61.08 80.26,60.95 80.26,60.57 79.74,60.05 79.74,58.73 79.86,58.61 79.86,58.47 79.78,58.39 79.45,58.39 79.38,58.31 79.38,58.17 79.63,57.92 CON1700.177
  IN4 w0.076: 53.76,114.22 52.98,115 52.98,116.96 52.97,116.97 52.97,117.55 48.1,122.43 48.1,128.47 47.58,128.99 47.58,130.25 v6(47.21,130.62)
  IN4 w0.114: 53.76,114.22 63.08,104.9 63.08,104.07 64.11,103.04 64.95,103.04 67.63,100.35 67.63,100.32 67.32,100.01 67.32,99.67 67.65,99.35 67.98,99.35 68.19,99.56 68.42,99.56 68.62,99.36 68.62,99.25 68.34,98.98 68.34,98.65 68.67,98.32 69,98.32 69.31,98.64 69.35,98.64 79.44,88.54 79.44,87.01 82.54,83.91 82.54,80.18 82.37,80.01 82.37,77.93 83.33,76.96 83.33,72.39 83.85,71.87 83.85,70.06 81.99,68.2 81.99,66.47 79.98,64.46 79.98,62.06 80.24,61.8 80.45,61.8 v2(80.7,61.55)
  BOTTOM w0.076: U0300.AC9 47.08,130.62 v6(47.21,130.62)
  BOTTOM w0.159: v2(80.7,61.55) 80.3,61.95 79.5,61.95 78.81,62.64 78.81,63.11 78.55,63.37 78.08,63.37 77.63,63.83 CON1701.177
M_CHB_DQS5: length 103.6
  TOP w0.159: CON1700.200 85.38,64.24 85.25,64.12 85.25,63.58 84.45,62.78 84.45,61.04 v2(83.36,59.96)
  IN4 w0.076: 57.66,116.53 57.66,117.02 55.17,119.51 54.59,119.51 52.31,121.79 51.83,121.79 50.5,123.12 50.5,130.25 50.87,130.62 v6(50.88,130.62)
  IN4 w0.114: v2(83.36,59.96) 83.54,59.96 83.67,60.09 83.67,60.27 83.75,60.34 83.94,60.34 84.45,59.83 84.72,59.83 85.09,60.21 85.09,60.8 84.44,61.45 84.44,63.55 87.7,66.81 87.7,68.22 88.52,69.04 88.52,73.4 88.16,73.76 88.16,77.51 87.41,78.26 87.41,82.2 86.9,82.71 86.9,87.63 64.17,110.36 63.85,110.36 62.97,111.24 62.12,111.24 57.66,115.7 57.66,116.53
  BOTTOM w0.076: U0300.V9 50.74,130.62 v6(50.88,130.62)
  BOTTOM w0.159: v2(83.36,59.96) 83.65,60.24 83.86,60.24 84,60.1 84,59.91 83.74,59.66 83.74,59.45 84.07,59.12 84.07,58.67 83.79,58.39 83.24,58.39 83.14,58.29 83.14,58.16 83.38,57.92 CON1701.200
M_CHB_DQS5#: length 103.6
  TOP w0.159: v2(83.36,60.59) 83.21,60.75 83.21,60.95 83.39,61.13 83.59,61.13 83.77,60.95 83.99,60.95 84.19,61.15 84.19,62.89 84.99,63.69 84.99,64.13 84.88,64.24 CON1700.198
  IN4 w0.076: v6(49.95,130.62) 50.11,130.78 50.41,130.78 50.5,130.7 50.5,130.48 50.33,130.32 50.33,123.05 51.76,121.62 52.24,121.62 54.52,119.34 55.1,119.34 57.46,116.99 57.46,116.53
  IN4 w0.114: 57.46,116.53 57.46,115.61 62.03,111.04 62.89,111.04 63.77,110.16 64.08,110.16 86.69,87.54 86.69,82.63 87.2,82.12 87.2,78.17 87.95,77.42 87.95,73.67 88.32,73.31 88.32,69.12 87.49,68.3 87.49,66.89 84.24,63.64 84.24,61.37 84.89,60.72 84.89,60.29 84.63,60.04 84.53,60.04 84.02,60.55 83.41,60.55 v2(83.36,60.59)
  BOTTOM w0.076: U0300.W9 49.82,130.62 v6(49.95,130.62)
  BOTTOM w0.159: CON1701.198 82.88,58.39 83.13,58.65 83.68,58.65 83.81,58.78 83.81,59.01 83.42,59.4 83.3,59.4 82.88,59.83 82.88,60.11 v2(83.36,60.59)
M_CHB_DQS6: length 104.3
  TOP w0.159: v2(89.08,61.36) 89.32,61.36 89.43,61.24 89.43,61 89.31,60.87 88.93,60.87 88.83,60.78 88.83,59.88 90.63,58.08 CON1700.221
  IN4 w0.076: v6(53.61,130.62) 53.61,130.49 53.24,130.13 53.24,129.15 53.47,128.92 53.65,128.92 54.19,128.38 54.19,125.43 54.78,124.85 54.78,123.32 56.25,121.85 61.84,121.85 62.59,121.09 62.65,121.09 62.75,120.99
  IN4 w0.114: v2(89.08,61.36) 89.83,62.11 89.83,63.48 92.65,66.3 92.65,70.32 93.09,70.76 93.09,79.29 92.51,79.86 92.51,83.45 92.19,83.78 91.18,83.78 91.08,83.87 91.08,85.54 91.17,85.62 92.15,85.62 92.39,85.87 92.39,87.87 65.89,114.37 65.89,117.85 62.75,120.99
  BOTTOM w0.076: v6(53.61,130.62) 53.48,130.62 U0300.P9
  BOTTOM w0.159: v2(89.08,61.36) 89.51,61.79 89.51,62.57 88.39,63.7 88.39,64.09 88.63,64.33 CON1701.221
M_CHB_DQS6#: length 104.3
  TOP w0.159: CON1700.219 90.13,58.21 88.57,59.77 88.57,61.48 v2(89.08,61.99)
  IN4 w0.076: 62.61,120.85 61.77,121.68 56.19,121.68 54.61,123.26 54.61,124.78 54.03,125.36 54.03,128.31 53.59,128.75 53.4,128.75 53.08,129.08 53.08,130.19 53.25,130.36 53.25,130.56 53.19,130.62 v6(52.7,130.62)
  IN4 w0.114: 62.61,120.85 65.68,117.77 65.68,114.29 92.19,87.78 92.19,85.95 92.06,85.82 91.08,85.82 90.88,85.62 90.88,83.78 91.09,83.57 92.11,83.57 92.31,83.37 92.31,79.78 92.88,79.21 92.88,70.84 92.44,70.41 92.44,66.38 89.63,63.56 89.63,62.19 89.33,61.89 89.18,61.89 v2(89.08,61.99)
  BOTTOM w0.076: U0300.R9 52.24,130.41 52.45,130.62 v6(52.7,130.62)
  BOTTOM w0.159: CON1701.219 88.13,63.59 88.95,62.76 88.95,62.55 88.82,62.42 88.52,62.42 88.39,62.3 88.39,62.09 88.49,61.99 v2(89.08,61.99)
M_CHB_DQS7: length 105.1
  TOP w0.159: CON1700.242 95.88,64.19 94.92,63.24 94.92,61.99 v2(93.78,60.85)
  IN4 w0.076: v6(56.33,130.62) 55.93,130.23 55.93,129.22 56.19,128.96 56.4,128.96 57.05,128.31 57.05,126.28 59.25,124.08 64.76,124.08 66.09,122.76
  IN4 w0.114: 66.09,122.76 66.19,122.66 67.19,122.66 70.63,119.22 70.63,114.72 73.74,111.6 78.26,107.09 96.88,88.47 96.88,87.51 98.32,86.06 98.32,75.04 97.33,74.06 97.33,72.34 97.51,72.17 97.51,69.35 96.85,68.69 96.85,64.91 95.91,63.97 95.91,62.47 95.71,62.27 95.22,62.27 94.89,62.6 94.54,62.6 94.39,62.44 94.39,61.46 v2(93.78,60.85)
  BOTTOM w0.076: U0300.L9 56.22,130.62 v6(56.33,130.62)
  BOTTOM w0.159: CON1701.242 93.88,58.19 93.6,58.46 93.6,60.26 93.7,60.37 94.04,60.37 94.15,60.47 94.15,60.75 94.04,60.85 v2(93.78,60.85)
M_CHB_DQS7#: length 105.2
  TOP w0.159: v2(93.78,61.48) 93.6,61.66 93.6,61.92 93.75,62.07 94.03,62.07 94.26,61.84 94.4,61.84 94.66,62.1 94.66,63.35 95.38,64.06 CON1700.240
  IN4 w0.076: 65.95,122.61 65.94,122.62 65.94,122.65 65.91,122.68 65.91,122.71 64.7,123.92 59.18,123.92 56.89,126.21 56.89,128.24 56.33,128.79 56.12,128.79 55.77,129.15 55.77,130.3 55.96,130.49 55.96,130.72 55.91,130.77 55.73,130.77 55.58,130.62 v6(55.45,130.62)
  IN4 w0.114: v2(93.78,61.48) 94.12,61.48 94.18,61.54 94.18,62.53 94.46,62.8 94.97,62.8 95.3,62.47 95.62,62.47 95.71,62.56 95.71,64.05 96.65,64.99 96.65,68.77 97.31,69.43 97.31,72.08 97.13,72.26 97.13,74.14 98.12,75.13 98.12,85.98 96.67,87.43 96.67,88.38 78.26,106.8 73.46,111.6 70.42,114.63 70.42,119.13 67.11,122.45 66.11,122.45 65.95,122.61
  BOTTOM w0.076: v6(55.45,130.62) 55.31,130.62 U0300.M9
  BOTTOM w0.159: v2(93.78,61.48) 93.34,61.05 93.34,58.35 93.38,58.32 CON1701.240
M_CHB_MAA0: length 102
  TOP w0.222: CON1700.144 69.38,63.7 69.51,63.56 69.92,63.56 70.08,63.72 70.08,64.97 70.26,65.15 70.6,65.15 70.76,64.99 70.76,62.66 v2(70.59,62.49)
  IN4 w0.076: v6(41.75,129.96) 42.09,129.62 42.09,128.94 42.5,128.52 42.5,115.37 42.64,115.23
  IN4 w0.152: v2(70.59,62.49) 70.59,62.49 70.59,72.09 70.22,72.46 70.22,72.98 70.75,73.5 70.75,76.54 70.47,76.82 70.47,77.12 70.33,77.26 70.03,77.26 69.9,77.39 69.9,77.76 70.05,77.92 70.41,77.92 70.51,78.02 70.51,78.32 70.41,78.42 69.75,78.42 69.67,78.5 69.67,78.88 69.77,78.99 70.39,78.99 70.51,79.11 70.51,79.34 70.39,79.47 69.8,79.47 69.67,79.6 69.67,79.82 69.77,79.93 70.33,79.93 70.51,80.1 70.51,80.31 70.36,80.46 69.88,80.46 69.67,80.66 69.67,80.93 69.11,81.49 69.11,83.72 68.65,84.19 68.65,84.47 69.1,84.92 69.1,85.09 68.89,85.31 68.71,85.31 68.25,84.85 67.99,84.85 67.36,85.48 67.36,85.69 67.84,86.17 67.84,86.35 67.39,86.81 67.11,86.81 66.67,86.37 66.46,86.37 45.07,107.76 45.07,109.4 43.36,111.11 43.36,114.51 42.64,115.23
  BOTTOM w0.076: v6(41.75,129.96) 41.6,129.96 U0300.AJ9
  BOTTOM w0.222: v2(70.59,62.49) 71.06,62.02 71.06,61.3 67.94,58.17 67.53,58.17 67.38,58.02 CON1701.144
M_CHB_MAA1: length 98.7
  TOP w0.222: v2(68.83,61.26) 68.6,61.26 68.3,60.96 68.3,60.09 68.12,59.91 66.35,59.91 66.12,59.68 66.12,59.12 66.63,58.61 CON1700.133
  IN4 w0.076: 41.27,122.04 41.19,122.13 41.19,125.07 41.6,125.49 41.6,127.66 v6(41.95,128.01)
  IN4 w0.152: v2(68.83,61.26) 69.29,61.26 69.6,61.57 69.6,65.63 69.1,66.13 69.1,68.21 69.6,68.71 69.6,71.68 69.23,72.05 69.23,76.66 68.86,77.03 68.86,77.43 68.67,77.62 68.67,80.52 67.02,82.17 67.02,83.28 66.75,83.55 66.75,83.77 67.1,84.12 67.1,84.33 66.77,84.66 66.56,84.66 66.21,84.31 65.99,84.31 65.67,84.63 65.67,84.85 66.02,85.19 66.02,85.41 65.69,85.73 65.48,85.73 65.13,85.38 64.91,85.38 64.59,85.71 64.59,85.92 64.94,86.27 64.94,86.49 64.62,86.81 64.4,86.81 64.05,86.46 63.84,86.46 44.08,106.22 44.08,108.99 42.33,110.74 42.33,110.76 42.27,110.82 42.27,114.6 41.8,115.06 41.8,121.14 41.27,121.68 41.27,122.04
  BOTTOM w0.076: v6(41.95,128.01) 41.04,128.01 U0300.AK6
  BOTTOM w0.222: CON1701.133 64.63,63.17 65.22,62.58 66.64,62.58 67.97,61.26 v2(68.83,61.26)
M_CHB_MAA2: length 97
  TOP w0.222: CON1700.132 66.38,63.1 65.73,62.46 65.73,61.17 65.98,60.91 65.98,60.24 65.76,60.01 v2(65.41,60.01) ; v1(40.87,125.37) 40.87,125.85 v6(41.07,126.05)
  IN4 w0.076: v6(41.07,126.05) 41.02,126 41.02,121.53
  IN4 w0.152: v2(65.41,60.01) 65.41,58.51 65.87,58.05 67.96,58.05 68.27,58.36 68.27,61.39 69.1,62.23 69.1,65.43 68.6,65.93 68.6,68.42 69.1,68.92 69.1,71.48 68.73,71.85 68.73,76.45 68.33,76.86 68.33,77.26 68.17,77.41 68.17,80.31 66.29,82.19 66.29,83.3 43.59,106.01 43.59,107.26 42.64,108.2 42.64,109.7 41.77,110.57 41.77,114.65 41.56,114.86 41.56,120.99 41.02,121.53
  BOTTOM w0.076: v6(41.07,126.05) 41.07,127.6 40.99,127.69 U0300.AK5
  BOTTOM w0.222: CON1701.132 64.38,58.17 65.41,59.2 v2(65.41,60.01)
M_CHB_MAA3: length 94.2
  TOP w0.222: CON1700.131 66.13,58.49 65.49,59.13 65.17,59.13 64.79,59.51 64.79,59.83 64.41,60.2 64.41,60.67 64.59,60.85 65.2,60.85 v2(65.41,60.64)
  IN4 w0.076: v6(39.47,127.36) 39.27,127.16 39.27,125.54 38.65,124.91 38.65,116.31 37.93,115.59 37.93,115.32
  IN4 w0.152: 37.93,115.32 37.93,105.38 57.29,86.02 57.29,84.3 58.97,82.63 58.97,81.17 61.09,79.04 61.09,78.85 61.26,78.69 61.26,78.47 60.98,78.2 60.98,77.98 61.3,77.66 61.52,77.66 61.79,77.94 62.01,77.94 64.3,75.65 64.3,73.51 64.21,73.42 63.78,73.42 63.65,73.3 63.65,72.05 63.83,71.87 64.17,71.87 64.29,71.75 64.29,71.47 64.19,71.36 63.75,71.36 63.65,71.26 63.65,70.4 64.15,69.9 64.15,69.09 65.08,68.15 65.08,66.03 64.93,65.88 64.85,65.88 64.7,65.74 64.7,65.53 64.85,65.38 64.93,65.38 65.08,65.24 65.08,65.03 64.93,64.89 64.85,64.89 64.7,64.74 64.7,64.54 64.85,64.39 64.93,64.39 65.08,64.25 65.08,64.04 64.93,63.9 64.85,63.9 64.7,63.75 64.7,62.97 65.31,62.37 65.31,60.75 v2(65.41,60.64)
  BOTTOM w0.076: U0300.AL5 39.8,127.69 v6(39.47,127.36)
  BOTTOM w0.222: v2(65.41,60.64) 65.41,61.59 64.06,62.94 64.06,64.19 64.13,64.26 CON1701.131
M_CHB_MAA4: length 94.4
  TOP w0.222: v1(39.88,128.54) 39.88,128.42 v6(39.47,128.01) ; v2(64.81,61.34) 65.13,61.66 65.13,64.03 65.38,64.28 CON1700.128
  IN4 w0.076: v6(39.47,128.01) 39.07,127.61 39.07,125.57 38.45,124.94 38.45,119.32 38.33,119.2
  IN4 w0.152: v2(64.81,61.34) 64.81,62.14 64.21,62.75 64.21,68.32 63.65,68.88 63.65,69.7 63.34,70.01 63.16,70.19 63.16,75.16 62.04,76.28 61.86,76.28 59.48,78.66 58.77,78.66 58.32,79.11 58.32,82.58 56.8,84.1 56.8,85.81 37.44,105.17 37.44,116.13 37.54,116.23 38.25,116.23 38.33,116.31 38.33,116.63 38.23,116.73 37.44,116.73 37.36,116.8 37.36,117.12 37.47,117.22 38.3,117.22 38.43,117.35 38.43,117.59 38.3,117.72 37.41,117.72 37.31,117.82 37.31,118.12 37.41,118.23 38.33,118.23 38.41,118.3 38.41,118.56 38.3,118.66 38.07,118.66 37.99,118.74 37.99,118.87 38.33,119.2
  BOTTOM w0.076: v6(39.47,128.01) 39.8,128.34 U0300.AL6
  BOTTOM w0.222: v2(64.81,61.34) 64.81,59.4 63.79,58.38 63.5,58.38 63.38,58.26 CON1701.128
M_CHB_MAA5: length 95.2
  TOP w0.222: v6(38.64,128.01) 38.64,127.96 38.51,127.84 v1(38.51,127.37) ; CON1700.126 64.88,64.43 64.57,64.12 64.57,61.91 63.93,61.28 63.93,60.36 v2(63.68,60.1)
  IN4 w0.076: 37.91,119.58 38.12,119.79 38.12,126.17 38.64,126.69 v6(38.64,128.01)
  IN4 w0.152: v2(63.68,60.1) 64.24,60.1 64.3,60.16 64.3,60.41 63.79,60.92 63.79,61.76 63.22,62.33 63.22,67.91 62.66,68.47 62.66,69.29 62.17,69.78 62.17,72.94 61.78,73.33 61.78,74.96 59.07,77.67 58.36,77.67 57.71,78.33 57.46,78.33 56.88,77.75 56.76,77.75 56.54,77.97 56.54,78.18 57.33,78.96 57.33,79.41 56.81,79.93 56.81,80.99 56.95,81.14 57.18,81.14 57.33,81.28 57.33,81.49 57.18,81.63 56.95,81.63 56.81,81.78 56.81,82.69 55.81,83.69 55.81,85.4 36.45,104.76 36.45,118.12 37.91,119.58
  BOTTOM w0.076: U0300.AM6 38.96,128.34 v6(38.64,128.01)
  BOTTOM w0.222: v2(63.68,60.1) 63.48,59.91 63.48,59.6 63.75,59.32 63.75,59.17 63.6,59.02 63.4,59.02 63.18,59.24 63.01,59.24 62.88,59.11 CON1701.126
M_CHB_MAA6: length 96.7
  TOP w0.222: v2(64.19,59.58) 64.19,59.51 65.13,58.57 CON1700.127 ; v6(38.98,129.33) 38.95,129.35 v1(38.18,129.35)
  IN4 w0.076: 38.06,119.37 38.28,119.59 38.28,125.01 38.91,125.64 38.91,127.69 39.09,127.88 39.09,128.7 38.98,128.81 v6(38.98,129.33)
  IN4 w0.152: 38.06,119.37 36.94,118.25 36.94,104.97 56.3,85.61 56.3,83.89 57.82,82.37 57.82,78.91 58.57,78.16 59.27,78.16 61.65,75.79 61.84,75.79 62.66,74.96 62.66,69.99 63.16,69.49 63.16,68.68 63.71,68.12 63.71,62.54 64.29,61.97 64.29,61.13 64.8,60.62 64.8,58.21 64.67,58.08 64.26,58.08 64.19,58.16 v2(64.19,59.58)
  BOTTOM w0.076: v6(38.98,129.33) 38.85,129.33 U0300.AN7
  BOTTOM w0.222: CON1701.127 63.13,64.26 63.49,63.9 63.49,62.7 64.24,61.95 64.24,59.64 v2(64.19,59.58)
M_CHB_MAA7: length 100.9
  TOP w0.222: CON1700.122 63.88,62.1 62.56,60.78 62.56,60.7 v2(62.31,60.44)
  IN4 w0.076: v6(38.98,131.27) 38.61,130.9 38.61,129.83 38.43,129.64 38.43,128.87 38.1,128.54 38.1,126.63 37.72,126.24 37.72,121.11
  IN4 w0.152: 37.72,121.11 35.35,118.74 35.35,115.77 35.46,115.66 35.46,104.35 54.82,84.99 54.82,80.37 54.83,80.36 54.83,78.22 56.28,76.76 57.88,76.76 60.79,73.85 60.79,69.76 61.67,68.88 61.67,66.29 62.23,65.73 62.23,61.92 62.8,61.35 62.8,58.43 62.7,58.33 62.38,58.33 62.31,58.41 v2(62.31,60.44)
  BOTTOM w0.076: U0300.AN10 38.85,131.27 v6(38.98,131.27)
  BOTTOM w0.222: CON1701.122 61.88,58.13 62.31,58.56 62.31,58.91 62.2,59.02 61.82,59.02 61.68,59.17 61.68,59.69 61.82,59.83 62.78,59.83 62.92,59.97 62.92,60.26 62.74,60.44 v2(62.31,60.44)
M_CHB_MAA8: length 94.9
  TOP w0.222: CON1700.125 64.63,58.27 63.11,59.78 63.11,60.54 v2(63.3,60.72)
  IN4 w0.076: 37.73,119.89 37.93,120.08 37.93,126.22 38.27,126.56 38.27,128.47 38.59,128.8 38.59,129.57 38.98,129.96 v6(38.98,129.97)
  IN4 w0.152: v2(63.3,60.72) 63.3,61.56 62.72,62.13 62.72,65.94 62.17,66.49 62.17,69.08 61.67,69.58 61.67,70.43 61.53,70.57 61.4,70.57 61.28,70.69 61.28,71.36 61.39,71.47 61.52,71.47 61.67,71.62 61.67,72.74 61.28,73.12 61.28,74.06 60.46,74.88 60.46,75.09 60.6,75.23 60.6,75.43 60.46,75.58 60.25,75.58 60.11,75.44 59.9,75.44 59.76,75.58 59.76,75.79 59.9,75.93 59.9,76.14 59.75,76.28 59.55,76.28 59.41,76.14 59.2,76.14 59.06,76.28 59.06,76.49 59.2,76.63 59.2,76.84 59.05,76.98 58.85,76.98 58.71,76.84 58.5,76.84 58.08,77.26 56.48,77.26 55.32,78.42 55.32,83.47 55.31,83.48 55.31,85.2 35.95,104.56 35.95,114.76 36.19,115 36.19,118.35 37.73,119.89
  BOTTOM w0.076: U0300.AN8 38.85,129.97 v6(38.98,129.97)
  BOTTOM w0.222: CON1701.125 62.63,63.97 62.93,63.66 62.93,61.92 63.3,61.55 v2(63.3,60.72)
M_CHB_MAA9: length 95.3
  TOP w0.222: v2(61.11,61.35) 61.11,60.8 61.96,59.95 62.15,59.95 63.63,58.47 CON1700.121
  IN4 w0.076: 36.71,120.91 36.82,121.02 36.82,123.88 37.38,124.43 37.38,126.37 37.77,126.76 37.77,128.68 37.85,128.76 37.85,129.66 37.69,129.82 37.69,131.39 v6(37.15,131.92)
  IN4 w0.152: v2(61.11,61.35) 61.11,65.45 60.68,65.88 60.68,68.47 59.8,69.35 59.8,73.44 57.47,75.77 55.87,75.77 53.42,78.22 53.42,84.99 34.47,103.94 34.47,118.67 36.71,120.91
  BOTTOM w0.076: v6(37.15,131.92) 37.02,131.92 U0300.AR11
  BOTTOM w0.222: v2(61.11,61.35) 61.6,61.84 62.13,61.84 62.36,62.07 62.36,63.43 61.99,63.8 61.99,64.03 61.63,64.4 CON1701.121
M_CHB_MAA10: length 96.2
  TOP w0.222: CON1700.146 71.88,64.3 71.28,63.71 v2(71.28,60.35)
  IN4 w0.076: v6(42.64,129.32) 42.64,128.92 42.83,128.73 42.83,126.33 42.84,126.32 42.84,118.66 42.92,118.58
  IN4 w0.152: 42.92,118.58 44.42,117.08 44.42,111.45 46.06,109.81 46.06,108.18 66.44,87.8 67.8,87.8 70.93,84.67 70.93,83.8 70.49,83.36 70.49,81.74 71.5,80.73 71.5,77.19 71.77,76.92 71.77,73.68 72.16,73.29 72.16,72.47 72.66,71.97 72.66,70.93 71.58,69.84 71.58,61.87 70.59,60.88 70.59,59.59 70.83,59.35 71.15,59.35 71.28,59.49 v2(71.28,60.35)
  BOTTOM w0.076: v6(42.64,129.32) 42.51,129.32 U0300.AH7
  BOTTOM w0.222: CON1701.146 69.88,57.95 69.39,58.43 69.39,58.95 70.79,60.35 v2(71.28,60.35)
M_CHB_MAA11: length 102.4
  TOP w0.222: v2(62.16,61.24) 62.16,61.24 63.38,62.45 CON1700.120
  IN4 w0.076: v6(38.98,131.92) 38.45,131.39 38.45,129.9 38.25,129.69 38.25,128.92 37.94,128.61 37.94,126.69 37.54,126.3 37.54,124.37 36.98,123.81 36.98,120.8
  IN4 w0.152: 36.98,120.8 34.96,118.78 34.96,104.15 54.32,84.79 54.32,80.16 54.33,80.15 54.33,78.01 56.07,76.27 57.67,76.27 60.29,73.65 60.29,69.55 61.18,68.67 61.18,66.08 61.65,65.61 61.65,61.44 61.61,61.4 61.61,61.15 59.89,59.44 59.89,58.31 60.05,58.16 60.38,58.16 60.5,58.28 60.5,59.3 62.16,60.96 v2(62.16,61.24)
  BOTTOM w0.076: U0300.AN11 38.85,131.92 v6(38.98,131.92)
  BOTTOM w0.222: v2(62.16,61.24) 61.91,61.24 61.11,60.44 61.11,58.66 61.38,58.4 CON1701.120
M_CHB_MAA12: length 97
  TOP w0.222: v2(60.51,62.64) 60.33,62.64 59.9,62.2 59.9,61.21 61.73,59.39 61.91,59.39 63.13,58.17 CON1700.119
  IN4 w0.076: 36.56,121.12 36.65,121.21 36.65,123.94 37.21,124.5 37.21,126.44 37.61,126.83 37.61,128.75 37.69,128.83 37.69,129.59 37.52,129.75 37.52,130.9 v6(37.15,131.27)
  IN4 w0.152: v2(60.51,62.64) 60.51,65.35 60.15,65.71 60.15,65.99 59.25,66.89 59.25,67.96 59.35,68.06 59.74,68.06 59.87,68.19 59.87,68.58 59.77,68.67 59.36,68.67 59.25,68.78 59.25,71.79 58.93,72.11 58.93,73.18 56.84,75.28 55.66,75.28 52.93,78.01 52.93,84.78 33.95,103.75 33.95,118.52 36.56,121.12
  BOTTOM w0.076: U0300.AR10 37.02,131.27 v6(37.15,131.27)
  BOTTOM w0.222: CON1701.119 61.13,64.04 60.99,63.9 60.63,63.9 60.46,63.73 60.46,63.4 60.6,63.26 61.11,63.26 61.27,63.41 61.58,63.41 61.8,63.19 61.8,62.6 61.65,62.45 60.93,62.45 60.75,62.64 v2(60.51,62.64)
M_CHB_MAA13: length 98.1
  TOP w0.222: CON1700.158 74.88,63.8 73.89,62.82 73.89,62.33 73.55,61.99 73.55,60.93 73.64,60.83 73.64,60.1 73.38,59.83 v2(73.18,59.83)
  IN4 w0.076: 43.77,119.62 43.64,119.75 43.64,124.57 44.25,125.18 44.25,128.07 43.95,128.37 43.95,129.49 v6(44.45,129.99)
  IN4 w0.152: 43.77,119.62 46.53,116.86 46.53,112.14 48.04,110.63 48.04,109 64.68,92.36 66.05,92.36 72.99,85.41 72.99,83.41 73.48,82.92 73.48,78.01 74.23,77.26 74.23,74.76 74.68,74.31 74.68,72.03 75.08,71.62 75.08,71.57 75.21,71.44 75.21,70.43 73.99,69.21 73.99,66.18 73.58,65.77 73.58,62.46 73.08,61.95 73.08,61.18 72.64,60.75 72.64,60.15 72.96,59.83 v2(73.18,59.83)
  BOTTOM w0.076: U0300.AF9 44.32,129.99 v6(44.45,129.99)
  BOTTOM w0.222: v2(73.18,59.83) 73.05,59.83 72.77,59.56 72.77,59.23 72.87,59.12 73.13,59.12 73.36,59.35 73.48,59.35 73.61,59.23 73.61,58.46 73.43,58.29 73.25,58.29 73,58.54 72.82,58.54 72.7,58.42 72.7,58.18 72.88,58 CON1701.158
M_CHB_MAA14: length 95
  TOP w0.222: v2(73.08,62.65) 72.88,62.45 72.88,61.11 72.44,60.67 72.44,59.4 73.13,58.72 CON1700.151
  IN4 w0.076: v6(42.64,131.92) 43.17,131.39 43.17,129.83 43.34,129.67 43.34,128.75 43.97,128.11 43.97,125.82 43.48,125.33 43.48,119.41
  IN4 w0.152: 43.48,119.41 45.97,116.91 45.97,112 47.55,110.42 47.55,108.79 64.59,91.75 65.95,91.75 72.5,85.2 72.5,83.21 72.99,82.72 72.99,77.8 73.73,77.06 73.73,73.91 74.18,73.46 74.18,71.22 74.54,70.86 74.54,70.46 73.49,69.42 73.49,66.38 73.08,65.97 73.08,62.65 v2(73.08,62.65)
  BOTTOM w0.076: U0300.AH11 42.51,131.92 v6(42.64,131.92)
  BOTTOM w0.222: v2(73.08,62.65) 72.11,62.65 71.13,63.64 CON1701.151
M_CHB_MAA15: length 100.9
  TOP w0.222: v2(73.18,60.47) 73.2,60.47 73.24,60.51 73.24,62.12 73.54,62.43 73.54,63.27 74.38,64.1 CON1700.156
  IN4 w0.076: 44.48,119.43 44.48,128.16 44.11,128.52 44.11,129.25 44.2,129.33 v6(44.47,129.33)
  IN4 w0.152: v2(73.18,60.47) 73.2,60.47 73.57,60.84 73.57,61.75 74.09,62.27 74.09,65.58 74.49,65.97 74.49,69.01 75.82,70.34 75.82,71.57 75.54,71.85 75.54,73.29 75.62,73.37 75.9,73.37 76.03,73.51 76.03,73.92 75.92,74.03 75.73,74.03 75.47,74.29 75.47,74.51 75.17,74.81 74.88,74.81 74.72,74.96 74.72,75.17 74.83,75.28 75.02,75.28 75.1,75.35 75.1,75.87 75.26,76.04 75.46,76.04 75.59,75.91 75.59,75.33 75.74,75.17 75.92,75.17 76.03,75.28 76.03,76.28 74.46,77.85 74.46,79.38 73.98,79.86 73.98,83.13 73.49,83.62 73.49,85.61 66.25,92.85 64.89,92.85 64.79,92.95 64.79,93.15 65.26,93.63 65.26,93.83 65.12,93.98 64.91,93.98 64.44,93.51 64.24,93.51 64.09,93.65 64.09,93.86 64.56,94.33 64.56,94.53 64.42,94.68 64.21,94.68 63.86,94.33 63.51,94.33 48.54,109.3 48.54,110.83 47.07,112.31 47.07,116.84 44.48,119.43
  BOTTOM w0.076: v6(44.47,129.33) 44.33,129.33 U0300.AF8
  BOTTOM w0.222: v2(73.18,60.47) 73.07,60.47 72.38,59.77 CON1701.156
M_CHB_MAA16: length 95.1
  TOP w0.222: CON1700.152 73.38,64.06 72.45,63.13 72.45,61.34 v2(72.41,61.31)
  IN4 w0.076: v6(42.64,131.27) 43.01,130.9 43.01,129.76 43.17,129.6 43.17,119.2 43.25,119.12
  IN4 w0.152: v2(72.41,61.31) 72.58,61.48 72.58,69.44 73.66,70.52 73.66,72.38 73.15,72.88 73.15,73.24 73.24,73.32 73.24,74.58 73.09,74.73 72.9,74.73 72.76,74.87 72.76,75.08 72.9,75.22 73.09,75.22 73.24,75.37 73.24,75.57 73.09,75.72 72.9,75.72 72.76,75.86 72.76,76.07 72.9,76.21 73.09,76.21 73.24,76.36 73.24,76.85 72.49,77.6 72.49,82.51 71.92,83.09 71.92,85.08 71.28,85.72 65.75,91.25 64.39,91.25 47.05,108.59 47.05,110.22 45.48,111.79 45.48,116.89 43.25,119.12
  BOTTOM w0.076: U0300.AH10 42.51,131.27 v6(42.64,131.27)
  BOTTOM w0.222: v2(72.41,61.31) 72.41,60.8 72.16,60.55 72.16,60.05 71.38,59.27 CON1701.152
M_CHB_ODT0: length 96.7
  TOP w0.222: v2(74.42,61.52) 74.18,61.52 73.96,61.3 73.96,58.38 74.13,58.21 CON1700.155
  IN4 w0.076: 44.68,125.34 44.68,128.54 v6(44.48,128.73)
  IN4 w0.121: v2(74.42,61.52) 74.74,61.84 74.74,65.49 74.97,65.71 74.97,68.81 76.3,70.14 76.3,71.48 76.51,71.7 76.51,76.48 74.94,78.05 74.94,79.58 74.46,80.06 74.46,83.33 73.97,83.82 73.97,85.81 66.42,93.36 65.82,93.36 65.74,93.44 65.74,94.04 64.42,95.36 63.95,95.36 63.86,95.26 63.86,95 63.75,94.89 63.63,94.89 49.02,109.5 49.02,111.03 47.63,112.43 47.63,116.85 45.49,118.99 45.49,119.32 45.24,119.57 44.78,119.57 44.7,119.65 44.7,119.83 44.82,119.95 45.68,119.95 45.8,120.07 45.8,120.25 45.68,120.37 44.82,120.37 44.7,120.5 44.7,120.68 44.82,120.8 45.78,120.8 45.9,120.92 45.9,121.1 45.78,121.23 44.82,121.23 44.7,121.35 44.7,121.53 44.82,121.65 45.37,121.65 45.49,121.77 45.49,121.96 45.37,122.08 44.82,122.08 44.7,122.2 44.7,122.38 44.82,122.5 45.17,122.5 45.29,122.62 45.29,122.81 45.17,122.93 44.82,122.93 44.7,123.05 44.7,123.23 44.82,123.35 45.17,123.35 45.29,123.47 45.29,123.66 45.17,123.78 44.82,123.78 44.7,123.9 44.7,124.07 44.81,124.17 45.21,124.17 45.29,124.25 45.29,124.47 45.19,124.58 44.78,124.58 44.68,124.68 44.68,125.34
  BOTTOM w0.076: U0300.AF7 44.23,129 44.48,128.75 v6(44.48,128.73)
M_CHB_ODT1: length 97
  TOP w0.222: v2(76.74,62.36) 76.49,62.36 76.17,62.04 76.17,61.36 76.51,61.03 76.51,58.69 76.15,58.34 75.83,58.34 75.63,58.13 CON1700.161
  IN4 w0.076: v6(45.38,129.97) 45.61,129.97 45.74,129.84 45.74,128.61 45.38,128.25 45.38,125.67 46.05,125 46.05,122.36 46.17,122.24 46.17,121.89 46.76,121.3 46.76,120.26
  IN4 w0.121: v2(76.74,62.36) 76.75,62.36 76.76,62.36 76.76,65.8 77.58,66.62 77.58,66.77 77.53,66.82 77.17,66.82 77.07,66.91 77.07,67.06 77.19,67.17 77.5,67.17 77.58,67.26 77.58,68.35 78.67,69.44 78.67,71.67 78.62,71.72 78.35,71.72 78.21,71.85 78.21,72 78.31,72.1 78.59,72.1 78.67,72.18 78.67,72.38 78.57,72.47 78.32,72.47 78.21,72.58 78.21,72.75 78.3,72.84 78.51,72.84 78.67,72.99 78.67,75.45 78.54,75.58 78.31,75.58 78.21,75.67 78.21,75.88 78.28,75.95 78.61,75.95 78.67,76.01 78.67,76.32 78.61,76.37 78.33,76.37 78.21,76.5 78.21,76.68 78.31,76.77 78.56,76.77 78.67,76.88 78.67,77.1 78.59,77.18 78.36,77.18 78.28,77.26 78.28,77.41 78.54,77.66 78.54,77.78 78.41,77.91 78.28,77.91 78,77.63 77.77,77.63 77.69,77.71 77.69,77.88 77.85,78.04 77.85,78.21 77.72,78.34 77.55,78.34 77.39,78.18 77.22,78.18 77.07,78.33 77.07,78.62 77.19,78.74 77.53,78.74 77.65,78.86 77.65,79.05 77.53,79.17 77.19,79.17 77.07,79.29 77.07,79.91 77.23,80.07 77.23,81.04 77.11,81.15 77.11,81.59 77.25,81.73 77.25,82.25 77.11,82.39 77.11,83.69 76.67,84.12 76.27,84.12 76.14,84.26 76.14,86.05 65.12,97.06 63.88,97.06 58.18,102.76 58.18,104.01 53.26,108.93 53.26,110.15 49.48,113.92 49.48,117.54 46.76,120.26
  BOTTOM w0.076: U0300.AE8 45.25,129.97 v6(45.38,129.97)
M_CHB_ODT2: length 99.7
  IN4 w0.076: 47.05,120.45 46.94,120.56 46.94,121.35 46.34,121.95 46.34,122.33 46.22,122.45 46.22,125.07 45.55,125.74 45.55,128.18 45.91,128.54 45.91,129.97 45.38,130.49 v6(45.38,130.62)
  IN4 w0.121: 47.05,120.45 49.94,117.57 49.94,114.07 53.68,110.32 53.68,109.11 56.43,106.36 56.6,106.36 57.04,106.79 57.21,106.79 57.38,106.62 57.38,106.45 56.94,106.02 56.94,105.85 57.11,105.68 57.28,105.68 57.72,106.11 57.89,106.11 58.06,105.94 58.06,105.77 57.63,105.34 57.63,105.17 57.8,105 57.97,105 58.25,105.28 58.37,105.28 58.61,105.04 58.61,102.94 60.46,101.09 60.48,101.09 64.08,97.49 65.3,97.49 76.56,86.23 76.56,84.83 77.53,83.86 77.53,83.29 77.7,83.12 78.08,83.12 78.24,82.97 78.24,82.15 78.03,81.95 77.79,81.95 77.67,81.83 77.67,81.65 77.79,81.53 77.96,81.53 78.08,81.4 78.08,81.22 77.96,81.1 77.79,81.1 77.67,80.98 77.67,80.8 77.79,80.67 77.96,80.67 78.08,80.55 78.08,80.37 77.96,80.25 77.79,80.25 77.67,80.13 77.67,79.94 77.79,79.82 77.96,79.82 78.08,79.7 78.08,78.58 78.32,78.34 78.85,78.34 79.04,78.15 79.04,77.68 79.09,77.62 79.09,69.26 78.01,68.18 78.01,66.45 77.18,65.62 77.18,61.24 76.96,61.02 76.08,61.02 75.98,60.92 v2(75.98,60.65)
  BOTTOM w0.076: v6(45.38,130.62) 45.25,130.62 U0300.AE9
  BOTTOM w0.222: v2(75.98,60.65) 74.98,61.64 74.98,61.65 73.34,63.3 73.04,63.3 72.13,64.21 CON1701.155
M_CHB_ODT3: length 99.7
  IN4 w0.076: 47.32,121.18 47.27,121.23 47.27,125.26 46.5,126.04 46.5,128.28 46.24,128.54 46.24,130.21 45.92,130.53 45.92,131.39 v6(45.38,131.92)
  IN4 w0.121: v2(75.98,59.39) 76.54,59.39 78.03,60.89 78.03,65.27 78.86,66.09 78.86,67.82 80.6,69.57 80.6,76.91 80.42,77.09 80.42,77.7 79.89,78.23 79.89,79.91 79.09,80.72 79.09,83.51 77.5,85.1 77.5,86.5 65.65,98.34 64.44,98.34 60.68,102.1 60.68,104.55 60.48,104.75 60.31,104.75 59.84,104.28 59.7,104.28 59.53,104.45 59.53,104.65 59.97,105.09 59.97,105.26 50.8,114.43 50.8,117.7 47.32,121.18
  BOTTOM w0.076: U0300.AE11 45.25,131.92 v6(45.38,131.92)
  BOTTOM w0.222: v2(75.98,59.39) 76.01,59.39 76.77,60.15 76.77,61.02 73.63,64.16 CON1701.161
M_CHB_PAR: length 99.7
  TOP w0.222: CON1700.143 69.13,58.44 69.38,58.69 69.38,59.06 69.11,59.32 69.11,59.7 69.27,59.86 69.88,59.86 70.02,60.01 70.02,61.21 69.93,61.31 69.55,61.31 69.44,61.2 69.44,60.6 69.32,60.47 68.95,60.47 68.81,60.62 68.82,60.62 v2(68.82,60.62)
  IN4 w0.076: 42.34,115.17 42.34,128.46 41.72,129.07 v6(41.72,129.32)
  IN4 w0.152: v2(68.82,60.62) 68.82,59.19 68.96,59.04 69.75,59.04 70.09,59.39 70.09,65.84 69.59,66.34 69.59,68.01 70.09,68.51 70.09,71.89 69.72,72.26 69.72,73.18 70.25,73.71 70.25,76.34 69.35,77.23 69.35,77.65 69.16,77.84 69.16,80.74 68.62,81.29 68.62,83.52 44.58,107.56 44.58,109.19 42.82,110.95 42.82,114.69 42.34,115.17
  BOTTOM w0.076: v6(41.72,129.32) 41.59,129.32 U0300.AJ7
  BOTTOM w0.222: CON1701.143 67.13,64.32 67.24,64.21 68.38,64.21 68.62,63.97 68.62,62.22 69.33,61.5 69.33,60.88 69.08,60.62 v2(68.82,60.62)
MB_ID0: length 16.2
  TOP w0.102: v2(168.21,44.9) 167.55,44.24 167.55,42.87 167.16,42.47 167.16,40.31 165.06,38.22 162.89,38.22 v1(162.65,37.98) 162.65,37.98 162.65,34.57 R6118.1 R6117.2
  BOTTOM w0.102: v2(168.21,44.9) 168.17,44.9 U2000.U36
MB_ID1: length 14.5
  BOTTOM w0.089: U2000.P44 165.92,41.49 165.92,41.4 165.65,41.13
  BOTTOM w0.102: 165.65,41.13 165.65,40.89 165.26,40.5 165.09,40.5 165.02,40.44 165.02,40.44 164.1,39.52 163.23,39.52 162.34,38.64 159.52,38.64 159.26,38.37 159.26,38.24 157.79,36.77 R6120.1 158.2,36.35 158.2,35.08 157.99,34.87 157.53,34.87 v1(157.43,34.76) 157.43,34.2 R6119.2
MB_ID2: length 10.7
  BOTTOM w0.089: U2000.T45 167.05,40.9 167.05,40.07 166.14,39.16 166.13,39.16 165.8,38.83 164.78,38.83 164.54,38.59 164.12,38.59 v1(163.27,37.73)
  BOTTOM w0.102: v1(163.27,37.73) 163.14,37.61 163.07,37.61 R6102.1 161.81,36.35 161.81,34.52 162.1,34.23 R6101.2
MB_ID3: length 12.4
  BOTTOM w0.089: 162.04,37.73 162.06,37.76 162.68,37.76 163.69,38.77 164.41,38.77 164.65,39.01 165.73,39.01 166.06,39.34 166.07,39.34 166.87,40.14 166.87,41.1 167.17,41.4 167.17,41.53 U2000.T44
  BOTTOM w0.102: 162.04,37.73 161.82,37.52 161.82,37.25 R6104.1 161.07,36.5 161.07,36.4 160.92,36.25 160.92,35.08 v1(161.37,34.64) 160.71,33.98 R6103.2
MB_ID4: length 13.3
  BOTTOM w0.102: U2000.R44 166.5,41.38 166.5,40.3 165.57,39.38 164.5,39.38 164.26,39.14 163.38,39.14 162.46,38.22 161.29,38.22 160.83,37.76 160.29,37.76 159.94,37.42 159.94,37.15 159.56,36.77 R6122.1 159.56,36.75 159.83,36.48 159.83,36.4 159.99,36.23 159.99,35.02 v1(159.61,34.64) 159.56,34.59 R6121.2
MB_ID5: length 14.4
  BOTTOM w0.089: U2000.R43 166.43,41.82 166.43,41.61 166.31,41.49 166.31,41
  BOTTOM w0.102: R6123.2 159.13,34.3 159.13,36.31 R6124.1 159.61,37.71 159.61,37.99 v1(159.79,38.17) 160.07,38.45 162.42,38.45 163.31,39.33 164.18,39.33 164.42,39.57 165.5,39.57 166.31,40.38 166.31,41
MCK_BUTTON1#: length 268
  TOP w0.102: v2(120.62,41.07) 120.62,41.14 120.65,41.11 120.65,37.27 121.41,36.51 123.35,36.51 124.3,35.55 U3001.108
  IN2 w0.102: v2(120.62,41.07) 119.23,41.07 118.26,40.09 113.57,40.09 112.76,40.9 96.69,40.9 95.21,42.38 93.58,42.38 93.24,42.72 93.24,42.79 92.78,43.26 91.24,43.26 90.73,42.75 69.51,42.75 68.79,43.48 67.58,43.48 66.84,44.21 58.06,44.21 57.35,43.5 48.77,43.5 47.16,45.1 45.13,45.1 44.3,45.94 44.3,46.48 41.16,49.62 36.85,49.62 34.83,51.64 34.83,53.07 28.19,59.71 28.19,61.81 28.12,61.88 28.12,65.79 25.02,68.89 25.02,74.38 25.45,74.81 25.45,81.25 17.42,89.29 17.42,112.51 11.84,118.09 11.84,125.06 12.32,125.54 12.32,131.85 11.44,132.72 11.44,136.86 12.41,137.83 12.41,142.87 13.03,143.48 13.03,144.92 11.64,146.3 11.64,148.23 13.09,149.68 13.09,151.12 20.85,158.88 20.85,167.29 19.1,169.04 19.1,172.85 19.48,173.24 19.48,174.29 19.78,174.59 21.4,174.59 24.31,177.5 24.31,177.98 25,178.67 31.4,178.67 31.77,179.04 33.91,179.04 35.74,180.88 35.74,181.27 v2(36.17,181.7)
  BOTTOM w0.102: v2(120.62,41.07) 120.09,41.6 v1(120.09,41.6) ; CON5602.14 36.25,178.4 35.74,178.91 35.74,181.27 v2(36.17,181.7)
MCK_BUTTON1_IO: length 34.8
  TOP w0.114: CON402.14 188.7,176.06 189.7,175.06 189.7,173.18 195.4,167.48 206.45,167.48 206.45,167.48 206.75,167.48 206.93,167.66 207.26,167.66 v1(207.5,167.9) 209.11,169.52 209.11,174.85 209.91,175.64 PCON702.4
MCK_BUTTON2#: length 267.4
  TOP w0.102: U3001.109 124.47,35.95 123.9,36.52 123.71,36.71 121.51,36.71 120.88,37.34 120.88,40.28 121.33,40.73 v2(121.33,41.07)
  IN2 w0.102: v2(121.33,41.07) 120.9,40.63 119.13,40.63 118.38,39.89 113.49,39.89 112.68,40.7 96.61,40.7 95.13,42.18 69.51,42.18 68.63,43.05 67.43,43.05 66.68,43.81 58.23,43.81 57.51,43.09 48.24,43.09 47.58,43.75 44.58,43.75 39.26,49.07 36.84,49.07 34.43,51.47 34.43,52.9 27.79,59.54 27.79,61.26 24.61,64.43 24.61,74.55 25.04,74.98 25.04,81.09 17.01,89.12 17.01,112.14 11.43,117.72 11.43,125.23 11.91,125.71 11.91,131.68 11.04,132.55 11.04,137.03 12.01,138 12.01,145.36 11.24,146.13 11.24,148.4 12.69,149.85 12.69,151.29 20.45,159.05 20.45,166.99 18.69,168.75 18.69,173.02 19.08,173.4 19.08,174.46 19.61,175 21.23,175 23.9,177.67 23.9,178.15 24.83,179.07 31.23,179.07 31.6,179.45 33.74,179.45 34.9,180.61 34.9,181.2 v2(35.38,181.68)
  BOTTOM w0.102: v2(121.33,41.07) 121.64,41.37 v1(121.94,41.37) ; CON5602.12 35.25,178.43 34.9,178.78 34.9,181.2 v2(35.38,181.68)
MCK_BUTTON2_IO: length 31.9
  TOP w0.114: PCON702.6 208.91,175.64 208.43,175.17 208.43,170.38 v1(207.83,169.78) 206.22,168.17 195.78,168.17 190.91,173.04 190.91,174.87 189.7,176.08 CON402.12
MCK_BUTTON3#: length 260.5
  TOP w0.102: U3001.35 112.18,42.75 112.5,42.43 112.5,39.85 v2(112.32,39.67)
  IN2 w0.102: v2(34.49,181.39) 34.09,180.98 34.09,180.46 33.48,179.86 31.44,179.86 31.06,179.48 24.66,179.48 23.66,178.48 20.95,178.48 19.88,177.41 19.88,176.79 18.67,175.58 18.67,173.57 18.28,173.19 18.28,168.58 20.04,166.83 20.04,159.6 18.38,157.94 14.87,157.94 10.83,153.9 10.83,144.25 11.53,143.55 11.53,142.31 10.56,141.34 10.43,141.34 9.75,140.66 9.75,120.61 10.49,119.87 10.49,99.42 10.15,99.08 10.15,90.6 11.43,89.31 13.85,89.31 14.95,88.21 14.95,85.67 19.08,81.54 20.73,81.54 24.44,77.83 24.44,75.23 23.9,74.7 23.9,70.92 22.03,69.05 22.03,65.99 22.56,65.47 22.64,65.47 22.99,65.12 22.99,64.9 26.98,60.92 26.98,59.05 33.61,52.41 33.61,48.73 37.89,44.45 40.45,44.45 42.87,42.04 68.21,42.04 69.09,41.16 92.7,41.16 93.14,40.72 93.14,40.1 93.58,39.67 v2(112.32,39.67)
  BOTTOM w0.102: CON5602.10 34.25,178.39 34.09,178.55 34.09,180.98 v2(34.49,181.39) ; v1(111.73,39.3) 111.95,39.3 v2(112.32,39.67)
MCK_BUTTON3_IO: length 28.7
  TOP w0.114: CON402.10 190.7,176.09 192.05,174.75 192.05,172.92 196.11,168.85 204.92,168.85 v1(207.63,171.56) 207.74,171.68 207.74,175.47 207.91,175.63 PCON702.8
MCK_BUTTON4#: length 269.7
  TOP w0.102: v2(114.57,38.52) 114.59,38.5 115.44,38.5 117.52,40.58 U3001.20 ; v2(33.25,180.48) 32.77,180.97 32.03,180.97 v1(31.93,180.87)
  IN2 w0.102: v2(114.57,38.52) 114.07,39.02 111.62,39.02 111.4,39.24 70.15,39.24 68.47,40.91 61.63,40.91 61.5,40.78 49.9,40.78 49.82,40.71 42.35,40.71 39.32,43.74 37.27,43.74 32.89,48.12 32.89,52.27 26.37,58.8 26.37,60.66 22.76,64.26 21.84,64.26 21.03,65.07 21.03,65.09 21,65.12 21,65.75 20.31,66.44 20.31,69.24 23.29,72.22 23.29,74.95 23.83,75.49 23.83,77.58 20.48,80.93 18.83,80.93 14.34,85.41 14.34,87.96 13.65,88.65 11.24,88.65 9.54,90.35 9.54,99.33 9.88,99.67 9.88,119.62 9.14,120.35 9.14,142.26 10.21,143.32 10.21,154.28 14.47,158.55 18.13,158.55 19.43,159.85 19.43,164.67 16.46,167.64 16.46,172.23 18.06,173.83 18.06,175.03 17.88,175.21 17.88,177.35 19.62,179.08 23.4,179.08 24.41,180.09 30.81,180.09 31.18,180.47 31.99,180.47 32.39,180.87 32.86,180.87 v2(33.25,180.48)
  BOTTOM w0.102: CON5602.8 33.25,177.3 33.25,178.15 33.05,178.35 33.05,179.42 33.25,179.62 v2(33.25,180.48)
MCK_BUTTON4_IO: length 25.8
  TOP w0.114: PCON702.10 206.91,172.41 v1(205.82,171.33) 204.03,169.54 196.44,169.54 193.13,172.85 193.13,174.81 191.7,176.24 CON402.8
MCK_BUTTON5#: length 275.6
  TOP w0.102: v2(113.89,38.52) 113.89,38.32 116.23,35.98 116.23,35.49 117.04,34.69 118.01,34.69 119.15,33.55 119.15,32.17 119.15,32 120.35,30.8 120.8,30.8 121.12,30.48 U3001.86
  IN2 w0.102: v2(33.1,181.22) 32.97,181.09 32.33,181.09 31.92,180.69 31.12,180.69 30.72,180.29 24.32,180.29 23.32,179.29 19.53,179.29 17.55,177.31 17.55,176.45 16.56,175.46 16.56,172.61 16.26,172.31 16.26,167.56 19.23,164.58 19.23,159.93 18.04,158.75 14.39,158.75 10,154.37 10,143.4 8.94,142.34 8.94,120.27 9.68,119.53 9.68,99.76 9.33,99.41 9.33,90.26 11.15,88.44 13.57,88.44 14.14,87.87 14.14,85.33 18.74,80.72 20.36,80.72 22.86,78.22 22.86,74.98 23.09,74.75 23.09,72.3 19.84,69.05 19.84,64.66 20.48,64.02 22.71,64.02 26.16,60.57 26.16,58.71 32.69,52.18 32.69,48.03 37.23,43.49 39.28,43.49 42.29,40.48 47.3,40.48 48.3,39.47 53.94,39.47 54.36,39.9 60.9,39.9 61.71,40.71 68.39,40.71 70.07,39.03 111.32,39.03 111.53,38.82 113.6,38.82 v2(113.89,38.52)
  BOTTOM w0.102: v2(33.1,181.22) 32.77,181.22 32.18,180.63 32.18,178.25 32.25,178.18 CON5602.6 ; v2(113.89,38.52) 113.89,38.32 113.62,38.05 v1(113.62,37.68)
MCK_BUTTON5_IO: length 22.8
  TOP w0.114: CON402.6 192.7,176.25 193.97,174.99 193.97,173.31 197.05,170.23 203.32,170.23 v1(203.56,170.47) 205.91,172.81 PCON702.12
MCK_BUTTON6#: length 278.6
  TOP w0.102: U3001.88 121.92,30.4 121.11,31.21 120.51,31.21 119.56,32.17 119.56,33.72 118.18,35.1 117.3,35.1 117.2,35.2 117.2,36.26 116.66,36.8 v2(116.66,37.78)
  IN2 w0.102: v2(12.42,163.38) 12.99,163.38 15.43,165.83 15.43,173.23 14.3,174.37 14.3,174.89 14.87,175.47 15.51,175.47 17.15,177.1 17.15,177.48 19.37,179.69 23.15,179.69 24.15,180.7 30.13,180.7 v2(30.56,181.12) ; v2(7.51,140.64) 7.83,140.64 7.92,140.56 7.92,138.04 7.46,137.58 6.69,137.58 5.29,136.18 5.29,126.27 6.31,125.25 6.31,124.67 7.11,123.87 7.11,120.66 8.66,119.11 8.66,105.4 7.72,104.46 7.72,88.89 7.9,88.71 7.9,88.51 8.69,87.72 8.69,86.63 9.42,85.9 9.42,75.8 7.14,73.51 7.14,68.68 8,67.81 8.71,67.81 13.01,63.52 19.54,63.52 20.05,63.01 22.29,63.01 25.15,60.15 25.15,58.28 28.96,54.47 28.96,50.33 36.94,42.35 38.99,42.35 43.59,37.74 46.91,37.74 47.6,38.43 54.91,38.43 55.24,38.76 57.6,38.76 58.38,37.98 98.08,37.98 98.73,37.33 101.46,37.33 101.91,37.79 111.12,37.79 111.6,37.3 116.18,37.3 v2(116.66,37.78)
  BOTTOM w0.102: v2(12.42,163.38) 11.7,163.38 10.21,161.89 10.21,144.38 7.51,141.67 v2(7.51,140.64) ; v1(116.55,38.45) 116.55,37.9 v2(116.66,37.78) ; CON5602.2 30.25,180.81 v2(30.56,181.12)
MCK_BUTTON6_IO: length 17
  TOP w0.114: PCON702.16 203.91,173.3 v1(202.7,172.09) 197.21,172.09 195.7,173.61 195.7,175.16 194.7,176.16 CON402.2
MCK_LED1: length 257.5
  TOP w0.102: R3087.2 96.11,24.3 95.94,24.48 93.4,24.48 93.14,24.22 v1(93.14,24.22) 92.81,23.89 90.23,23.89 87.79,26.33 87.79,32.63 94.72,39.56 94.72,40.91 93.69,41.94 v2(93.69,42.85)
  IN2 w0.102: v2(93.69,42.85) 93.08,43.46 91.15,43.46 90.65,42.96 69.59,42.96 68.87,43.68 67.66,43.68 66.93,44.42 57.98,44.42 57.26,43.7 48.85,43.7 47.24,45.31 45.22,45.31 44.5,46.02 44.5,46.57 41.19,49.88 36.89,49.88 35.04,51.73 35.04,53.15 28.4,59.79 28.4,61.89 28.33,61.97 28.33,65.87 25.22,68.98 25.22,74.29 25.65,74.73 25.65,81.34 17.62,89.37 17.62,112.59 12.04,118.18 12.04,124.98 12.52,125.46 12.52,131.93 11.64,132.81 11.64,136.78 12.63,137.76 12.63,141.2 13.45,142.03 13.48,142.03 13.67,142.22 13.67,143.01 13.35,143.33 13.35,144.89 11.85,146.39 11.85,148.14 13.3,149.6 13.3,151.04 21.06,158.8 21.06,167.37 19.3,169.13 19.3,172.47 20.66,173.83 21.31,173.83 25.94,178.46 31.48,178.46 31.86,178.84 33.99,178.84 36.17,181.02 v2(36.17,181.07)
  BOTTOM w0.102: v2(36.17,181.07) 36.17,178.88 36.75,178.3 CON5602.15
MCK_LED1_IO: length 36.3
  TOP w0.114: CON402.15 188.2,176.05 189.2,175.05 189.2,173.17 195.23,167.14 207.65,167.14 v1(209.46,168.94) 209.46,174.71 210.4,175.66 PCON702.3
