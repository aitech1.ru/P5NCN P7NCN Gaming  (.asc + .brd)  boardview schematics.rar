# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on TOP (solid shape): 241.58,62.95 241.58,60.46 241.52,60.4 241.52,60.04 240.88,59.4 240.54,59.4 240.16,59.02 238.43,59.02 238.37,58.95 237.95,58.95 237.9,59 237.9,59.62 237.81,59.71 237.81,60.15 237.78,60.18 237.2,60.18 237.19,60.2 237.19,60.35 237.21,60.38 237.83,60.38 237.86,60.41 237.86,60.57 237.85,60.58 237.25,60.58 237.21,60.63 237.21,60.77 237.21,60.78 237.87,60.78 237.99,60.9 238.5,60.9 238.5,60.69 238.53,60.67 238.71,60.67 238.71,60.26 238.71,60.25 239.32,59.78 239.11,60.52 239.08,60.54 239.07,60.57 239.07,60.67 240.48,60.67 240.6,60.79 240.61,60.79 240.75,61.19 240.44,61.48 240.4,61.49 240.4,61.61 240.44,61.62 240.72,62 240.41,62.36 240.4,62.37 240.32,62.44 239.07,62.44 239.07,62.57 239.11,62.58 239.25,63.35 238.71,62.79 238.71,62.44 238.17,62.44 237.9,62.18 237.2,62.18 237.17,62.21 237.17,62.37 237.18,62.38 237.81,62.38 237.82,62.39 237.82,62.57 237.81,62.58 237.2,62.58 237.15,62.63 237.15,62.77 237.17,62.78 237.81,62.78 237.86,62.83 237.86,64.03 238.09,64.27 240.26,64.27
+5V_FAN0 on TOP (solid shape): outline of 106 points within 25.25,115 29.32,119.75
+5V_FAN0 on BOTTOM (solid shape): 30.69,117.43 30.69,116.67 29.65,115.63 29.65,114.47 29.56,114.38 28.57,114.38 28.53,114.42 28.53,115.63 29.41,116.52 29.41,117.69 29.57,117.84 30.28,117.84
+5V_FAN1 on TOP (solid shape): 184.1,79.57 184.1,79.41 183.34,78.64 183.34,77.41 183.42,77.33 185.13,77.33 185.33,77.13 186.84,77.13 186.89,77.08 186.89,76.37 186.79,76.27 185.37,76.27 185.32,76.22 183.36,76.22 182.43,77.15 182.43,78.58 182.95,79.1 182.95,79.47 183.31,79.83 183.84,79.83
+5V_USB on TOP (solid shape): 261.71,67.62 261.65,67.56 261.65,67 261.51,66.86 259.99,66.86 259.82,66.7 259.7,66.58 259.7,66.52 259.7,66.51 259.67,66.39 259.67,66.13 259.7,66.01 259.7,65.98 259.41,65.69 259.41,65.27 259.07,64.93 258.94,64.93 257.86,63.85 255.7,63.85 251.81,59.96 249.13,59.96 248.86,60.22 248.86,60.63 248.98,60.74 249.89,60.74 250.4,61.25 250.4,61.55 253.54,64.69 253.54,65.23 253.88,65.57 253.88,66.66 254.81,67.59 257.42,67.59 257.73,67.91 259.88,67.91 259.88,67.91 260.42,68.04 260.69,68.52 260.7,68.54 260.78,68.62 260.78,69.69 261.71,69.69
+5V_USB on BOTTOM (solid shape): 261.74,67.27 261.35,66.87 260.34,66.87 259.79,66.58 259.71,65.96 259.71,65.87 259,65.17 258.37,65.17 257.99,65.55 257.99,67.45 258.77,68.24 259.3,68.24 260.42,67.94 260.63,69.08 261.03,69.48 261.74,69.48
+5V_USB on IN2 (solid shape): 261.74,67.27 261.35,66.87 260.34,66.87 260.01,66.79 259.77,66.55 259.64,66.25 259.71,65.93 259.71,65.87 259,65.17 258.37,65.17 257.99,65.55 257.99,67.45 258.77,68.24 259.3,68.24 260.42,67.94 260.63,69.08 261.03,69.48 261.74,69.48
+5V_USB on IN3 (solid shape): 261.74,67.27 261.35,66.87 260.34,66.87 260.01,66.79 259.77,66.55 259.64,66.25 259.71,65.93 259.71,65.87 259,65.17 258.37,65.17 257.99,65.55 257.99,67.45 258.77,68.24 259.3,68.24 260.42,67.94 260.63,69.08 261.03,69.48 261.74,69.48
+5VA on TOP (solid shape): 225.35,70.88 225.35,69.86 224.84,69.36 222.81,69.36 222.42,69.36 222.18,69.6 222.18,70.48 222.11,70.55 222.11,71.08 222.17,71.13 225.1,71.13
+5VAO on TOP (solid shape): 218.7,72.06 219.47,71.3 221.72,71.3 221.88,71.14 221.88,70.31 222,70.19 222,69.59 221.84,69.43 220.62,69.43 220.54,69.46 220.52,69.55 220.38,69.92 219.98,69.96 219.97,69.96 219.47,69.96 219.29,70.13 219.29,70.47 219.14,70.62 218.65,70.62 218.51,70.75 218.51,73.37 218.7,73.37
+5VO on TOP (solid shape): outline of 140 points within 225.98,59.25 242.77,81.29
+5VO on BOTTOM (solid shape): outline of 252 points within 217.96,70.56 237.29,84.52
+5VO on IN3 (solid shape): 220.12,85.08 220.12,83.69 219.53,83.1 219.18,83.1 218.96,83.32 218.96,84.63 219.18,84.63 219.18,84.57 219.19,84.52 219.21,84.46 219.24,84.41 219.27,84.37 219.31,84.33 219.36,84.3 219.41,84.27 219.46,84.26 219.52,84.25 219.57,84.24 219.63,84.25 219.68,84.26 219.73,84.29 219.78,84.31 219.82,84.35 219.86,84.39 219.89,84.44 219.91,84.49 219.93,84.54 219.94,84.6 219.94,84.65 219.93,84.71 219.91,84.76 219.89,84.81 219.86,84.86 219.82,84.9 219.78,84.94 219.73,84.97 219.68,84.99 219.63,85 219.57,85.01 219.52,85.01 219.46,85 219.41,84.98 219.36,84.95 219.31,84.92 219.27,84.88 219.24,84.84 219.21,84.79 219.19,84.74 219.18,84.68 219.18,84.63 218.96,84.63 218.96,85.22 219.25,85.51 219.68,85.51
+5VO_1_1 on TOP (solid shape): 244.65,69.61 244.65,69 244.4,68.75 244.4,65.93 244.27,65.8 243.51,65.8 243.38,65.93 243.38,69.08 244.12,69.82 244.45,69.82
+5VO_1_2 on TOP (solid shape): 243.41,65.01 243.41,63.95 240.91,63.95 240.08,64.79 240.08,65.24 240.23,65.4 243.03,65.4
+5VO_2_2 on TOP (solid shape): 249.81,68.29 249.81,67.66 249.4,67.25 249.4,66.08 249.15,65.83 248.46,65.83 248.21,66.08 248.21,68.7 248.21,68.7 248.21,68.85 249.25,68.85
+5VS on TOP (solid shape): 186.94,78.53 186.94,77.76 186.66,77.48 183.85,77.48 183.69,77.64 183.69,78.58 183.9,78.78 186.69,78.78
+5VS on TOP (solid shape): 14.17,84.21 14.17,83.38 13.94,83.15 12.7,83.15 12.7,83.15 12.5,83.15 12.35,83.29 12.35,84.57 12.63,84.84 13.54,84.84
+5VS on TOP (solid shape): 14.17,79.14 14.17,77.44 14.1,77.44 13.89,77.23 13.89,76.34 13.77,76.21 12.96,76.21 12.78,76.4 12.78,78.78 13.21,79.21 14.1,79.21
+5VS on TOP (solid shape): 25.38,117.29 26.78,117.29 26.89,117.18 26.89,116.29 26.85,116.25 24.88,116.25 24.61,116.51 24.61,117.11 24.61,117.11 24.61,117.49 24.74,117.62 25.04,117.62
+5VS on TOP (solid shape): 23.6,63.67 23.6,61.93 22.86,61.18 22.02,61.18 21.77,61.43 21.77,62.07 22.11,62.07 22.56,62.53 22.56,63.44 22.24,63.76 22.24,63.94 22.52,64.22 23.05,64.22
+5VS on TOP (solid shape): 144.67,99.21 144.67,98.85 144.61,98.79 144.05,98.79 143.69,98.43 143.69,97.65 142.96,97.65 142.88,97.73 142.88,98.24 143.31,98.66 143.31,98.84 143.32,98.84 143.83,99.36 144.52,99.36
+5VS on TOP (solid shape): 165.79,26.13 165.79,24.99 165.53,24.73 163.12,24.73 162.87,24.48 162.87,23.72 163.12,23.46 164.9,23.46 164.98,23.38 164.98,22.75 164.66,22.43 162.68,22.43 162.67,22.44 162.67,22.56 162.55,22.56 162.54,22.57 160.91,22.57 160.76,22.43 160.58,22.43 160.04,22.97 160.04,24.19 162.61,26.76 165.15,26.76
+5VS on TOP (solid shape): 94.51,178.73 95.76,178.73 95.81,178.68 95.81,177.77 95.68,177.64 94.5,177.64 94.42,177.72 94.45,177.76 94.51,178.16 94.17,178.39 93.86,178.25 93.79,177.92 93.79,177.89 93.67,177.77 92.77,177.77 92.58,177.96 92.58,178.81 92.65,178.88 94.36,178.88
+5VS on BOTTOM (solid shape): 216.56,81.52 216.28,81.24 214.22,81.24 214,81.47 214,83.05 214.3,83.36 215.34,83.36 215.57,83.58 215.57,84.32 215.8,84.55 216.56,84.55
+5VS on BOTTOM (solid shape): 40.04,46.24 40.04,43.87 36.94,40.77 35.42,40.77 35.17,40.52 34.04,40.52 33.17,41.39 33.17,42.03 33.79,42.65 36.64,42.65 38.82,44.83 38.82,46.24 38.84,46.27 40.01,46.27
+5VS on IN1 (solid shape): 175.01,26.33 175.01,25 174.64,24.63 163.42,24.63 162.86,25.19 162.86,25.75 170.36,25.75 170.36,25.72 170.37,25.67 170.38,25.61 170.41,25.56 170.44,25.52 170.47,25.47 170.52,25.44 170.56,25.41 170.62,25.39 170.67,25.37 170.73,25.37 170.78,25.37 170.84,25.38 170.89,25.4 170.94,25.42 170.98,25.46 171.02,25.49 171.06,25.54 171.09,25.59 171.11,25.64 171.12,25.69 171.12,25.75 171.12,25.8 171.11,25.86 171.09,25.91 171.06,25.96 171.02,26 170.98,26.04 170.94,26.08 170.89,26.1 170.84,26.12 170.78,26.13 170.73,26.13 170.67,26.13 170.62,26.11 170.56,26.09 170.52,26.06 170.47,26.02 170.44,25.98 170.41,25.94 170.38,25.89 170.37,25.83 170.36,25.78 170.36,25.75 162.86,25.75 162.86,26.6 163.21,26.95 174.4,26.95
+5VS on IN1 (solid shape): 92.13,179.16 92.89,179.16 93.23,178.82 93.23,177.86 93.02,177.64 89.71,177.64 89.46,177.89 89.46,178.4 91.11,178.4 91.11,178.35 91.12,178.29 91.14,178.24 91.17,178.19 91.21,178.15 91.25,178.11 91.29,178.08 91.34,178.05 91.39,178.03 91.45,178.02 91.51,178.02 91.56,178.03 91.61,178.04 91.67,178.06 91.71,178.09 91.76,178.13 91.79,178.17 91.82,178.21 91.85,178.27 91.86,178.32 91.87,178.37 91.87,178.43 91.86,178.49 91.85,178.54 91.82,178.59 91.79,178.64 91.76,178.68 91.71,178.71 91.67,178.74 91.61,178.76 91.56,178.78 91.51,178.78 91.45,178.78 91.39,178.77 91.34,178.75 91.29,178.73 91.25,178.7 91.21,178.66 91.17,178.61 91.14,178.56 91.12,178.51 91.11,178.46 91.11,178.4 89.46,178.4 89.46,179.67 89.59,179.8 91.49,179.8
+5VS on IN2 (solid shape): 26.13,118.03 26.13,116.31 26.03,116.21 24.64,116.21 24.38,116.47 24.38,117.41 24.39,117.41 24.39,118.18 24.56,118.36 25.81,118.36
+5VS on IN2 (solid shape): 198.86,26.28 198.86,25.27 200.3,23.82 200.3,22.01 200.14,21.85 197.49,21.85 197.43,21.91 197.43,25.06 197.59,25.21 197.91,25.55 197.83,26 197.92,26.19 197.92,26.41 198.73,26.41
+5VS on IN2 (solid shape): 165.94,25.8 165.93,25.77 166.04,25.46 166.36,25.35 166.38,25.35 166.43,25.3 166.43,24.59 166.8,24.22 166.8,22.19 166.55,21.94 161.53,21.94 161.39,22.06 161.2,22.11 161,22.04 160.87,21.88 160.85,21.85 155.2,21.85 154.74,22.32 154.74,25.11 154.86,25.24 156.39,25.24 156.72,24.91 159.1,24.91 159.43,25.24 160.2,25.24 160.63,25.67 160.67,25.66 161.1,25.73 161.18,26.17 161.16,26.2 161.8,26.84 164.89,26.84
+5VS on IN2 (solid shape): outline of 340 points within 64.64,166.64 72.47,172.91
+5VS on IN2 (solid shape): outline of 564 points within 46.95,30.19 67.92,35.08
+5VS on IN2 (solid shape): outline of 678 points within 28.5,30.5 36.8,42.51
+5VS on IN2 (solid shape): outline of 2290 points within 88.09,23.95 149.17,31.66
+5VS on IN2 (solid shape): outline of 15079 points within 214,25.14 253.62,85.9
+5VS on IN3 (solid shape): 26.16,119.07 26.16,116.5 26.05,116.39 23.97,116.39 23.75,116.61 23.75,119.01 24,119.27 25.96,119.27
+5VS on IN3 (solid shape): 31.87,55.68 31.87,54.7 32.56,54.01 32.56,52.93 31.67,52.04 30.53,52.04 30.28,52.29 30.28,54.15 28.03,56.4 28.03,59.09 28.25,59.3
+5VS on IN3 (solid shape): 36.14,43.83 36.14,40.15 35.92,39.92 35.22,39.92 35.21,39.93 34.74,39.93 33.22,41.45 33.22,44.29 33.66,44.72 35.26,44.72
+5VS on IN3 (solid shape): outline of 169 points within 23.48,60.65 27.74,66.57
+5VS on IN3 (solid shape): outline of 191 points within 10.67,77.43 15.22,85.01
+5VS on IN3 (solid shape): outline of 182 points within 22.71,67.02 25.93,78.78
+5VS on IN3 (solid shape): outline of 419 points within 8.08,163.54 19.33,168.24
+5VS on IN3 (solid shape): outline of 536 points within 24.66,169.77 49.96,178.22
+5VS on IN4 (solid shape): 216.43,85.06 216.43,82.21 215.83,81.61 213.53,81.61 212.34,82.79 212.34,85.11 212.52,85.29 216.21,85.29
+5VS on IN4 (solid shape): 185.21,84.56 185.53,84.56 186.06,84.03 186.16,83.83 186.36,83.73 186.5,83.73 186.63,83.78 186.7,83.83 186.76,83.9 186.79,83.93 189.04,83.93 189.23,83.74 189.23,81.4 185.32,77.49 183.79,77.49 183.4,77.88 183.4,79.01 184.06,79.5 183.4,79.99 183.4,81.72 183.59,82.05 183.4,82.38 183.4,83.95 184.02,84.57 185.2,84.57
+5VS on IN4 (solid shape): outline of 510 points within 18.19,165.96 35.74,178.53
+5VS_3DCAM on TOP (solid shape): 94.88,181.86 94.88,180.64 94.92,180.61 95.1,180.61 95.15,180.66 95.15,181.88 95.38,181.88 95.38,180.71 95.63,180.46 95.63,179.7 95.5,179.57 94.56,179.57 94.56,179.58 93.79,179.58 93.7,179.67 93.7,180.09 94.09,180.48 94.44,180.48 94.67,180.71 94.67,181.78 94.77,181.88 94.87,181.88
+5VS_AVDD on TOP (solid shape): 15.29,76.57 15.29,76.09 15.01,75.81 15.01,74.74 15.67,74.08 15.67,73.42 15.04,73.42 15,73.46 15,73.46 14.93,73.56 14.83,73.64 14.82,73.64 14.57,73.89 14.57,74.06 14.32,74.32 14.31,74.32 14.07,74.48 13.78,74.42 13.55,74.42 13.5,74.45 12.88,75.07 12.88,75.64 12.94,75.71 14.27,75.71 14.85,76.28 14.85,76.43 15.04,76.62 15.24,76.62
+5VS_FAN2 on TOP (solid shape): 164.9,21.05 164.77,20.92 162.99,20.92 162.67,20.6 162.67,20.1 162.48,19.91 160.71,19.91 160.71,21.05 160.96,21.3 162.48,21.3 163.12,21.94 164.9,21.94
+5VS_HDD on BOTTOM (solid shape): outline of 376 points within 29.58,31.56 41.62,46.14
+5VS_HDMI on TOP (solid shape): 254.72,83.12 254.79,83.12 254.85,83.12 257.4,83.12 257.42,83.11 257.95,83.11 258.06,83 258.06,82.69 257.63,82.26 257.63,81.57 256.95,81.57 256.57,81.19 256.57,80.74 256.31,80.48 254.28,80.48 254.28,82.82 254.58,83.12
+5VS_ODD_FAN on TOP (solid shape): 43.98,35.22 43.98,34.05 42.06,32.13 39.89,32.13 39.54,32.48 39.54,32.91 42.04,35.41 43.79,35.41
+5VS_ODD_FAN on TOP (solid shape): 158.55,26.13 158.55,24.89 157.37,24.89 157.37,23.8 158.17,23.8 158.97,22.99 158.97,19.91 156.52,19.91 155.5,20.92 155.5,25.62 155.56,25.68 155.56,25.94 155.88,26.26 158.42,26.26
+5VS_ODD_FAN on TOP (solid shape): 29.13,25.16 27.88,23.91 25.72,23.91 25.45,23.64 22.53,23.64 21.01,25.16 21.01,25.8 21.13,25.92 21.9,25.92 22.02,25.8 23.17,25.8 23.76,26.39 28.02,26.39 28.32,26.68 29.13,26.68
+5VS_ODD_FAN on IN1 (solid shape): 157.55,27.02 162.29,27.02 162.68,26.64 162.68,25 162.27,24.59 156.1,24.59 154.69,26 160.45,26 160.45,25.95 160.47,25.89 160.49,25.84 160.51,25.79 160.55,25.75 160.59,25.71 160.63,25.68 160.68,25.65 160.74,25.63 160.79,25.62 160.85,25.62 160.9,25.63 160.96,25.64 161.01,25.66 161.06,25.69 161.1,25.73 161.14,25.77 161.17,25.81 161.19,25.87 161.21,25.92 161.21,25.97 161.21,26.03 161.21,26.09 161.19,26.14 161.17,26.19 161.14,26.24 161.1,26.28 161.06,26.31 161.01,26.34 160.96,26.36 160.9,26.38 160.85,26.38 160.79,26.38 160.74,26.37 160.68,26.35 160.63,26.33 160.59,26.3 160.55,26.26 160.51,26.21 160.49,26.16 160.47,26.11 160.45,26.06 160.45,26 154.69,26 153.39,27.3 153.39,27.68 156.89,27.68
+5VS_ODD_FAN on IN2 (solid shape): 46.45,34.97 46.45,34.03 46.21,33.79 42.15,33.79 41.77,34.17 41.77,35.02 41.9,35.15 46.27,35.15
+5VS_ODD_FAN on IN2 (solid shape): outline of 154 points within 153.52,25.26 161.47,29.58
+5VS_ODD_FAN on IN3 (solid shape): 44.8,34.9 44.8,33.93 44.71,33.84 42.29,33.84 42.12,34 42.12,34.96 42.23,35.06 44.64,35.06
+5VS_ODD_FAN on IN3 (solid shape): 155.41,26.96 155.41,26.97 155.42,27 155.43,27.03 155.46,27.05 155.48,27.06 155.51,27.06 155.54,27.06 155.57,27.04 155.58,27.03 161.45,27.03 161.46,27.02 163.51,27.02 163.7,26.83 163.7,25.8 163.18,25.28 161.26,25.28 161.23,25.31 156.33,25.31 155.64,26 160.45,26 160.45,25.95 160.47,25.89 160.49,25.84 160.51,25.79 160.55,25.75 160.59,25.71 160.63,25.68 160.68,25.65 160.74,25.63 160.79,25.62 160.85,25.62 160.9,25.63 160.96,25.64 161.01,25.66 161.06,25.69 161.1,25.73 161.14,25.77 161.17,25.81 161.19,25.87 161.21,25.92 161.21,25.97 161.21,26.03 161.21,26.09 161.19,26.14 161.17,26.19 161.14,26.24 161.1,26.28 161.06,26.31 161.01,26.34 160.96,26.36 160.9,26.38 160.85,26.38 160.79,26.38 160.74,26.37 160.68,26.35 160.63,26.33 160.59,26.3 160.55,26.26 160.51,26.21 160.49,26.16 160.47,26.11 160.45,26.06 160.45,26 155.64,26 155.41,26.24
+5VSUS on TOP (solid shape): 232.17,52.77 232.17,51.1 231.94,50.87 231.32,50.87 230.81,51.38 230.81,52.75 230.91,52.85 232.08,52.85
+5VSUS on TOP (solid shape): 14.15,105.35 14.15,104.31 13.87,104.03 11.3,104.03 11.23,104.11 10.47,104.11 10.34,104.23 10.34,106.21 10.75,106.62 12.88,106.62
+5VSUS on TOP (solid shape): 253.67,60.04 253.67,59.02 253.29,58.64 253.01,58.64 252.22,57.85 251.38,57.85 251.38,58.49 251.33,58.54 251.33,59.08 252.55,60.29 253.42,60.29
+5VSUS on TOP (solid shape): 16.86,61.86 16.86,61.04 16.69,60.87 11.2,60.87 10.56,60.87 10.53,60.9 9.84,60.9 9.55,61.19 9.55,61.87 9.7,62.02 16.71,62.02
+5VSUS on TOP (solid shape): 242.05,77.85 242.05,74.5 242.79,73.76 242.79,70.87 242.44,70.53 238.66,70.53 238.15,71.03 234.62,71.03 234.24,71.41 234.24,77.89 234.47,78.12 241.78,78.12
+5VSUS on TOP (solid shape): 243.98,62.07 244.46,62.07 244.5,62.03 245.12,62.03 245.72,61.43 246.83,61.43 246.9,61.36 246.9,60.16 246.62,59.89 245.02,59.89 244.87,60.04 244.87,60.46 244.63,60.7 243.31,60.7 243.14,60.86 243.14,62.16 243.3,62.32 243.74,62.32
+5VSUS on BOTTOM (solid shape): 12.07,106.09 12.07,104.56 11.61,104.11 11.1,104.11 10.11,105.1 9.47,105.1 9.3,104.92 9.3,104.58 9.29,104.58 9.29,103.47 8.71,103.47 8.71,104.94 8.67,104.97 8.35,104.97 8.31,104.93 8.31,104.9 8.32,104.89 8.32,103.47 7.7,103.47 7.7,104.92 7.67,104.96 7.35,104.96 7.31,104.93 7.31,103.49 7.29,103.47 6.7,103.47 6.7,106.22 7.26,106.77 11.38,106.77
+5VSUS on IN3 (solid shape): outline of 486 points within 3.61,60.7 22.2,69.94
+5VSUS on IN3 (solid shape): outline of 513 points within 126.16,23.95 149.03,28.39
+5VSUS on IN3 (solid shape): outline of 566 points within 47.47,30.19 67.66,35.22
+5VSUS on IN3 (solid shape): outline of 590 points within 26.34,35.4 32.44,48.61
+5VSUS on IN3 (solid shape): outline of 1072 points within 3.67,72.65 12.07,106.85
+5VSUS on IN3 (solid shape): outline of 1536 points within 87.1,23.95 112.09,33.01
+5VSUS on IN3 (solid shape): outline of 12119 points within 231.19,22.02 256.23,78.32
+5VSUS on IN4 (solid shape): 53.72,177.6 53.72,173.27 53.24,172.8 53.08,172.7 52.99,172.54 52.96,172.52 52.45,172.52 52.19,172.77 52.19,177.73 52.32,177.85 53.46,177.85
+5VSUS_CHARGING on TOP (solid shape): 261.74,42.06 261.74,39.79 261.47,39.51 261.11,39.51 259.79,39.51 259.79,39.14 259.75,39.08 259.51,39.08 257.73,37.3 256.97,37.3 256.46,36.8 254.43,36.8 254.43,37.18 255.13,37.88 255.13,38.99 255.65,39.51 257.81,39.51 258.74,40.45 260.5,40.45 260.78,40.73 260.78,40.99 261.04,41.24 261.04,42.13 261.67,42.13
+5VSUS_CHARGING on TOP (solid shape): outline of 105 points within 251.37,52.49 258.5,56.67
+5VSUS_CHARGING on IN1 (solid shape): outline of 337 points within 254.72,37.7 259.25,54.78
+5VSUS_CHARGING on IN2 (solid shape): outline of 133 points within 255.45,37.69 261.67,42.47
+5VSUS_CHARGING on IN3 (solid shape): outline of 122 points within 255.32,37.56 261.68,42.47
+5VSUS_TYPEC on TOP (solid shape): 241.05,54.94 241.05,54.63 241.12,54.6 241.15,54.53 241.15,53.61 241.07,53.54 239.32,53.54 239.21,53.64 239.21,53.64 239.1,53.64 239,53.65 238.88,53.64 238.01,54.82 237.11,53.65 232.59,53.65 232.27,53.33 231.17,53.33 231.17,53.87 232.85,55.55 240.44,55.55
+10VO on TOP (solid shape): 248.13,65.04 248.13,63.97 247.35,63.97 246.85,63.47 245.97,63.47 245.6,63.84 244.64,63.84 244.5,63.97 244.5,65.19 244.56,65.25 247.92,65.25
+12VO on TOP (solid shape): 253.42,65.14 253.42,64.96 252.57,64.12 251.84,64.12 251.26,63.54 250.39,63.54 250.22,63.71 249.31,63.71 249.3,63.72 249.3,64.94 249.35,64.99 250.37,64.99 250.55,65.17 251.82,65.17 251.92,65.27 253.29,65.27
+12VSUS on TOP (solid shape): 253.42,67.17 253.42,65.65 253.31,65.55 251.99,65.55 251.84,65.7 251.84,67.12 252.07,67.35 253.24,67.35
+DVDDL on TOP (solid shape): 228.75,90.11 228.75,89.15 228.91,88.99 228.91,88.41 229.16,88.15 229.18,88.15 229.28,87.74 229.66,87.56 229.71,87.56 230.09,87.7 230.22,88.09 230.25,88.17 230.33,88.2 230.46,88.22 230.58,88.28 232.84,88.28 233.1,88.03 233.1,85.74 231.54,85.74 230.14,84.34 228.52,84.34 228.52,87.99 228.4,88.11 228.4,88.95 228.4,88.96 228.4,90.05 228.55,90.2 228.66,90.2
+DVDDL on BOTTOM (solid shape): 230.28,88.99 230.28,87.27 230.18,87.17 229.26,87.17 228.96,87.47 228.96,87.75 228.96,87.75 228.96,89.15 228.98,89.17 230.1,89.17
+V1P0A_VCCAMPHYPLL_W25MIL on BOTTOM (solid shape): outline of 175 points within 152.57,38.19 160.93,42.61
+V1P0A_VCCF24_W15MIL on TOP (solid shape): 163.64,68.02 163.64,64.93 163.64,64.93 163.64,63.88 164.31,63.21 164.31,62.98 163.96,62.63 162.83,62.63 162.68,62.78 162.68,63.38 162.75,63.45 162.75,67.28 162.75,67.29 162.75,67.67 162.59,67.84 162.59,68.27 162.69,68.37 163.3,68.37
+VBUS1 on TOP (solid shape): 259.26,22.35 259.26,19.65 259.13,19.52 258.62,19.52 258.5,19.65 258.5,20.29 258.24,20.54 257.61,20.54 257.35,20.79 257.35,21.3 256.72,21.94 254.19,21.94 254.19,21.95 253.54,21.95 253.42,22.06 253.42,24.02 253.75,24.35 253.75,24.92 254.1,25.27 256.34,25.27
+VBUS1 on TOP (solid shape): 240.14,53.27 240.14,53.04 240.07,52.97 240.04,52.97 239.95,52.97 239.86,52.95 239.85,52.94 239.56,52.94 239.49,52.95 239.4,52.94 239.31,52.88 239.25,52.78 239.24,52.77 239.04,52.57 239.02,52.57 238.77,52.32 237.79,52.32 237.72,52.39 237.7,52.42 237.7,52.62 238.02,52.94 238.43,52.94 238.89,53.4 240.01,53.4
+VBUS1 on TOP (solid shape): 245.67,55.21 246.38,55.21 246.38,55.21 248.58,55.21 249.48,54.31 249.48,53.65 249.41,53.57 248.75,53.57 248.4,53.92 244.6,53.92 244.36,53.91 244.23,53.7 244.23,53.62 244.18,53.62 244.03,53.47 244.01,53.48 243.82,53.42 243.72,53.27 243.71,53.24 243.71,53.2 243.68,53.13 243.6,53.1 243.36,53.1 243.27,53.2 243.25,53.28 243.22,53.35 243.14,53.43 243.03,53.47 242.99,53.48 242.9,53.48 242.9,54.28 242.92,54.33 242.93,54.37 242.93,54.45 243.29,54.82 243.76,54.82 243.76,55.21 243.89,55.34 245.54,55.34
+VBUS1 on BOTTOM (solid shape): 267.69,27.4 267.69,27.16 267.51,26.98 267.29,26.98 266.84,26.53 265.93,26.53 265.89,26.58 265.89,27.4 265.94,27.45 267.64,27.45
+VBUS1 on BOTTOM (solid shape): 266.89,25.06 267.57,25.06 267.6,25.04 267.6,24.64 267.54,24.58 266.15,24.58 266.07,24.51 265.97,24.51 265.91,24.57 265.91,25.44 265.93,25.46 266.49,25.46
+VBUS1 on BOTTOM (solid shape): 254.52,23.88 255.47,23.43 257.33,22.89 258.68,22.89 259.17,22.4 259.17,19.84 258.88,19.55 258.63,19.55 257.61,20.03 257.38,20.13 254.36,21.68 253.8,21.68 253.29,22.19 253.29,24.1 253.54,24.35 254.05,24.35
+VBUS1 on IN1 (solid shape): 249.86,54.2 249.86,53.31 249.73,53.18 247.32,53.18 246.98,53.52 246.98,55.01 247.18,55.21 248.84,55.21
+VBUS1 on IN1 (solid shape): 255.75,26.53 255.75,22.19 255.24,21.67 253.79,21.67 253.22,22.24 253.22,24.92 255.16,26.86 255.42,26.86
+VBUS1 on IN1 (solid shape): 239.83,52.93 239.83,52.42 239.7,52.29 239.18,52.29 239.04,52.32 238.9,52.29 237.67,52.29 237.54,52.42 237.54,52.64 237.63,52.76 237.67,52.91 237.71,52.98 237.79,53 238.08,52.98 238.36,53.05 238.37,53.05 239.7,53.05
+VBUS1 on IN2 (solid shape): outline of 878 points within 257.33,19.1 267.79,29.03
+VCC_SYS_HV on TOP (solid shape): 239.65,52.26 239.65,52.03 239.82,51.86 240.06,51.86 240.16,51.76 240.16,51.6 240.08,51.53 239.7,51.53 239.62,51.45 239.62,51.15 239.59,51.11 239.47,51.11 239.44,51.12 239.4,51.12 239.37,51.12 239.34,51.15 239.34,51.4 238.89,51.86 238.89,52.21 239.01,52.34 239.57,52.34
+VCCGT on TOP (solid shape): outline of 1213 points within 9.91,132.98 41.58,160.48
+VCCGT on BOTTOM (solid shape): outline of 3173 points within 10.96,132.71 41.71,159.4
+VCCGT on IN1 (solid shape): outline of 3537 points within 9.45,132.98 41.45,159.65
+VCCGT on GND2 (solid shape): 36.12,156.12 36.12,154.53 36.13,154.48 36.16,154.44 39.08,151.52 39.12,151.49 39.17,151.48 40.64,151.48 41.45,150.66 41.45,142.51 40.98,142.04 40.95,142 40.95,141.95 40.95,133.06 40.95,133.01 40.98,132.97 41.02,132.94 25.25,132.94 24.94,133.24 24.94,149.95 24.93,150 24.91,150.04 22.66,152.29 22.66,152.87 22.65,152.92 22.62,152.96 22.28,153.31 22.28,154.6 24.11,156.43 35.81,156.43
+VCCGT on IN2 (solid shape): outline of 4572 points within 21.9,132.98 41.45,156.42
+VCCGT on IN3 (solid shape): outline of 6398 points within 11.23,132.98 41.46,156.48
+VCCGT on GND3 (solid shape): 42.47,151.43 42.47,134.89 42.29,134.71 26.14,134.71 25.07,135.78 25.07,143.6 25.06,143.65 25.03,143.69 24.78,143.95 24.74,143.98 24.69,143.98 22.07,143.98 20.59,145.47 20.55,145.5 20.5,145.51 11.15,145.51 10.72,145.94 10.72,153.97 13.18,156.43 37.46,156.43
+VCCGT on IN4 (solid shape): outline of 4605 points within 11.34,134.08 42.47,156.48
+VCCIO on BOTTOM (solid shape): 72.95,150.17 72.95,147.84 69.99,144.88 68.86,144.88 68.7,145.04 68.7,145.47 68.71,145.48 68.71,146.12 67.87,146.95 67.87,147.5 67.68,147.69 67.54,147.69 67.45,147.78 67.45,150.19 67.48,150.22 69.06,150.22 69.19,150.08 71.69,150.08 72.08,150.47 72.64,150.47
+VCCIO on BOTTOM (solid shape): outline of 134 points within 54.92,134.63 58.47,144.67
+VCCIO on IN1 (solid shape): outline of 1547 points within 55.93,133.19 71.64,147.84
+VCCIO on IN2 (solid shape): outline of 1919 points within 55.93,130.7 69.86,144.29
+VCCIO on IN3 (solid shape): outline of 3452 points within 18.5,126.85 44.24,135.05
+VCCIO on IN4 (solid shape): outline of 1396 points within 55.93,133.36 69.85,144.29
+VCCPFUSE_W20MIL on BOTTOM (solid shape): 182.22,62.22 182.22,61.86 181.66,61.31 181.44,61.31 181.37,61.31 181.32,61.36 181.13,61.54 180.86,61.56 180.83,61.55 180.73,61.65 180.73,61.9 180.77,61.98 180.86,61.99 181.05,62 181.2,62.12 181.21,62.13 181.28,62.18 181.3,62.16 181.5,62.15 181.65,62.26 181.75,62.35 182.09,62.35
+VCCPGPPCD_W15MIL on BOTTOM (solid shape): 180.62,41.75 180.62,41.31 180.75,41.18 180.75,41.1 180.82,41.03 180.82,41.02 180.87,40.95 180.95,40.89 180.95,40.89 181.59,40.26 181.59,40.16 181.31,39.89 181.21,39.89 180.22,40.87 179.91,40.87 179.72,40.92 179.53,40.87 179.5,40.87 179.43,40.94 179.43,41.21 179.49,41.26 179.63,41.26 179.72,41.18 179.93,41.18 180.28,41.52 180.28,41.77 180.34,41.83 180.54,41.83
+VCCPLL_OC on TOP (solid shape): outline of 564 points within 22.28,128.41 27.89,133.03
+VCCSA on TOP (solid shape): 77.57,167.68 77.57,162.73 76.85,162.01 76.64,162.01 76.32,162.09 76.06,161.87 76.04,161.84 76.03,161.8 75.71,161.48 75.71,159.7 71.17,155.16 70.66,155.16 69.65,156.18 69.65,160.22 69.66,160.25 71.8,164.39 73.25,167.73 77.52,167.73
+VCCSA on TOP (solid shape): outline of 1157 points within 55,145.58 69.65,155.47
+VCCSA on BOTTOM (solid shape): 76.51,171.26 76.51,168.29 76.76,168.04 76.76,165.62 76.39,165.26 72.68,165.26 71.55,166.39 71.55,168.29 71.55,168.3 71.55,169.24 74.13,169.24 74.13,168.61 74.18,168.61 74.18,168.48 74.66,168.48 74.66,168.51 74.67,168.54 74.69,168.56 74.71,168.58 74.74,168.59 74.77,168.59 74.8,168.59 74.84,168.57 74.89,168.55 74.94,168.54 75,168.54 75.05,168.55 75.11,168.56 75.16,168.59 75.21,168.62 75.25,168.65 75.28,168.69 75.32,168.74 75.34,168.79 75.35,168.84 75.36,168.9 75.36,168.95 75.35,169.01 75.34,169.06 75.32,169.11 75.28,169.16 75.25,169.2 75.21,169.23 75.16,169.26 75.11,169.29 75.05,169.3 75,169.31 74.94,169.31 74.89,169.3 74.84,169.28 74.8,169.26 74.77,169.26 74.74,169.26 74.71,169.27 74.69,169.29 74.67,169.31 74.66,169.34 74.66,169.37 74.18,169.37 74.18,169.24 71.55,169.24 71.55,171.59 72.06,172.1 75.67,172.1
+VCCSA on BOTTOM (solid shape): outline of 478 points within 54.66,145 57.3,152.54
+VCCSA on IN1 (solid shape): outline of 439 points within 54.61,146.42 76.63,167.61
+VCCSA on GND2 (solid shape): 76.51,167.55 76.51,162.07 70.61,156.18 62.79,156.18 62.74,156.17 62.7,156.14 56.35,149.79 56.32,149.75 56.31,149.7 56.31,146.7 56.13,146.52 55.09,146.52 54.92,146.7 54.92,152.7 59.03,156.81 60.5,156.81 60.55,156.82 60.59,156.85 60.97,157.23 61,157.27 61.01,157.32 61.01,158.41 61.19,158.59 66.09,158.59 66.14,158.6 66.18,158.63 72.66,165.1 72.69,165.15 72.7,165.19 72.7,167.05 73.64,167.99 76.07,167.99
+VCCSA on IN2 (solid shape): outline of 198 points within 54.61,146.57 76.61,168.16
+VCCSA on IN3 (solid shape): outline of 197 points within 54.6,146.57 76.61,168.16
AGND on TOP (solid shape): 13.39,74.27 14.14,74.27 14.36,74.05 14.36,73.85 14.36,73.85 14.78,73.42 14.78,73.17 15.04,72.91 15.04,72.66 14.91,72.53 14.47,72.53 14.03,72.96 14.03,72.97 13.86,73.14 13.04,73.14 11.99,74.2 11.99,74.72 12.12,74.85 12.81,74.85
AGND on BOTTOM (solid shape): 13.16,74.66 12.88,74.37 12,74.37 11.86,74.52 11.86,74.99 11.86,75 11.86,75.36 12.14,75.63 13.16,75.63
AGND on GND1 (solid shape): 21.01,77.76 21.01,75.53 21.01,75.47 21.03,75.42 21.26,74.96 21.26,74.56 21.28,74.47 21.33,74.38 21.46,74.26 21.54,74.2 21.64,74.18 22.15,74.18 22.15,72.51 21.92,72.28 17.32,72.28 17.23,72.26 17.14,72.2 16.89,71.95 16.83,71.87 16.82,71.77 16.82,67.45 16.83,67.35 16.89,67.27 17.14,67.02 17.23,66.96 17.32,66.94 18.34,66.94 18.34,65.27 17.8,64.74 15.27,64.74 15.16,64.84 15.16,66.11 15.14,66.21 15.09,66.29 14.81,66.57 14.73,66.62 14.63,66.64 13.72,66.64 13.64,66.72 13.64,67.4 13.62,67.5 13.57,67.58 12.93,68.22 12.85,68.27 12.75,68.29 12.48,68.29 11.66,69.11 11.58,69.16 11.48,69.18 9.07,69.18 9.01,69.18 8.95,69.16 8.75,69.05 8.41,69.05 8.31,69.16 8.31,72.51 8.41,72.61 11.23,72.61 11.32,72.63 11.41,72.69 11.79,73.07 11.84,73.15 11.86,73.25 11.86,74.92 12.73,75.79 14.15,75.79 14.25,75.81 14.33,75.86 14.71,76.24 14.76,76.32 14.78,76.42 14.78,78.14 15.14,78.5 20.27,78.5
AGND on GND2 (solid shape): 21.01,77.76 21.01,75.53 21.01,75.47 21.03,75.42 21.26,74.96 21.26,74.56 21.28,74.47 21.33,74.38 21.46,74.26 21.54,74.2 21.64,74.18 22.15,74.18 22.15,72.51 21.92,72.28 17.32,72.28 17.23,72.26 17.14,72.2 16.89,71.95 16.83,71.87 16.82,71.77 16.82,67.45 16.83,67.35 16.89,67.27 17.14,67.02 17.23,66.96 17.32,66.94 18.34,66.94 18.34,65.27 17.8,64.74 15.27,64.74 15.16,64.84 15.16,66.11 15.14,66.21 15.09,66.29 14.81,66.57 14.73,66.62 14.63,66.64 13.72,66.64 13.64,66.72 13.64,67.4 13.62,67.5 13.57,67.58 12.93,68.22 12.85,68.27 12.75,68.29 12.48,68.29 11.66,69.11 11.58,69.16 11.48,69.18 9.07,69.18 9.01,69.18 8.95,69.16 8.75,69.05 8.41,69.05 8.31,69.16 8.31,72.51 8.41,72.61 11.23,72.61 11.32,72.63 11.41,72.69 11.79,73.07 11.84,73.15 11.86,73.25 11.86,74.92 12.73,75.79 14.15,75.79 14.25,75.81 14.33,75.86 14.71,76.24 14.76,76.32 14.78,76.42 14.78,78.14 15.14,78.5 20.27,78.5
AGND on GND3 (solid shape): 21.01,77.76 21.01,75.53 21.01,75.47 21.03,75.42 21.26,74.96 21.26,74.56 21.28,74.47 21.33,74.38 21.46,74.26 21.54,74.2 21.64,74.18 22.15,74.18 22.15,72.51 21.92,72.28 17.32,72.28 17.23,72.26 17.14,72.2 16.89,71.95 16.83,71.87 16.82,71.77 16.82,67.45 16.83,67.35 16.89,67.27 17.14,67.02 17.23,66.96 17.32,66.94 18.34,66.94 18.34,65.27 17.8,64.74 15.27,64.74 15.16,64.84 15.16,66.11 15.14,66.21 15.09,66.29 14.81,66.57 14.73,66.62 14.63,66.64 13.72,66.64 13.64,66.72 13.64,67.4 13.62,67.5 13.57,67.58 12.93,68.22 12.85,68.27 12.75,68.29 12.48,68.29 11.66,69.11 11.58,69.16 11.48,69.18 9.07,69.18 9.01,69.18 8.95,69.16 8.75,69.05 8.41,69.05 8.31,69.16 8.31,72.51 8.41,72.61 11.23,72.61 11.32,72.63 11.41,72.69 11.79,73.07 11.84,73.15 11.86,73.25 11.86,74.92 12.73,75.79 14.15,75.79 14.25,75.81 14.33,75.86 14.71,76.24 14.76,76.32 14.78,76.42 14.78,78.14 15.14,78.5 20.27,78.5
AGND on GND4 (solid shape): 21.01,77.76 21.01,75.53 21.01,75.47 21.03,75.42 21.26,74.96 21.26,74.56 21.28,74.47 21.33,74.38 21.46,74.26 21.54,74.2 21.64,74.18 22.15,74.18 22.15,72.51 21.92,72.28 17.32,72.28 17.23,72.26 17.14,72.2 16.89,71.95 16.83,71.87 16.82,71.77 16.82,67.45 16.83,67.35 16.89,67.27 17.14,67.02 17.23,66.96 17.32,66.94 18.34,66.94 18.34,65.27 17.8,64.74 15.27,64.74 15.16,64.84 15.16,66.11 15.14,66.21 15.09,66.29 14.81,66.57 14.73,66.62 14.63,66.64 13.72,66.64 13.64,66.72 13.64,67.4 13.62,67.5 13.57,67.58 12.93,68.22 12.85,68.27 12.75,68.29 12.48,68.29 11.66,69.11 11.58,69.16 11.48,69.18 9.07,69.18 9.01,69.18 8.95,69.16 8.75,69.05 8.41,69.05 8.31,69.16 8.31,72.51 8.41,72.61 11.23,72.61 11.32,72.63 11.41,72.69 11.79,73.07 11.84,73.15 11.86,73.25 11.86,74.92 12.73,75.79 14.15,75.79 14.25,75.81 14.33,75.86 14.71,76.24 14.76,76.32 14.78,76.42 14.78,78.14 15.14,78.5 20.27,78.5
GND on TOP (solid shape): 14.3,66.87 14.26,66.83 12.62,66.83 12.62,67.58 14.3,67.58
GND on TOP (solid shape): 162.48,21.81 162.23,21.56 160.45,21.56 160.45,21.94 160.96,22.45 162.48,22.45
GND on TOP (solid shape): 14.28,103.42 14.28,100.8 13.64,100.17 11.35,100.17 10.47,101.06 10.47,103.59 14.1,103.59
GND on TOP (solid shape): 54.03,26.79 54.03,25.95 50.57,25.95 50.44,26.08 50.44,26.76 50.6,26.92 53.9,26.92
GND on TOP (solid shape): 69.69,119.83 71.15,119.83 71.15,113.69 67.01,113.69 67.01,120.03 67.19,120.22 69.31,120.22
GND on TOP (solid shape): 239.47,91.13 239.47,90.54 239.39,90.45 237.72,90.45 237.15,91.01 237.15,91.68 238.93,91.68
GND on TOP (solid shape): 23.5,109.47 23.5,108.65 23.03,108.18 22.58,108.18 22.32,108.45 22.32,109.55 22.58,109.82 23.16,109.82
GND on TOP (solid shape): 33.25,117.77 33.25,112.31 33.15,112.21 30.4,112.21 30.12,112.49 30.12,118.05 30.35,118.28 32.74,118.28
GND on TOP (solid shape): 34.21,111.11 34.21,106.77 33.96,106.52 30.79,106.52 30.56,106.75 30.56,111.19 30.76,111.39 33.93,111.39
GND on TOP (solid shape): 39.27,137 39.27,134.46 39.14,134.33 38.38,134.33 38.35,134.36 38.35,137.07 38.41,137.12 39.14,137.12
GND on TOP (solid shape): 46.76,132.09 46.76,129.76 46.66,129.66 45.9,129.66 45.77,129.78 45.77,132.04 45.95,132.22 46.63,132.22
GND on TOP (solid shape): 47.83,124.85 47.83,124.45 47.1,123.71 46.41,123.71 46.32,123.8 46.32,124.65 46.58,124.9 47.77,124.9
GND on TOP (solid shape): 51.89,137.23 51.89,133.85 51.79,133.75 50.67,133.75 50.57,133.85 50.57,137.25 50.62,137.3 51.82,137.3
GND on TOP (solid shape): 52.27,131.84 52.27,129.76 52.17,129.66 51.49,129.66 51.33,129.81 51.33,132.02 51.44,132.12 51.99,132.12
GND on TOP (solid shape): 57.4,153.24 57.4,152.75 56.78,152.13 56.28,152.13 56.22,152.18 56.22,153.03 56.48,153.29 57.35,153.29
GND on TOP (solid shape): 93.37,151.08 93.37,150.34 93.12,150.1 92.06,150.1 91.78,150.39 91.78,150.92 92.08,151.23 93.22,151.23
GND on TOP (solid shape): 97.25,127.71 97.25,127.04 97.15,126.94 95.38,126.94 95,127.31 95,127.64 95.18,127.81 97.15,127.81
GND on TOP (solid shape): 101.88,68.03 101.88,66.98 101.79,66.88 101.1,66.88 100.95,67.04 100.95,68.01 101.1,68.16 101.75,68.16
GND on TOP (solid shape): 102.77,51.32 102.77,46.75 102.59,46.57 97.51,46.57 97.18,46.9 97.18,50.45 98.17,51.44 102.66,51.44
GND on TOP (solid shape): 105.3,167.34 105.3,166.34 105.2,166.24 104.4,166.24 104.28,166.36 104.28,167.31 104.39,167.42 105.21,167.42
GND on TOP (solid shape): 122.15,73.04 122.15,70.76 122.07,70.68 119.86,70.68 119.74,70.81 119.74,73.07 119.76,73.09 122.1,73.09
GND on TOP (solid shape): 127.1,168.69 127.1,167.74 126.89,167.52 126.2,167.52 125.99,167.73 125.99,168.76 126.06,168.82 126.97,168.82
GND on TOP (solid shape): 130.81,60.75 130.81,59.73 130.45,59.38 129.59,59.38 129.41,59.56 129.41,60.06 130.18,60.83 130.73,60.83
GND on TOP (solid shape): 148.78,98.37 148.78,97.32 148.73,97.27 148.03,97.27 147.78,97.52 147.78,98.4 147.87,98.49 148.67,98.49
GND on TOP (solid shape): 210.13,79.65 210.13,79.14 210.01,79.01 208.92,79.01 208.66,79.27 208.66,79.88 208.69,79.9 209.88,79.9
GND on TOP (solid shape): 214.86,41.8 214.86,37.66 214.45,37.25 210.47,37.25 210.28,37.44 210.28,41.81 210.38,41.91 214.74,41.91
GND on TOP (solid shape): 247.5,66.23 247.5,65.72 247.32,65.55 245.11,65.55 244.91,65.75 244.91,66.26 245.03,66.39 247.35,66.39
GND on TOP (solid shape): 251.51,67.14 251.51,66 251.43,65.93 250.47,65.93 250.24,66.16 250.24,67.22 250.37,67.35 251.3,67.35
GND on TOP (solid shape): 251.61,57.62 251.61,55.92 251.59,55.89 249.94,55.89 249.86,55.97 249.86,57.57 249.94,57.65 251.59,57.65
GND on TOP (solid shape): 26.23,72.47 26.1,72.34 25.08,72.34 24.96,72.47 24.96,75.26 25.08,75.39 26.23,75.39
GND on TOP (solid shape): 54.92,131.46 54.92,129.55 54.84,129.48 54.2,129.48 54.15,129.53 54.15,131.46 54.2,131.51 54.86,131.51
GND on TOP (solid shape): 102.67,87.16 102.67,82.95 102.54,82.82 98.35,82.82 98.22,82.95 98.22,88.79 98.63,89.19 100.64,89.19
GND on TOP (solid shape): 130.89,97.43 130.89,97.15 130.77,97.04 130.45,96.94 127.97,96.94 127.74,97.17 127.74,97.53 127.99,97.78 130.53,97.78
GND on TOP (solid shape): 152.78,140.27 159.49,140.27 159.49,130.93 149.78,130.93 148.08,132.63 148.08,140.04 148.82,140.77 152.28,140.77
GND on TOP (solid shape): 244.42,60.31 244.42,59.91 244.16,59.65 244.15,59.66 243.22,59.66 243.09,59.78 243.09,60.22 243.34,60.46 244.27,60.46
GND on TOP (solid shape): 253.8,89.8 253.8,89.2 253.51,88.91 251.26,88.91 251,89.17 251,89.8 251.13,89.93 253.67,89.93
GND on TOP (solid shape): 253.92,12.03 253.92,11.14 253.67,10.89 248.46,10.89 248.46,12.16 248.72,12.41 253.54,12.41
GND on TOP (solid shape): 7.52,111.7 8.73,111.7 8.94,111.49 8.94,110.13 6.82,110.13 5.82,111.13 5.82,112.51 5.94,112.64 6.58,112.64
GND on TOP (solid shape): 12.58,78.16 12.58,77.44 12.26,77.13 10.79,77.13 10.69,77.22 10.69,78.29 10.92,78.51 12.22,78.51
GND on TOP (solid shape): 13.64,99.41 13.64,98.9 13.13,98.39 13.13,96.61 12.75,96.23 11.61,96.23 11.35,96.49 11.35,99.15 11.74,99.53 13.51,99.53
GND on TOP (solid shape): 94.03,175.99 94.03,172.05 93.9,171.92 92.51,171.92 92.13,172.31 92.13,174.97 92.76,175.61 92.76,176.37 93.65,176.37
GND on TOP (solid shape): 100.36,126.92 100.36,125.97 100,125.61 99.1,125.61 98.78,125.93 98.78,127.4 98.98,127.6 99.68,127.6
GND on TOP (solid shape): 113.22,49.15 113.22,48.5 112.95,48.23 109.91,48.23 109.78,48.35 109.78,49.5 110.02,49.74 112.63,49.74
GND on TOP (solid shape): 130.48,171 131.04,171 131.18,170.86 131.18,170.28 131.03,170.12 130.02,170.12 129.68,170.46 129.68,170.83 129.87,171.03 130.48,171.03
GND on TOP (solid shape): 133.76,103.67 133.76,103.24 133.73,103.22 131.95,103.22 131.47,102.73 131.24,102.73 131.09,102.88 131.09,103.9 131.19,104 133.43,104
GND on TOP (solid shape): 220.45,68.12 220.45,66.64 219.89,66.08 215.95,66.08 215.7,66.34 215.7,68.7 216.05,69.05 219.51,69.05
GND on TOP (solid shape): 242.39,67.48 242.39,66.31 242.29,66.21 241.35,66.21 241.25,66.31 241.25,67.45 241.4,67.6 242.27,67.6
GND on TOP (solid shape): 248.27,109.12 248.27,104.02 248.11,103.86 243.17,103.86 242.98,104.05 242.98,109.12 243.18,109.32 248.06,109.32
GND on TOP (solid shape): 254.6,133.22 254.64,133.22 257.42,130.44 257.42,129.81 257.31,129.71 257.2,129.71 253.21,133.7 253.21,134.21 253.62,134.21
GND on TOP (solid shape): 258.45,51.78 258.45,49.71 258.11,49.37 255.04,49.37 254.91,49.51 254.91,51.78 255.16,52.03 258.2,52.03
GND on TOP (solid shape): 27.32,23.57 27.32,22.59 26.74,22.01 24.51,22.01 24.31,22.21 24.31,23.05 24.49,23.23 25.51,23.23 25.95,23.67 27.22,23.67
GND on TOP (solid shape): 29.95,146.12 29.95,141.93 29.83,141.81 28.69,141.81 28.58,141.93 28.58,146.09 28.65,146.17 29.9,146.17
GND on TOP (solid shape): 35.87,131.46 35.87,129.3 35.67,129.11 34.91,129.11 34.85,129.17 34.85,130.08 34.96,130.08 34.96,131.37 35.17,131.59 35.74,131.59
GND on TOP (solid shape): 37.49,48.93 37.49,47.19 37.17,46.86 31.42,46.86 31.38,46.9 31.38,51.42 31.51,51.54 34.87,51.54
GND on TOP (solid shape): 105.47,69.11 106.31,69.11 106.48,68.95 106.48,68.34 106.4,68.27 104.45,68.27 104.25,68.47 104.25,69.27 104.46,69.48 105.11,69.48
GND on TOP (solid shape): 134.83,57.82 134.83,56.9 133.06,55.13 132.48,55.13 132.39,55.22 132.39,57.8 132.68,58.1 132.68,58.93 132.74,59 133.66,59
GND on TOP (solid shape): 153.36,155.68 153.36,154.29 153.09,154.02 152.3,154.02 152.12,154.2 152.12,154.99 152.23,155.1 152.59,155.1 152.92,155.42 152.92,155.72 153.31,155.72
GND on TOP (solid shape): 27.35,28.13 27.35,26.77 27.19,26.6 26.08,26.6 26.08,26.6 25.73,26.6 25.62,26.71 25.62,27.95 25.76,28.09 25.76,28.21 25.78,28.24 27.24,28.24
GND on TOP (solid shape): 38.96,146.12 38.96,141.98 38.86,141.87 37.67,141.87 37.59,141.95 37.59,146.14 37.64,146.19 38.89,146.19
GND on TOP (solid shape): 42.72,108.55 42.72,107.89 42.67,107.84 40.89,107.84 40.64,108.09 40.64,109.16 41.07,109.59 41.68,109.59
GND on TOP (solid shape): 44.98,149.58 44.98,149.09 45.3,149.09 45.3,147.74 44.98,147.74 44.98,147.3 44.92,147.24 44.52,147.24 44.42,147.34 44.42,149.51 44.51,149.6 44.97,149.6
GND on TOP (solid shape): 49.71,149.37 49.71,149.09 49.96,149.09 49.96,147.87 49.71,147.87 49.71,147.55 49.64,147.48 49.38,147.48 49.34,147.51 49.34,149.5 49.39,149.54 49.54,149.54
GND on TOP (solid shape): 125.87,59.62 125.87,58.68 125.27,58.08 122.66,58.08 122.3,58.44 122.3,58.86 122.49,59.05 123.09,59.05 123.3,59.26 123.3,59.71 123.79,60.2 125.28,60.2
GND on TOP (solid shape): 131.29,163.84 132.01,163.84 132.72,163.14 132.72,161.05 132.49,160.83 128,160.83 127.87,160.95 127.87,162.32 128.31,162.75 128.9,162.75 130.42,164.28 130.86,164.28
GND on TOP (solid shape): 147.5,108.42 147.5,107.28 149.28,105.5 149.28,100.93 148.51,100.17 145.21,100.17 144.7,100.68 144.7,109.82 146.1,109.82
GND on TOP (solid shape): 14.53,64.99 14.53,64.64 14.98,64.19 16.65,64.19 16.82,64.02 16.82,62.5 16.64,62.32 13.13,62.32 12.63,62.83 12.63,64.65 13.06,65.09 14.43,65.09
GND on TOP (solid shape): 28.47,149.38 28.47,149.09 28.73,149.09 28.73,147.88 28.59,147.74 28.47,147.74 28.47,147.62 28.2,147.35 28.15,147.35 28.09,147.42 28.09,149.5 28.1,149.52 28.33,149.52
GND on TOP (solid shape): 34.24,146.12 34.24,141.95 34.16,141.87 32.94,141.87 32.88,141.94 32.88,146.06 33.01,146.19 34.17,146.19
GND on TOP (solid shape): 46.53,152.54 46.53,151.14 46.42,151.03 46.4,151.02 46.05,151.02 45.99,151.06 45.9,151.14 45.9,152.54 46.03,152.67 46.41,152.67
GND on TOP (solid shape): 47.4,149.4 47.4,149.09 47.62,149.09 47.62,147.96 47.53,147.87 47.4,147.87 47.4,147.74 47.14,147.48 47.08,147.48 47,147.56 47,149.5 47.01,149.51 47.28,149.51
GND on TOP (solid shape): 48.82,152.54 48.82,151.14 48.69,151.02 48.41,151.02 48.34,151.06 48.26,151.09 48.24,151.09 48.18,151.14 48.18,152.54 48.31,152.67 48.69,152.67
GND on TOP (solid shape): 51.36,152.54 51.36,151.14 51.3,151.09 51.29,151.09 51.2,151.06 51.13,151.02 50.85,151.02 50.72,151.14 50.72,152.54 50.85,152.67 51.23,152.67
GND on TOP (solid shape): 52.1,149.44 52.1,149.09 52.4,149.09 52.4,147.89 52.38,147.87 52.1,147.87 52.1,147.59 51.95,147.44 51.87,147.44 51.72,147.59 51.72,149.48 51.79,149.54 52,149.54
GND on TOP (solid shape): 52.76,124.86 52.76,124.35 51.99,123.59 51.61,123.59 51.23,123.97 51.23,124.6 51.61,124.98 52.63,124.98
GND on TOP (solid shape): 73.17,152 73.17,151.06 72.76,150.65 72.26,150.65 70.83,149.23 70.24,149.23 69.94,149.52 69.94,152.28 70.41,152.75 72.42,152.75
GND on TOP (solid shape): 40.72,147.45 40.61,147.34 40.55,147.34 40.34,147.56 40.34,147.74 40.3,147.74 40.3,147.81 40.12,147.99 40.12,148.95 40.26,149.09 40.34,149.09 40.34,149.51 40.34,149.51 40.72,149.51
GND on TOP (solid shape): 117.4,68.17 117.4,66.9 116.56,66.06 109.7,66.06 109.53,65.88 106.86,65.88 106.81,65.93 106.81,67.92 107,68.12 114.96,68.12 115.16,68.32 117.25,68.32
GND on TOP (solid shape): 176.5,27.02 176.5,25.57 176.1,25.16 174.96,25.16 174.88,25.24 174.88,25.85 175.01,25.98 175.26,25.98 175.41,26.13 175.41,26.94 175.62,27.14 176.38,27.14
GND on TOP (solid shape): 233.6,53.24 237.22,53.24 237.56,52.9 237.56,52.78 237.54,52.71 237.54,52.64 237.09,52.19 232.56,52.19 232.46,52.29 232.46,52.54 233.22,53.31 233.56,53.31
GND on TOP (solid shape): 258.38,62.29 258.38,60.61 257.94,60.16 255.96,60.16 254.94,59.15 254.43,59.15 254.41,59.17 254.33,59.17 254.09,59.42 254.09,59.49 254.05,59.53 254.05,61.18 255.31,62.44 258.23,62.44
GND on TOP (solid shape): 33.11,131.7 33.12,131.7 33.4,131.42 33.4,130.18 33.14,129.92 33.15,129.89 33.15,129.7 32.38,129.7 32.38,128.6 32.13,128.85 32.12,128.87 32.12,131.98 32.28,132.15 32.67,132.15
GND on TOP (solid shape): 105.05,177.47 105.5,177.47 105.71,177.26 105.71,176.81 105.71,176.81 105.71,175.79 105.55,175.63 104.65,175.63 104.51,175.77 104.51,175.88 104.56,175.94 104.56,177.41 104.8,177.64 104.88,177.64
GND on TOP (solid shape): 134.11,100.98 134.11,100.24 134.01,100.14 133.99,100.14 133.84,100.13 133.72,100.05 132.93,100.05 132.36,100.62 132.36,101.03 132.44,101.11 133.99,101.11
GND on TOP (solid shape): 216.03,55.82 216.03,52.11 215.82,51.91 214.53,51.91 214.41,51.93 214.28,51.91 211.2,51.91 211,52.11 211,55.72 211.2,55.92 215.93,55.92
GND on TOP (solid shape): 113.58,109.4 113.58,108.76 114.25,108.08 114.25,107.55 114.11,107.41 113.3,107.41 113.28,107.43 113.28,107.91 112.31,108.88 112.31,108.96 112.3,108.97 112.3,109.53 112.43,109.66 113.32,109.66
GND on TOP (solid shape): 136.55,143.18 137.19,143.18 139.86,140.51 144.43,140.51 145.2,139.74 145.2,138.19 142.15,135.14 138.8,135.14 136.9,137.04 132.75,137.04 132.75,143.43 134.24,144.92 134.81,144.92
GND on TOP (solid shape): 228.27,88.66 228.27,84.72 227.89,84.34 226.62,84.34 226.62,84.35 225.25,84.35 224.01,85.59 224.01,87.07 224.46,87.52 226.49,87.52 227.76,88.79 228.14,88.79
GND on TOP (solid shape): 161.92,65.86 161.92,63.71 162.17,63.45 162.17,62.94 162.05,62.82 161.03,62.82 160.51,63.34 160.48,63.37 160.48,64.27 161.06,64.85 161.06,65.86 161.18,65.99 161.79,65.99
GND on TOP (solid shape): 127.61,67.2 128.45,67.2 128.83,66.82 128.83,66.07 127.14,64.38 127.14,64.34 125.77,64.34 124.63,65.48 124.63,66.17 125.3,66.84 125.3,67.38 125.55,67.63 127.18,67.63
GND on TOP (solid shape): 26.72,64.33 26.72,64.16 26.5,63.93 26.5,62.48 26.04,62.02 25.44,62.02 25.44,62.03 25.19,62.03 25.07,62.15 25.07,62.97 25.08,62.98 25.02,63.07 24.94,63.14 24.94,64.18 25.26,64.49 26.56,64.49
GND on TOP (solid shape): 107.16,118.31 107.34,118.23 107.54,118.26 107.55,118.26 108.45,118.26 108.64,118.07 108.64,113.4 108.33,113.1 106.71,113.1 106.59,113.22 106.59,117.83 107.07,118.31
GND on TOP (solid shape): 231.19,16.73 231.19,13.17 230.56,12.54 228.19,12.54 227.79,12.14 227.79,11.17 227.51,10.89 222.43,10.89 222.17,11.14 222.17,15.71 222.43,15.97 226.81,15.97 227.41,16.57 227.41,16.78 227.72,17.1 230.82,17.1
GND on TOP (solid shape): 237.9,38.9 237.9,38.5 238.05,38.35 238.05,38.35 237.94,38.23 237.75,38.23 237.69,38.3 237.23,38.3 237.11,38.41 237.11,38.42 236.97,38.42 236.94,38.45 236.78,38.45 236.65,38.57 236.65,38.75 236.66,38.75 236.66,38.84 236.79,38.98 237.82,38.98
GND on TOP (solid shape): 256.08,21.56 256.59,21.56 256.97,21.18 256.97,20.41 257.1,20.29 257.73,20.29 257.99,20.03 257.99,19.65 257.73,19.4 254.69,19.4 254.13,18.84 253.25,18.84 253.19,18.91 253.19,19.93 252.78,20.34 252.78,21.43 252.92,21.57 256.07,21.57
GND on TOP (solid shape): 257.35,69.12 257.92,69.12 258.04,69 258.04,68.41 257.75,68.13 257.75,68.09 257.73,68.06 256.4,68.06 256.34,68 255.6,68 255.43,68.18 254.56,68.18 254.45,68.29 254.45,68.78 254.89,69.22 255.22,69.22 255.33,69.33 257.13,69.33
GND on TOP (solid shape): 257.22,57.99 257.38,57.99 257.49,57.87 257.49,56.16 257.31,55.99 257.02,55.99 256.9,56.12 256.9,56.77 256.74,56.93 255.92,56.93 255.88,56.88 253.62,56.88 253.47,57.03 252.95,57.03 252.81,57.17 252.81,57.5 252.91,57.6 255.07,57.6 255.15,57.68 255.27,57.68 255.6,58.01 257.2,58.01
GND on TOP (solid shape): 110.44,111.35 110.44,109.44 112.34,107.54 112.34,100.89 112.34,100.88 112.32,100.69 112.41,100.52 112.41,99.16 112.32,99.07 107.49,99.07 107.11,99.46 107.11,102.88 107.06,102.94 104.32,106.75 104.32,112.03 104.7,112.41 109.37,112.41
GND on TOP (solid shape): 170.99,96.11 172.52,94.96 173.63,93.85 174.61,93.36 174.62,92.4 174.21,91.99 174.17,91.96 174.14,91.92 173.43,91.22 173.43,90.53 171.65,88.74 164.77,88.74 164.64,88.87 164.64,93.57 165.02,93.95 165.81,93.95 167.01,94.54 167.06,94.58 167.95,95.02 168.05,95.12 169.09,95.77 169.6,96.23
GND on TOP (solid shape): 60.15,182.75 60.15,182.21 60.07,182.14 58.28,182.14 58.16,182.26 58.16,182.51 58.36,182.71 58.56,182.71 58.97,182.61 59.29,182.87 60.02,182.87
GND on TOP (solid shape): 78.92,175.23 78.92,173.89 78.28,173.89 78.25,173.87 78.09,173.87 78.09,172.8 78.25,172.8 78.61,172.43 79.05,172.43 79.17,172.31 81.91,172.31 81.93,172.29 82.06,172.29 82.09,172.26 82.09,171.72 81.36,170.99 77.44,170.99 76,172.43 76,173.83 77.65,175.48 78.66,175.48
GND on TOP (solid shape): 98.37,109.82 98.58,109.7 98.82,109.73 98.93,109.62 98.93,108.4 98.92,108.39 98.92,107.04 98.42,106.53 98.21,106.53 98.15,106.47 97.69,106.47 97.52,106.63 97.52,109.44 97.89,109.81 98.22,109.81 98.24,109.82
GND on TOP (solid shape): 172.69,28.36 172.69,25.01 172.34,24.65 170.92,24.65 170.54,25.04 170,25.04 170,25.11 169.85,25.27 169.85,25.49 169.98,25.62 170.28,25.62 170.61,25.29 171.78,25.29 171.86,25.36 171.86,28.26 171.55,28.56 171.54,28.55 169.42,28.55 169.35,28.62 169.35,29.04 169.38,29.06 172,29.06
GND on TOP (solid shape): 50.01,146.19 50.01,143.55 50.09,143.48 50.09,138.27 49.96,138.14 49.37,138.14 48.48,137.25 48.48,133.84 48.38,133.75 47.22,133.75 47.12,133.85 47.12,137.93 47.46,138.27 47.46,145.21 47.46,145.22 47.46,146.18 47.55,146.27 49.94,146.27
GND on TOP (solid shape): 36.03,149.49 36.03,149.46 36.04,149.35 36.08,149.25 36.08,147.68 36.03,147.53 36.04,147.38 36.05,147.35 35.94,147.24 35.77,147.24 35.64,147.37 35.64,147.74 35.43,147.74 35.43,149.09 35.64,149.09 35.64,149.49 35.69,149.54 35.97,149.54
GND on TOP (solid shape): 158.79,113.9 159.71,111.66 159.71,104.16 159.35,103.64 158.78,102.51 158.5,101.57 158.29,100.8 158.17,100.68 157.53,100.68 157.02,101.19 157.02,106.65 156.47,107.2 156.47,109.21 156.47,109.22 156.49,109.36 156.47,109.51 156.47,109.52 156.47,110 156.01,110.46 156.01,114.9 156.26,115.16 157.53,115.16
GND on TOP (solid shape): 251.62,34.67 251.97,34.67 252,34.64 252,34.29 251.97,34.26 250.97,34.26 250.77,34.47 248.94,34.47 248.93,34.48 248.85,34.53 248.77,34.56 248.73,34.57 248.73,34.86 248.86,34.99 250.98,34.99 250.98,35 251.28,35
GND on TOP (solid shape): 34.73,161.67 34.73,156.29 35.6,155.42 35.79,155.42 35.91,155.3 35.91,154.57 35.77,154.43 35.45,154.43 34.85,155.03 31.8,155.03 31.67,155.16 31.67,155.67 31.04,156.3 29.13,156.3 28.5,156.94 28.5,158.76 26.72,160.54 26.72,161.81 26.98,162.07 34.34,162.07
GND on TOP (solid shape): 99.21,67.45 99.21,66.39 99.13,66.31 98.26,66.31 98.18,66.35 98.16,66.44 98.17,66.49 98.18,66.56 98.44,66.82 98.49,66.82 98.49,66.86 98.53,66.9 98.53,67.2 98.52,67.25 98.51,67.31 98.5,67.34 98.67,67.51 99.16,67.51
GND on TOP (solid shape): 31.2,149.53 31.27,149.5 31.3,149.43 31.3,149.39 31.31,149.34 31.31,147.58 31.3,147.51 31.3,147.44 31.31,147.42 31.18,147.29 31.1,147.29 30.94,147.45 30.94,147.74 30.65,148.03 30.64,148.03 30.64,148.93 30.8,149.09 30.94,149.09 30.94,149.53
GND on TOP (solid shape): 140.13,91.7 140.13,91.66 140.25,91.38 140.53,91.28 140.55,91.28 140.85,90.98 140.85,89.54 140.78,89.47 143.94,86.3 143.94,80.74 143.1,79.9 138.33,79.9 137.41,80.82 137.41,83.99 134.29,87.12 134.29,92.04 139.79,92.04
GND on TOP (solid shape): 44.77,172.74 44.66,172.63 44.13,172.63 43.99,172.49 43.99,171.66 44.01,171.64 44.7,171.64 44.75,171.58 44.75,170.52 44.67,170.45 41.02,170.45 40.78,170.21 40.78,169.18 40.52,168.92 36.5,168.92 36.25,169.18 36.25,172.48 36.5,172.73 39.68,172.73 39.93,172.48 43.06,172.48 43.33,172.75 43.33,173.97 43.37,174 44.77,174
GND on TOP (solid shape): 93.52,132.86 93.52,132.33 93.42,132.22 93.24,132.22 93.11,132.25 92.98,132.22 92.77,132.01 92.8,131.71 89.08,131.71 88.95,131.84 88.95,132.73 89.21,132.98 93.4,132.98
GND on TOP (solid shape): 115.04,129.54 115.92,129.54 116.03,129.43 116.03,129.12 115.99,129.07 115.29,129.07 115.24,129.11 114.98,129.11 114.85,129.17 114.72,129.18 114.58,129.17 114.46,129.11 114.43,129.11 114.35,129.19 114.35,129.6 114.24,129.71 113.94,129.71 113.88,129.77 113.88,130.08 113.9,130.11 114.47,130.11
