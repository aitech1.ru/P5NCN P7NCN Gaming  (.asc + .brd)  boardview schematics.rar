# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPSRC1_ML3_N: length 5.5
  TOP w0.089: U1101.AC21 237.53,29.61 237.57,29.57 237.57,29.45 237.5,29.38 237.12,29.38 237.01,29.49 236.64,29.49 236.59,29.45 236.53,29.45
  TOP w0.114: v1(235.13,27.32) 235.13,27.56 ; 235.13,27.56 235.38,27.56 235.94,28.12 235.94,29.1 236.06,29.22 236.29,29.45 236.53,29.45 ; 235.13,27.56 234.43,27.56 C1145.2
DPSRC1_ML3_P: length 5.5
  TOP w0.089: 236.53,29.68 237.02,29.68 237.16,29.83 237.62,29.83 U1101.AB21
  TOP w0.114: 235.71,28.72 235.71,29.2 235.82,29.32 236.19,29.68 236.53,29.68 ; 235.71,28.72 v1(235.46,28.72) ; 235.71,28.72 235.71,28.22 235.28,27.79 234.43,27.79 C1144.2
DRAMRST_R#: length 245.8
  TOP w0.102: v2(186.87,66.05) 187.27,65.65 187.27,65.28 187.44,65.12 187.98,65.12 R2485.1 ; v2(56.96,72.71) 56.67,72.71 56.29,73.09 56.29,74.66 57.66,76.04 60,76.04 60.38,76.42 CON1600.108 60.38,78.87 v2(60.52,79.01) ; v2(56.19,59.4) 56.19,63.14 57.15,64.1 60.07,64.1 60.38,64.4 CON1700.108
  IN1 w0.102: v2(106.37,64.2) 104.52,62.35 100.28,62.35 97.97,64.66 60.06,64.66 57.34,61.93 57.34,60.55 v2(56.19,59.4) 56.19,62.96 57.12,63.89 57.12,70.83 56.96,70.99 v2(56.96,72.71) ; v2(99.44,42.51) 103.54,42.51 105.22,44.19 111,44.19 112.29,42.89 116.66,42.89 116.72,42.94 134.54,42.94 136.88,40.61 145.53,40.61 146.37,39.77 157.38,39.77 158.93,41.32 160.07,41.32 160.42,40.97 171.51,40.97 172.25,41.7 179.08,41.7 179.4,42.02 180.09,42.02 180.16,41.95 180.49,41.95 181.17,42.62 181.17,59.49 185.01,63.34 185.63,63.34 186.45,64.16 186.45,65.64 v2(186.87,66.05)
  BOTTOM w0.102: v2(56.96,72.71) 56.96,71.31 58.38,69.89 CON1601.108 ; CON1701.108 58.38,57.97 57.46,58.89 56.69,58.89 v2(56.19,59.4) ; C1602.2 C1702.2 C1703.2 C1603.2 58.52,80.41 59.97,80.41 60.15,80.23 60.15,79.37 v2(60.52,79.01) ; v2(106.37,64.2) 107.13,64.2 108.28,63.06 108.28,51.2 104.61,47.53 101.46,47.53 99.44,45.51 v1(99.44,45.12) v2(99.44,42.51)
EC_AGND: length 4.8
  TOP w0.178: C3021.2 116.63,27.37 116.63,28.41 116.72,28.5 U3001.75
  TOP w0.381: v1(114.91,26.1) 114.99,26.19 R3048.2
  TOP w0.457: R3048.2 116.33,26.44 C3021.2
EC_KBL_LED1_CON: length 30.7
  TOP w0.102: R3094.2 129.45,28.48 131.97,28.48 132.08,28.37 132.08,25.27 v1(132.54,24.81) 133.3,25.57 133.3,26.33 133.66,26.7 134.38,26.7 135.18,27.49 135.18,30.37 136.47,31.67 136.96,31.67 137.41,32.12 137.41,32.85 136.73,33.53 136.73,35.68 136.97,35.91 139.89,35.91 140.86,36.88 144.94,36.88 Q3108.1
EC_KBL_LED1_CON_M: length 19.5
  TOP w0.102: v1(147.19,36.26) 145.47,36.26 144.83,35.63 Q3108.3 142.36,35.11 141.68,34.43 139.71,34.43 139.34,34.07 139.34,32.63 140.54,31.44 140.54,29.84 140.98,29.4 U3102.6 140.98,26.62 140.56,26.21 v2(140.51,26.21)
  BOTTOM w0.102: CON3110.3 139.75,26.83 139.94,26.64 140.36,26.64 140.51,26.49 v2(140.51,26.21)
EC_KBL_LED2_CON: length 11.1
  TOP w0.102: R3095.2 132.28,28.48 132.28,26.92 v1(132.59,26.62) 132.87,26.9 134.3,26.9 134.98,27.58 134.98,30.47 135.71,31.21 135.71,31.95 136.18,32.41 Q3109.1
EC_KBL_LED2_CON_M: length 22.4
  TOP w0.102: v2(139.9,26.23) 140.33,26.66 U3102.7 140.33,29.38 139.15,30.56 Q3109.3
  BOTTOM w0.102: CON3110.4 139.25,26.89 139.9,26.24 v2(139.9,26.23) 141.16,24.97 141.16,23.86 140.49,23.18 132.49,23.18 131.24,24.43 v1(129.67,24.43)
EC_KBL_LED3_CON: length 17.6
  TOP w0.102: R3096.2 133.11,27.13 134.24,27.13 134.77,27.66 134.77,30.62 135.51,31.35 135.51,32.97 v1(136.29,33.75) 136.4,33.86 136.4,35.63 136.88,36.11 139.8,36.11 141.41,37.72 Q3110.1
EC_KBL_LED3_CON_M: length 20
  TOP w0.102: v1(147.24,38.04) 145.67,36.47 143.24,36.47 141.89,35.11 Q3110.3 139.98,35.11 139.14,34.28 139.14,32.94 138.46,32.25 138.46,30.7 139.68,29.48 U3102.8 139.68,26.64 v2(139.27,26.23)
  BOTTOM w0.102: CON3110.5 138.75,26.86 139.27,26.33 v2(139.27,26.23)
EC_KBL_LED4_CON: length 13.4
  TOP w0.102: R3097.2 134.11,27.53 134.39,27.81 134.39,30.07 v1(134.16,30.29) 135.31,31.44 135.31,33.54 135.31,33.71 135.97,34.37 135.97,35.48 136.8,36.31 138.02,36.31 138.42,36.71 Q3111.1
EC_KBL_LED4_CON_M: length 11.7
  TOP w0.102: v2(137.98,26.21) 137.73,26.46 U3102.11 137.73,29.8 138.25,30.32 138.25,32.33 138.92,33 138.92,33.45 v1(138.61,33.76) 138.33,34.04 138.33,34.89 138.11,35.11 Q3111.3
  BOTTOM w0.102: CON3110.6 138.25,26.47 v2(137.98,26.21)
EC_RST#: length 11.2
  TOP w0.102: U3001.14 119.92,47.14 C3011.1 120.38,47.6 120.38,48.48 120.52,48.62 120.52,49.94 120.85,50.27 v1(120.85,51.35) 120.85,52.1 121.31,52.55 D5004.3 122,54.02 R5004.2 C5002.1
EDP_AUX_DN_C: length 2
  BOTTOM w0.114: C4530.2 61.29,175.61 61.29,176.6 60.97,176.92 L4505.1
EDP_AUX_DN_R: length 8.2
  TOP w0.114: v2(63.08,182.89) 63.15,182.89 63.43,182.62 63.43,182.13 63.25,181.96 CON4500.15
  BOTTOM w0.114: RN4505.4 60.99,178.94 61.27,179.21 61.27,179.54 R4523.2 61.29,180.33 61.29,180.48 61.68,180.86 63.04,180.86 63.42,181.25 63.42,182.57 63.1,182.89 v2(63.08,182.89)
EDP_AUX_DP_C: length 2
  BOTTOM w0.114: C4529.2 61.53,175.7 61.53,176.6 61.82,176.89 L4505.4
EDP_AUX_DP_R: length 8.1
  TOP w0.114: CON4500.14 63.75,181.91 63.66,182 63.66,182.74 v2(63.81,182.89)
  BOTTOM w0.114: v2(63.81,182.89) 63.66,182.74 63.66,181.15 63.14,180.63 61.77,180.63 61.52,180.38 61.52,180.28 61.61,180.19 61.76,180.19 R4524.2 61.5,179.5 61.5,179.23 61.82,178.91 L4505.3
EDP_AUXN: length 58.8
  IN4 w0.089: v2(61.52,173.24) 61.72,173.44 61.72,174.82 62.08,175.18 71.3,175.18 72.31,174.17 72.31,173.45 69.93,171.08 69.93,170.84 67.63,168.53 67.63,154.11 71.19,150.56 71.19,145.32 69.55,143.68 66.78,143.68 66.13,143.03 65.6,143.03 65.38,143.25 65.38,143.66 65.18,143.86 v6(65.18,143.86)
  BOTTOM w0.076: v6(65.18,143.86) 65.18,143.85 64.83,143.5 63.43,143.5 63.04,143.11 62.8,143.11 62.64,143.27 61.37,143.27 61.27,143.38 61.27,143.48 61.36,143.58 U0300.B26
  BOTTOM w0.114: v2(61.52,173.24) 61.52,173.47 61.34,173.65 61.34,174.13 C4530.1
EDP_AUXP: length 58.8
  IN4 w0.089: v2(65.76,143.86) 65.76,143.84 65.56,143.63 65.56,143.33 65.67,143.21 66.06,143.21 66.7,143.86 69.48,143.86 71.01,145.39 71.01,150.49 67.46,154.04 67.46,168.61 69.76,170.91 69.76,171.15 72.13,173.53 72.13,174.1 71.23,175 62.15,175 61.9,174.75 61.9,173.5 v2(62.15,173.24)
  BOTTOM w0.076: 65.27,143.47 65.04,143.47 64.9,143.34 63.5,143.34 63.11,142.95 62.73,142.95 62.57,143.11 61.3,143.11 61.1,143.31 61.1,143.5 61.03,143.58 U0300.C26
  BOTTOM w0.114: C4529.1 61.58,174.14 61.58,173.74 61.68,173.64 61.97,173.64 62.15,173.45 v2(62.15,173.24) ; 65.27,143.47 65.38,143.47 v2(65.76,143.86)
EDP_HPD: length 412.8
  TOP w0.102: R4501.2 44.45,181.55 44.45,183.23 44.86,183.63 46.25,183.63 46.81,184.2 59.53,184.2 60.68,183.05 v2(60.68,182.64) 60.75,182.57 CON4500.20
  IN1 w0.102: v2(150.85,41.78) 151.16,42.08 155.2,42.08 155.67,41.61 157.92,41.61 158.24,41.92 160.32,41.92 160.67,41.58 171.26,41.58 175.1,45.42 176.93,45.42 177.02,45.33 177.44,45.33 178,45.89 179.1,45.89 180.47,47.26 180.47,58.49 v2(179.33,59.63)
  IN2 w0.102: v2(17.12,182.54) 17.12,181.94 11.56,176.38 11.56,173.78 13.41,171.92 13.41,166.09 13.16,165.83 12.25,165.83 7.39,160.97 7.39,151.66 8.58,150.46 8.58,143.99 7.51,142.93 7.51,142.65 4.27,139.41 4.27,126.42 5.7,124.99 5.7,124.42 6.5,123.61 6.5,119.06 7.66,117.9 7.66,105.26 7.11,104.71 7.11,88.64 7.29,88.46 7.29,86.56 7.7,86.15 8.26,86.15 8.72,85.68 8.72,75.96 5.44,72.67 5.44,69.43 7.66,67.2 8.27,67.2 9.55,65.92 9.55,64.96 10.84,63.67 11.99,63.67 12.75,62.91 19.29,62.91 19.8,62.4 22.04,62.4 24.51,59.92 24.51,58.04 28.3,54.26 28.3,50.13 36.83,41.6 38.24,41.6 40.56,39.27 40.56,37.92 42.17,36.31 48.39,36.31 49.27,37.19 97.4,37.19 98.14,36.45 106.82,36.45 107.35,35.93 109.88,35.93 110.65,36.69 117.07,36.69 117.15,36.77 122.91,36.77 124.71,38.57 147.76,38.57 149.94,40.76 149.94,41.57 150.36,41.98 150.65,41.98 v2(150.85,41.78)
  IN3 w0.102: v2(60.68,182.64) 60.68,182.1 59.84,181.25 47.8,181.25 47.49,181.56 45.04,181.56 44.68,181.2 42.49,181.2 41.76,181.92 38.12,181.92 37.79,181.59 37.79,180.8 36.51,179.53 27.02,179.53 26.5,180.05 19.62,180.05 v2(17.12,182.54)
  BOTTOM w0.089: v2(179.33,59.63) 179.45,59.5 179.99,59.5 180.39,59.9 U2000.BD7
  BOTTOM w0.102: v2(60.68,182.64) 60.21,183.11 T4505.1 60.88,184.24 C4526.2 R4586.2
EDP_TX0_DN_C: length 2.1
  BOTTOM w0.114: L4504.4 64.36,176.9 64.05,176.59 64.05,175.72 C4533.2
EDP_TX0_DN_R: length 6.7
  TOP w0.114: v2(65.34,182.89) 65.13,182.68 65.13,182.01 65.25,181.89 CON4500.11
  BOTTOM w0.114: 65.03,181.75 65.03,182.59 v2(65.34,182.89) ; 65.03,181.75 v1(65.28,181.75) ; 65.03,181.75 65.03,180.9 64.13,179.99 64.13,179.25 64.36,179.02 L4504.3
EDP_TX0_DP_C: length 2
  BOTTOM w0.114: C4531.2 63.81,175.59 63.81,176.59 63.51,176.9 L4504.1
EDP_TX0_DP_R: length 6.6
  TOP w0.114: CON4500.12 64.75,181.87 64.89,182.01 64.89,182.71 v2(64.7,182.89)
  BOTTOM w0.114: 64.16,180.36 63.89,180.09 63.89,179.43 63.51,179.04 L4504.2 ; 64.16,180.36 64.8,181 64.8,182.8 v2(64.7,182.89) ; 64.16,180.36 v1(63.98,180.54)
EDP_TX1_DN_C: length 2
  BOTTOM w0.114: C4534.2 66.58,175.6 66.58,176.62 66.87,176.92 RN4503.1
EDP_TX1_DN_R: length 6.3
  TOP w0.114: CON4500.8 66.75,182.01 66.63,182.13 66.63,182.66 v2(66.86,182.89)
  BOTTOM w0.114: v2(66.86,182.89) 66.59,182.62 66.59,181.78 ; L4503.3 66.9,179.06 66.59,179.37 66.59,181.78 ; v1(66.83,181.78) 66.59,181.78
EDP_TX1_DP_C: length 2
  BOTTOM w0.114: C4535.2 66.35,175.71 66.35,176.65 66.05,176.95 L4503.1
EDP_TX1_DP_R: length 6.2
  TOP w0.114: v2(66.2,182.89) 66.4,182.7 66.4,182.1 66.25,181.95 CON4500.9
  BOTTOM w0.114: v2(66.2,182.89) 66.35,182.74 66.35,180.48 ; 66.35,180.48 66.35,179.38 66.05,179.07 L4503.2 ; 66.35,180.48 v1(66.12,180.48)
EDP_TX2_DN_C: length 2
  BOTTOM w0.114: L4502.4 69.44,176.9 69.14,176.6 69.14,175.58 C4519.2
EDP_TX2_DN_R: length 6.8
  TOP w0.114: CON4500.5 68.25,181.94 68.11,182.07 68.11,182.62 v2(68.38,182.89)
  BOTTOM w0.114: 68.76,180.46 68.76,180.92 68.5,181.18 68.5,181.84 67.99,182.35 67.99,182.5 v2(68.38,182.89) ; 68.76,180.46 v1(68.98,180.46) ; 68.76,180.46 68.76,179.95 69.14,179.57 69.14,179.28 69.41,179 RN4502.2
EDP_TX2_DP_C: length 2.1
  BOTTOM w0.114: L4502.1 68.59,176.92 68.9,176.6 68.9,175.73 C4520.2
EDP_TX2_DP_R: length 6.8
  TOP w0.114: CON4500.6 67.75,181.94 67.88,182.07 67.88,182.76 67.75,182.89 v2(67.65,182.89)
  BOTTOM w0.114: 68.26,181.34 68.26,181.75 67.76,182.25 67.76,182.83 67.69,182.89 v2(67.65,182.89) ; 68.26,181.34 68.26,181.09 68.53,180.82 68.53,179.85 68.9,179.47 68.9,179.3 68.59,178.99 L4502.2 ; 68.26,181.34 v1(68.04,181.34)
EDP_TX3_DN_C: length 3.7
  BOTTOM w0.114: 72.31,176.52 v1(72.49,176.34) ; 72.31,176.52 71.97,176.17 71.56,176.17 71.4,176.01 71.4,175.6 C4522.2 ; 72.31,176.52 72.7,176.9 72.7,177.21 72.97,177.48 RN4501.1
EDP_TX3_DN_R: length 7.8
  TOP w0.114: v2(70.14,183.13) 69.86,182.85 69.86,182.33 69.75,182.22 CON4500.2
  BOTTOM w0.114: v2(70.14,183.13) 69.86,182.85 69.86,182.41 71.45,180.81 71.93,180.81 ; L4501.3 72.99,179.5 72.66,179.84 72.66,180.35 72.19,180.81 71.93,180.81 ; 71.93,180.81 v1(71.93,181.07)
EDP_TX3_DP_C: length 3.7
  BOTTOM w0.114: RN4501.3 72.17,177.53 72.46,177.23 72.46,177 71.87,176.41 71.46,176.41 71.29,176.23 ; 71.29,176.23 v1(71.09,176.42) ; 71.29,176.23 71.17,176.11 71.17,175.7 C4521.2
EDP_TX3_DP_R: length 7.8
  TOP w0.114: v2(69.43,183.12) 69.63,182.92 69.63,182.43 69.51,182.32 69.51,182.14 69.25,181.88 CON4500.3
  BOTTOM w0.114: v1(70.03,181.58) 70.19,181.74 ; 70.19,181.74 69.62,182.31 69.62,182.95 69.45,183.12 v2(69.43,183.12) ; 70.19,181.74 71.36,180.58 72.09,180.58 72.42,180.25 72.42,179.91 72.14,179.63 L4501.2
EDP_TXN_0: length 44.9
  IN4 w0.089: v2(63.68,173.07) 63.91,173.07 64.03,172.94 64.03,172.73 63.75,172.44 59.16,172.44 57.27,170.55 57.27,165.1 56.65,164.47 55.13,164.47 54.9,164.24 54.9,163.08 55.13,162.85 57.77,162.85 59.93,160.69 59.93,157.49 61.49,155.93 61.49,154.36 57.07,149.95 57.07,147.21 58.27,146.02 59.13,146.02 59.29,145.86 v6(59.29,145.55)
  BOTTOM w0.114: U0300.E29 59.29,145.61 v6(59.29,145.55) ; C4533.1 64.14,174.16 64.14,173.53 v2(63.68,173.07)
EDP_TXN_1: length 45.3
  IN4 w0.089: v6(59.94,144.76) 60.09,144.61 60.32,144.61 60.37,144.67 60.37,145.07 60.62,145.32 60.62,145.7 58.85,147.46 58.85,148.1 59.18,148.43 60.3,148.43 60.49,148.24 60.49,148.17 60.72,147.94 61.67,147.94 61.9,148.17 61.9,151.83 63.38,153.31 63.38,155.37 60.7,158.05 60.7,161.34 58.07,163.97 58.07,170.24 59.44,171.62 64.13,171.62 64.88,172.37 66.16,172.37 66.53,172.74 66.53,173.04 v2(66.73,173.24)
  BOTTOM w0.114: v2(66.73,173.24) 66.56,173.4 66.56,174.17 C4534.1 ; v6(59.94,144.76) 59.94,145.03 59.82,145.15 U0300.E28
EDP_TXN_2: length 45
  IN4 w0.089: v2(66.04,145.68) 66.62,146.27 67.38,146.27 67.92,146.8 67.92,149.04 67.45,149.51 64.01,149.51 63.89,149.64 63.89,150.15 64.01,150.28 66.39,150.28 66.73,150.62 66.73,152.61 66.12,153.22 66.12,159.96 64.49,161.59 64.49,163.37 66.12,165 66.12,170.07 66.53,170.48 66.53,171.27 67.92,172.66 68.78,172.66 69.09,172.97 69.09,173.32 v2(69.27,173.5)
  BOTTOM w0.076: U0300.B29 61.76,145.74 61.76,145.64 61.95,145.46 62.86,145.46 63.04,145.64 63.98,145.64 64.35,145.26 65.27,145.26
  BOTTOM w0.114: 65.27,145.26 65.62,145.26 v2(66.04,145.68) ; C4519.1 69.09,174.15 69.09,173.68 v2(69.27,173.5)
EDP_TXN_3: length 43.1
  IN4 w0.089: v2(67.26,145.68) 67.49,145.45 67.49,145.06 67.69,144.87 68.2,144.87 68.57,145.25 68.57,152.14 66.92,153.8 66.92,169.9 67.45,170.43 67.45,171.33 68.14,172.03 70.06,172.03 71.25,173.22 71.25,173.29 71.5,173.55 v2(71.55,173.55)
  BOTTOM w0.076: U0300.B28 61.36,145.15 61.3,145.09 61.3,144.87 61.33,144.83 62.85,144.83 62.94,144.75 65.33,144.75
  BOTTOM w0.114: 66.17,144.75 v1(66.17,144.99) ; 66.17,144.75 65.33,144.75 ; 66.17,144.75 67.17,144.75 67.59,145.17 67.59,145.35 v2(67.26,145.68) ; C4522.1 71.41,174.19 71.41,173.69 v2(71.55,173.55)
EDP_TXP_0: length 45
  IN4 w0.089: v6(59.94,145.54) 59.51,145.98 59.42,145.98 59.21,146.19 58.34,146.19 57.25,147.28 57.25,149.88 61.66,154.29 61.66,156 60.11,157.56 60.11,160.76 57.85,163.03 55.21,163.03 55.08,163.15 55.08,164.17 55.21,164.29 56.72,164.29 57.45,165.02 57.45,170.47 59.24,172.26 63.82,172.26 64.21,172.65 64.21,173.01 64.08,173.14 64.08,173.3 v2(63.68,173.7)
  BOTTOM w0.114: v6(59.94,145.54) 59.94,145.62 U0300.D29 ; v2(63.68,173.7) 63.88,173.91 63.88,174.13 C4531.1
EDP_TXP_1: length 45.4
  IN4 w0.089: v2(66.09,173.24) 66.35,172.98 66.35,172.81 66.09,172.55 64.81,172.55 64.05,171.79 59.37,171.79 57.89,170.31 57.89,163.89 60.52,161.26 60.52,157.98 63.2,155.3 63.2,153.38 61.72,151.9 61.72,148.24 61.6,148.12 60.8,148.12 60.67,148.24 60.67,148.31 60.37,148.6 59.11,148.6 58.67,148.17 58.67,147.39 60.44,145.62 60.44,145.39 60.18,145.13 59.66,145.13 v6(59.29,144.76)
  BOTTOM w0.114: v6(59.29,144.76) 59.29,144.83 U0300.F28 ; v2(66.09,173.24) 66.33,173.48 66.33,174.1 C4535.1
EDP_TXP_2: length 44.9
  IN4 w0.089: v2(68.63,173.5) 68.91,173.22 68.91,173.04 68.71,172.84 67.85,172.84 66.35,171.35 66.35,170.55 65.94,170.14 65.94,165.07 64.31,163.44 64.31,161.52 65.94,159.89 65.94,153.15 66.55,152.53 66.55,150.69 66.32,150.45 63.94,150.45 63.71,150.22 63.71,149.57 63.94,149.34 67.37,149.34 67.74,148.97 67.74,146.88 67.31,146.45 66.55,146.45 66.23,146.13 65.52,146.13 65.43,146.04 65.43,145.69 v2(65.43,145.68)
  BOTTOM w0.076: U0300.A29 61.97,145.94 61.93,145.89 61.93,145.71 62.01,145.62 62.8,145.62 62.97,145.8 64.05,145.8 64.42,145.43 65.17,145.43 65.19,145.45 65.2,145.45 65.33,145.58
  BOTTOM w0.114: C4520.1 68.85,174.12 68.85,173.72 v2(68.63,173.5) ; 65.33,145.58 v2(65.43,145.68)
EDP_TXP_3: length 42.8
  IN4 w0.089: v2(70.92,173.55) 71.07,173.4 71.07,173.29 69.98,172.2 68.07,172.2 67.27,171.4 67.27,170.51 66.74,169.98 66.74,153.73 68.39,152.07 68.39,145.32 68.12,145.05 67.76,145.05 67.67,145.14 67.67,145.41 67.94,145.68 v7(67.95,145.68)
  BOTTOM w0.076: U0300.C28 61.03,145.15 61.13,145.05 61.13,144.81 61.27,144.67 62.79,144.67 62.87,144.58 65.23,144.58 65.25,144.56 65.27,144.56 65.32,144.51 65.33,144.51
  BOTTOM w0.114: v2(70.92,173.55) 71.17,173.8 71.17,174.08 C4521.1 ; v7(67.95,145.68) 67.83,145.57 67.83,145.07 67.27,144.51 65.33,144.51
ENABLE1: length 5.7
  TOP w0.102: U8100.20 219.97,75.69 220.46,76.18 220.97,76.18 v1(221.08,76.29) 221.32,76.54 222.16,76.54 222.71,75.99 R8111.1 223.39,75.61 224.08,75.61 SR8102.1
ENABLE2: length 4.1
  TOP w0.102: SR8103.2 214.08,75.96 v1(214.66,75.96) 214.86,75.76 216.36,75.76 216.76,75.36 U8100.6
ESPI_ALERT0#: length 85
  TOP w0.114: v2(190.04,58.85) 190.04,58.64 v1(189.64,58.23) 189.46,58.06 188.95,58.06 R2225.1 ; v2(125.12,49.41) 125.27,49.26 R3013.1
  IN2 w0.114: v2(125.5,46.32) 126.26,45.56 129.15,45.56 133.54,41.16 135.3,41.16 136.12,40.34 146.6,40.34 147.24,40.98 147.24,42.63 148.77,44.17 151.56,44.17 155.41,48.01 163.4,48.01 163.43,47.98 165.66,47.98 166.45,48.76 168.94,48.76 169.5,49.32 173.58,49.32 173.73,49.17 178.81,49.17 178.92,49.07 182.26,49.07 183.15,49.95 183.15,51.11 184.14,52.11 184.46,52.11 185.86,53.51 185.86,56.88 186.53,57.55 187.55,57.55 188.27,58.26 189.45,58.26 v2(190.04,58.85)
  BOTTOM w0.114: v2(125.5,46.32) 124.64,47.19 124.64,49.12 124.93,49.41 v2(125.12,49.41)
EXP_RXN0: length 22
  TOP w0.114: 79.93,129.05 79.93,129.38 80.82,130.27 83.74,133.19 86.21,135.65 88.02,137.47 94.17,137.47 94.33,137.63 94.33,137.87 v6(93.9,138.3) ; 79.93,129.05 v1(79.63,129.05) ; 79.93,129.05 79.93,128.67 79.59,128.32 79.14,128.32 C0631.1
  BOTTOM w0.114: U7000.BD21 94.3,138.2 94.2,138.3 v6(93.9,138.3)
EXP_RXN1: length 23.5
  TOP w0.089: v6(93.98,139) 93.63,138.65 92.99,138.65 92.77,138.87 91.51,138.87 90.77,138.13 90.3,138.13 90.3,138.13 90.27,138.13
  TOP w0.114: 76.58,129.25 v1(76.58,129) ; 76.58,129.25 76.72,129.25 77.01,129.55 79.39,129.55 80.82,130.98 83.03,133.19 85.5,135.65 87.98,138.13 90.27,138.13 ; 76.58,129.25 C0629.1
  BOTTOM w0.114: v6(93.98,139) 93.97,139.02 93.5,139.48 U7000.BE23
EXP_RXN2: length 21.4
  TOP w0.089: v1(90.12,139.49) 90.12,139.27 ; v6(95.5,139.1) 95.1,139.5 94.6,139.5 94.51,139.59 93.59,139.59 93.49,139.69 92.76,139.69 92.65,139.58 91.08,139.58 90.76,139.26 90.62,139.26 90.61,139.27
  TOP w0.114: 90.61,139.27 89.17,139.27 88.93,139.51 87.5,139.51 79.52,131.54 C0627.1
  BOTTOM w0.114: U7000.BC23 v6(95.5,139.1)
EXP_RXN3: length 23.1
  TOP w0.114: v6(93.9,139.96) 93.71,140.16 92.46,140.16 92.33,140.04 87.01,140.04 86.21,139.24 85.8,139.24 85.06,138.5 85.06,138.35 ; 85.06,138.35 85.06,137.89 79.53,132.35 75.97,132.35 C0625.1 ; 85.06,138.35 v1(85.29,138.35)
  BOTTOM w0.114: U7000.BD24 94.17,140.43 94.01,140.43 93.9,140.33 v6(93.9,139.96)
EXP_RXN4: length 20.2
  TOP w0.114: v6(93.1,141.5) 93.39,141.5 93.5,141.39 93.5,141.22 93.33,141.05 86.25,141.05 85.98,140.79 85.17,140.79 82.44,138.06 82.44,137.33 ; v1(82.22,137.33) 82.44,137.33 ; 82.44,137.33 82.44,136.84 79.58,133.98 78.97,133.98 78.89,134.06 78.89,134.23 C0623.1
  BOTTOM w0.114: U7000.BE25 v6(93.1,141.5)
EXP_RXN5: length 24.5
  TOP w0.089: 91.71,141.74 91.72,141.76 91.92,141.76 92.09,141.92 94.01,141.92 94.31,141.62 94.31,141.35 94.54,141.12 95.12,141.12 v6(95.5,141.5)
  TOP w0.114: v1(79.68,135.22) 79.51,135.39 ; 79.51,135.39 79.21,135.08 75.91,135.08 C0621.1 ; 79.51,135.39 80.92,136.8 80.92,137.36 85.01,141.44 85.52,141.44 85.82,141.74 91.71,141.74
  BOTTOM w0.114: U7000.BC26 v6(95.5,141.5)
EXP_RXN6: length 21.1
  TOP w0.089: v6(94.7,143.1) 95.03,143.1 95.1,143.03 95.1,142.79 94.93,142.62 91.32,142.62 91.32,142.63 91.25,142.63 91.24,142.64 91.22,142.64
  TOP w0.114: 87.05,142.9 v1(87.05,143.15) ; 87.05,142.9 84.97,142.9 79.41,137.34 79.41,136.85 79.26,136.7 79.15,136.7 C0619.1 ; 87.05,142.9 88.31,142.9 88.57,142.64 91.22,142.64
  BOTTOM w0.114: v6(94.7,143.1) 94.3,142.7 U7000.BD27
EXP_RXN7: length 22.3
  TOP w0.089: v1(88.85,143.43) 88.85,143.67
  TOP w0.114: C0617.1 75.89,137.73 79.14,137.73 85.09,143.67 89.59,143.67 90.07,143.19 93.4,143.19 93.73,143.52 93.73,143.68 v6(93.93,143.88)
  BOTTOM w0.114: v6(93.93,143.88) 93.51,144.3 U7000.BE29
EXP_RXN8: length 21
  TOP w0.114: v6(95.49,143.91) 95.33,144.07 95.33,144.19 94.98,144.54 91.16,144.54 91.01,144.7 83.41,144.7 81.65,142.94 81.65,142.41 ; 81.65,142.41 81.65,141.61 79.59,139.54 79.09,139.54 C0615.1 ; 81.65,142.41 v1(81.41,142.41)
  BOTTOM w0.114: v6(95.49,143.91) 95.49,143.91 U7000.BC29
EXP_RXN9: length 23.7
  TOP w0.089: v6(94.68,145.5) 95.03,145.5 95.1,145.43 95.1,145.2 94.94,145.05 92.04,145.05 91.97,145.11 91.97,145.13
  TOP w0.114: 76.63,140.86 77.11,140.86 77.42,141.17 79.8,141.17 80.56,141.92 80.56,142.86 83.08,145.38 91.72,145.38 91.97,145.13 ; 76.63,140.86 v1(76.63,141.11) ; 76.63,140.86 76,140.86 C0613.1
  BOTTOM w0.114: U7000.BD30 94.68,145.48 v6(94.68,145.5)
EXP_RXN10: length 18.7
  TOP w0.089: 91.76,145.97 92.53,145.97 92.62,145.88 93.54,145.88 v6(93.9,146.24)
  TOP w0.114: 87.5,146.26 88.61,146.26 88.9,145.97 91.76,145.97 ; 87.5,146.26 v1(87.5,146.02) ; 87.5,146.26 83.33,146.26 80.11,143.04 80.11,142.3 79.64,141.83 C0611.1
  BOTTOM w0.114: v6(93.9,146.24) 93.9,146.3 U7000.BE32
EXP_RXN11: length 22.7
  TOP w0.114: v1(82.04,146.83) 82.22,146.65 ; 82.22,146.65 82.73,147.16 88.65,147.16 88.75,147.26 90.5,147.26 90.82,146.94 94.89,146.94 95.14,146.69 95.14,146.48 v6(95.39,146.24) ; 82.22,146.65 79.33,143.76 76.01,143.76 C0605.1
  BOTTOM w0.114: v6(95.39,146.24) 95.39,146.42 U7000.BC32
EXP_RXN12: length 19
  TOP w0.089: v6(94.77,147.91) 94.17,147.31 91.54,147.31 91.45,147.4
  TOP w0.114: 86.33,147.92 90.56,147.92 91.01,147.46 91.39,147.46 91.45,147.4 ; 86.33,147.92 82.42,147.92 79.52,145.02 79.11,145.02 C0609.1 ; 86.33,147.92 v1(86.33,147.67)
  BOTTOM w0.114: v6(94.77,147.91) 94.77,147.65 94.63,147.5 U7000.BD33
EXP_RXN13: length 21.7
  TOP w0.089: v6(93.92,147.93) 93.73,148.12 93.73,148.28 93.43,148.59 91.34,148.59 91.33,148.6 91.26,148.6 91.25,148.61 91.24,148.61 ; v1(90.02,149.47) 90.02,149.22
  TOP w0.114: C0608.1 76.02,146.55 79.58,146.55 82.25,149.22 90.6,149.22 91.21,148.61 91.24,148.61
  BOTTOM w0.114: U7000.BE35 93.92,148.68 v6(93.92,147.93)
EXP_RXN14: length 20
  TOP w0.114: 83.44,149.97 90.55,149.97 91.67,148.86 94.98,148.86 95.3,149.17 95.3,149.3 v6(95.5,149.5) ; 83.44,149.97 82.2,149.97 79.87,147.65 78.44,147.65 C0602.1 ; 83.44,149.97 v1(83.44,149.73)
  BOTTOM w0.114: U7000.BC35 95.1,149.1 v6(95.5,149.5)
EXP_RXN15: length 21.6
  TOP w0.114: C0600.1 75.89,149.35 80.02,149.35 81.53,150.87 82.14,150.87 ; v6(93.9,150.3) 94.14,150.3 94.31,150.13 94.31,150.01 94.1,149.8 92.07,149.8 91,150.87 82.14,150.87 ; 82.14,150.87 v1(82.14,151.1)
  BOTTOM w0.114: v6(93.9,150.3) 94.19,150.3 94.3,150.19 U7000.BD36
EXP_RXP0: length 21.9
  TOP w0.114: v1(82.02,130.75) 81.83,130.94 ; 81.83,130.94 88.12,137.23 94.26,137.23 94.56,137.53 94.56,138.16 v6(94.7,138.3) ; 81.83,130.94 80.17,129.28 80.17,128.57 79.68,128.09 78.95,128.09 C0630.1
  BOTTOM w0.114: U7000.BC21 v6(94.7,138.3)
EXP_RXP1: length 23.4
  TOP w0.089: 90.35,138.37 90.38,138.34 90.68,138.34 91.42,139.08 v6(93.12,139.08)
  TOP w0.114: 80.11,130.6 87.88,138.37 90.35,138.37 ; 80.11,130.6 v1(79.93,130.78) ; 80.11,130.6 79.29,129.78 76.91,129.78 76.62,129.49 76.22,129.49 76.1,129.61 76.1,129.74 76.35,129.99 76.35,130.14 76.25,130.24 76.05,130.24 75.95,130.14 C0628.1
  BOTTOM w0.114: v6(93.12,139.08) 93.4,139.08 93.5,138.98 U7000.BE22
EXP_RXP2: length 21.4
  TOP w0.089: 90.61,139.03 90.62,139.03 90.64,139.05 90.71,139.05 90.85,139.05 91.17,139.37 92.74,139.37 92.85,139.48 93.4,139.48 93.51,139.38 94.42,139.38 v6(94.7,139.1) ; v1(88.16,139.03) 88.16,139.28
  TOP w0.114: C0626.1 79.2,130.65 79.3,130.75 79.3,130.88 79.17,131.01 79.17,131.15 79.32,131.3 79.62,131.3 87.6,139.28 88.83,139.28 89.07,139.03 90.61,139.03
  BOTTOM w0.114: v6(94.7,139.1) 94.7,139.44 94.64,139.5 U7000.BD23
EXP_RXP3: length 23.8
  TOP w0.114: 86.35,139.71 86.91,140.27 92.24,140.27 92.36,140.4 94.24,140.4 v6(94.74,139.9) ; 86.35,139.71 86.11,139.47 85.71,139.47 84.83,138.59 84.83,137.99 79.43,132.59 76.02,132.59 C0624.1 ; 86.35,139.71 v1(86.18,139.87)
  BOTTOM w0.114: v6(94.74,139.9) 94.74,139.94 U7000.BC24
EXP_RXP4: length 20.1
  TOP w0.114: 83.39,138.68 85.27,140.56 86.08,140.56 86.34,140.82 93.43,140.82 93.75,141.14 93.75,141.35 v6(93.9,141.5) ; 83.39,138.68 v1(83.57,138.5) ; 83.39,138.68 82.68,137.97 82.68,136.74 79.68,133.74 78.94,133.74 C0622.1
  BOTTOM w0.114: U7000.BE26 93.5,141.9 v6(93.9,141.5)
EXP_RXP5: length 24.6
  TOP w0.089: 91.71,141.98 91.85,141.98 92,142.13 94.1,142.13 94.3,141.93 95.03,141.93 95.12,141.84 95.12,141.55 95.07,141.5 v6(94.7,141.5)
  TOP w0.114: 80.69,137.15 80.69,136.89 79.11,135.31 76.08,135.31 C0620.1 ; 80.69,137.15 80.69,137.45 84.91,141.67 85.42,141.67 85.73,141.98 91.71,141.98 ; 80.69,137.15 v1(80.47,137.15)
  BOTTOM w0.114: v6(94.7,141.5) 94.7,141.87 94.67,141.9 U7000.BD26
EXP_RXP6: length 21.1
  TOP w0.089: 91.22,142.4 91.23,142.41 95.02,142.41 95.31,142.7 95.31,142.91 v6(95.5,143.1)
  TOP w0.114: C0618.1 78.94,136.46 79.36,136.46 79.65,136.75 79.65,137.24 85.07,142.67 85.34,142.67 ; 85.34,142.67 88.21,142.67 88.47,142.4 91.22,142.4 ; 85.34,142.67 v1(85.34,142.41)
  BOTTOM w0.114: U7000.BC27 95.1,142.7 v6(95.5,143.1)
EXP_RXP7: length 22.4
  TOP w0.089: v1(90.63,143.71) 90.63,143.42
  TOP w0.114: v6(93.11,143.89) 93.42,143.89 93.5,143.81 93.5,143.62 93.3,143.42 90.17,143.42 89.68,143.91 84.99,143.91 79.04,137.96 76.1,137.96 C0616.1
  BOTTOM w0.114: U7000.BE28 93.5,143.81 93.42,143.89 v6(93.11,143.89)
EXP_RXP8: length 21
  TOP w0.114: C0614.1 78.99,139.31 79,139.31 79.69,139.31 81.89,141.51 81.89,142.84 83.51,144.46 84.05,144.46 ; 84.05,144.46 90.91,144.46 91.07,144.31 94.89,144.31 95.1,144.09 95.1,143.98 95.01,143.89 v6(94.72,143.89) ; 84.05,144.46 v1(84.05,144.19)
  BOTTOM w0.114: U7000.BD29 94.72,143.88 v6(94.72,143.89)
EXP_RXP9: length 23.7
  TOP w0.089: 91.81,144.96 91.93,144.84 95.03,144.84 95.31,145.11 95.31,145.33 v6(95.49,145.51)
  TOP w0.114: C0612.1 75.99,140.63 77.21,140.63 77.51,140.93 79.6,140.93 ; 79.6,140.93 v1(79.6,140.68) ; 79.6,140.93 79.9,140.93 80.8,141.83 80.8,142.77 83.18,145.15 91.62,145.15 91.81,144.96
  BOTTOM w0.114: U7000.BC30 95.49,145.49 v6(95.49,145.51)
EXP_RXP10: length 18.7
  TOP w0.089: v6(93.1,146.27) 92.92,146.09 92.71,146.09 92.61,146.18 91.87,146.18 91.85,146.19 91.78,146.19 91.77,146.21 91.76,146.21 ; v1(89.87,146.45) 89.87,146.21
  TOP w0.114: 91.76,146.21 89,146.21 88.71,146.5 83.24,146.5 79.88,143.14 79.88,142.39 79.54,142.06 79.24,142.06 79.12,142.18 79.12,142.29 79.32,142.49 79.32,142.61 79.22,142.71 C0606.1
  BOTTOM w0.114: U7000.BE31 93.5,146.17 93.4,146.27 v6(93.1,146.27)
EXP_RXP11: length 22.7
  TOP w0.114: C0610.1 75.97,143.53 76.73,143.53 ; 76.73,143.53 79.43,143.53 82.83,146.93 88.74,146.93 88.85,147.03 90.4,147.03 90.73,146.7 94.8,146.7 94.91,146.59 94.91,146.45 v6(94.7,146.24) ; 76.73,143.53 v1(76.73,143.25)
  BOTTOM w0.114: U7000.BD32 94.42,146.82 94.6,146.82 94.7,146.73 v6(94.7,146.24)
EXP_RXP12: length 19.8
  TOP w0.089: 91.62,147.57 91.66,147.52 94.09,147.52 94.39,147.82 94.39,148.07 94.62,148.3 95.07,148.3 v6(95.49,147.89)
  TOP w0.114: 91.62,147.57 91.49,147.69 91.11,147.69 90.65,148.15 84.63,148.15 ; v1(84.63,148.4) 84.63,148.15 ; 84.63,148.15 82.32,148.15 79.42,145.25 78.97,145.25 C0604.1
  BOTTOM w0.114: U7000.BC33 v6(95.49,147.89)
EXP_RXP13: length 21
  TOP w0.089: 91.24,148.38 93.34,148.38 93.52,148.2 93.52,148.02 93.42,147.92 v6(93.12,147.92) ; v1(88.21,148.73) 88.21,148.98
  TOP w0.114: C0603.1 75.97,146.32 79.68,146.32 82.34,148.98 90.51,148.98 91.11,148.38 91.24,148.38
  BOTTOM w0.114: v6(93.12,147.92) 93.39,147.92 93.5,148.03 U7000.BE34
EXP_RXP14: length 19.9
  TOP w0.114: 79.17,147.88 79.78,147.88 82.1,150.21 90.65,150.21 91.76,149.09 94.89,149.09 95.05,149.25 95.05,149.4 94.94,149.5 v6(94.7,149.5) ; 79.17,147.88 78.53,147.88 78.45,147.96 78.45,148.06 C0601.1 ; 79.17,147.88 v1(79.17,148.15)
  BOTTOM w0.114: U7000.BD35 94.3,149.1 v6(94.7,149.5)
EXP_RXP15: length 21.6
  TOP w0.114: C0607.1 75.84,149.12 76.43,149.12 ; v6(94.71,150.29) 94.55,150.12 94.55,149.91 94.2,149.57 91.97,149.57 90.9,150.63 81.63,150.63 80.11,149.12 76.43,149.12 ; 76.43,149.12 v1(76.43,148.86)
  BOTTOM w0.114: U7000.BC36 v6(94.71,150.29)
EXP_TXN0: length 15.7
  BOTTOM w0.076: U0300.B10 61.87,130.67 62.64,130.67 62.84,130.47 63.15,130.47
  BOTTOM w0.114: C7014.2 75.06,127.14 71.62,127.14 71.25,127.51 ; 63.15,130.47 65.33,130.47 65.82,129.98 68.78,129.98 71.25,127.51 ; 71.25,127.51 v1(71.41,127.67)
EXP_TXN0_C: length 21.1
  BOTTOM w0.089: U7000.BG21 91.58,137.9 91.21,138.27 90.82,138.27 90.59,138.5
  BOTTOM w0.114: C7014.1 76.45,127.12 77.45,127.12 78.11,127.78 78.26,127.92 80.82,130.49 83.52,133.19 85.99,135.65 86.63,136.3 87.02,136.3 ; 87.02,136.3 v1(87.02,136.57) ; 87.02,136.3 87.51,136.3 89.71,138.5 90.59,138.5
EXP_TXN1: length 13.1
  BOTTOM w0.114: 69.26,130.6 69.78,130.09 69.78,129.7 70.92,128.56 71.88,128.56 71.99,128.44 71.99,128.3 C7005.2 ; 69.26,130.6 69.05,130.82 68.55,130.82 68.37,130.63 65.79,130.63 65.44,130.98 63.71,130.98 63.27,131.42 61.91,131.42 U0300.B11 ; 69.26,130.6 v1(69.1,130.44)
EXP_TXN1_C: length 22.9
  BOTTOM w0.089: 90.76,139.07 90.77,139.08
  BOTTOM w0.114: 90.77,139.08 91.1,139.41 ; 78.87,129.76 v1(79.05,129.58) ; 78.87,129.76 86.3,137.2 87.88,137.2 89.55,138.87 90.56,138.87 90.76,139.07 ; 78.87,129.76 77.34,128.23 73.94,128.23 73.61,127.9 C7005.1
EXP_TXN2: length 16.2
  BOTTOM w0.076: 64,131.93 63.75,132.19 62.69,132.19 62.63,132.25 61.24,132.25 61.2,132.29 61.2,132.41 61.34,132.55 U0300.B12
  BOTTOM w0.114: 66.75,131.57 66.18,131.57 65.82,131.93 64,131.93 ; 66.75,131.57 v1(66.75,131.8) ; 66.75,131.57 67.99,131.57 68.13,131.72 69.45,131.72 71.56,129.6 74.98,129.6 C7010.2
EXP_TXN2_C: length 18.9
  BOTTOM w0.114: C7010.1 76.5,129.61 76.99,129.61 84.14,136.76 ; U7000.BJ24 89.97,139.97 89.28,139.97 88.11,138.8 86.18,138.8 84.14,136.76 ; v1(83.97,136.92) 84.14,136.76
EXP_TXN3: length 12.3
  BOTTOM w0.076: U0300.B13 61.93,132.97 63.69,132.97 63.87,132.79 63.87,132.77 64.03,132.61 64.16,132.61
  BOTTOM w0.114: v1(68.54,132.38) 68.54,132.61 ; 68.54,132.61 64.16,132.61 ; 68.54,132.61 69.19,132.61 71.35,130.44 C7021.2
EXP_TXN3_C: length 23.9
  BOTTOM w0.076: 90.77,140.35 90.77,140.04 90.82,139.99 91.59,139.99 91.9,140.3 U7000.BG24
  BOTTOM w0.089: 90.77,140.35 90.45,140.68 89.46,140.68 88.72,139.95 88.58,139.95 88.48,139.85
  BOTTOM w0.114: C7021.1 73.46,130.65 74.3,130.65 74.38,130.73 77.29,130.73 78.33,131.77 78.33,132.07 81.1,134.84 ; 81.1,134.84 85.77,139.51 88.15,139.51 88.48,139.85 ; 81.1,134.84 v1(81.28,134.66)
EXP_TXN4: length 16.1
  BOTTOM w0.076: 64.35,133.59 64.33,133.59 64.21,133.71 62.68,133.71 62.58,133.81 61.33,133.81 61.24,133.9 61.24,134.08 61.29,134.13 U0300.B14
  BOTTOM w0.114: 64.35,133.59 70.21,133.59 71.45,132.36 73.89,132.36 74.19,132.05 ; v1(74.36,132.22) 74.19,132.05 ; 74.19,132.05 74.42,131.82 74.82,131.82 75.03,132.04 75.03,132.2 C7023.2
EXP_TXN4_C: length 20.6
  BOTTOM w0.089: 88.41,141.02 88.69,141.3 90.56,141.3 90.88,141.62 90.88,141.68 U7000.BH26
  BOTTOM w0.114: 84.12,139.72 84.12,140.02 85.06,140.96 88.35,140.96 88.41,141.02 ; 84.12,139.72 v1(83.82,139.72) ; 84.12,139.72 84.12,139.36 77.18,132.42 77.18,132.09 76.91,131.82 76.73,131.82 76.66,131.9 76.66,132.4 76.58,132.48 C7023.1
EXP_TXN5: length 11.8
  BOTTOM w0.076: U0300.B15 61.7,134.92 62.08,134.54 63.21,134.54 63.42,134.32 63.5,134.32 63.52,134.31 63.53,134.31
  BOTTOM w0.114: 67.39,134.31 68.15,134.31 68.41,134.05 70.39,134.05 71.45,132.98 C7025.2 ; 67.39,134.31 v1(67.39,134.09) ; 67.39,134.31 63.53,134.31
EXP_TXN5_C: length 22.9
  BOTTOM w0.114: C7025.1 74.75,132.98 75.08,133.31 77.32,133.31 81.1,137.1 81.1,137.99 81.97,138.85 ; v1(82.14,138.68) 81.97,138.85 ; 81.97,138.85 84.63,141.52 90.42,141.52 90.66,141.75 90.66,141.75 90.7,141.8 90.7,142.3 U7000.BJ27
EXP_TXN6: length 15.3
  BOTTOM w0.076: 63.12,135.2 62.79,135.2 62.61,135.39 61.29,135.39 61.23,135.44 61.23,135.64 61.29,135.7 U0300.B16
  BOTTOM w0.114: v1(74.42,134.9) 74.42,134.67 ; 74.42,134.67 74.97,134.67 C7030.2 ; 74.42,134.67 71.98,134.67 71.45,135.2 63.12,135.2
EXP_TXN6_C: length 20
  BOTTOM w0.114: 77.48,135.49 v1(77.29,135.68) ; 77.48,135.49 77.01,135.02 C7030.1 ; 77.48,135.49 78.23,136.24 78.23,136.65 84.23,142.65 88.96,142.65 89.69,143.38 90.71,143.38 90.95,143.14 91.46,143.14 U7000.BG27
EXP_TXN7: length 11.8
  BOTTOM w0.076: 63.82,135.74 63.82,135.74 63.37,135.74 62.99,136.11 62.13,136.11 61.75,136.49 U0300.B17
  BOTTOM w0.114: 67.79,136.18 68.18,136.18 68.63,135.73 71.86,135.73 72.07,135.52 C7032.2 ; 67.79,136.18 67.3,136.18 66.86,135.74 63.82,135.74 ; 67.79,136.18 v1(67.79,135.96)
EXP_TXN7_C: length 23.1
  BOTTOM w0.114: 81.99,141.47 81.99,141.72 83.55,143.28 88.96,143.28 89.35,143.68 90.58,143.68 90.81,143.91 91.01,143.91 91.1,144 U7000.BH29 ; 81.99,141.47 v1(82.25,141.47) ; 81.99,141.47 81.99,141.19 76.69,135.88 73.82,135.88 73.72,135.78 73.72,135.61 73.91,135.42 73.91,135.29 73.75,135.14 73.64,135.14 C7032.1
EXP_TXN8: length 15.6
  BOTTOM w0.076: U0300.C18 61.22,137.58 61.69,137.58 61.88,137.39 61.88,137.17 62.09,136.96 62.55,136.96 62.75,136.76 63.26,136.76 63.33,136.83
  BOTTOM w0.114: 64.62,136.83 63.33,136.83 ; 64.62,136.83 v1(64.62,137.05) ; 64.62,136.83 66.6,136.83 67.01,137.24 74.97,137.24 75.11,137.38 C7034.2
EXP_TXN8_C: length 18.1
  BOTTOM w0.114: 85.65,144.67 88.45,144.67 88.65,144.88 90.08,144.88 U7000.BJ30 ; 85.65,144.67 v1(85.65,144.95) ; 85.65,144.67 83.52,144.67 81.02,142.18 81.02,141.59 76.68,137.26 76.5,137.26 C7034.1
EXP_TXN9: length 10.8
  BOTTOM w0.114: 71.51,138.21 71.81,138.5 72.07,138.5 C7036.2 ; 71.51,138.21 v1(71.35,138.37) ; 71.51,138.21 71.31,138 62.63,138 62.57,138.07 U0300.A19
EXP_TXN9_C: length 23
  BOTTOM w0.114: C7036.1 73.5,138.58 77.04,138.58 77.69,139.23 77.69,139.66 80.16,142.13 80.16,142.56 ; 80.16,142.56 80.16,142.89 83.03,145.77 90.65,145.77 90.91,145.51 91.5,145.51 U7000.BG30 ; 80.16,142.56 v1(79.88,142.56)
EXP_TXN10: length 15.5
  BOTTOM w0.076: 63.51,138.5 63.35,138.5 63.23,138.37 61.23,138.37 61.05,138.55 61.05,138.72 U0300.C20
  BOTTOM w0.114: 74.32,139.52 71.46,139.52 70.43,138.5 63.51,138.5 ; 74.32,139.52 v1(74.32,139.3) ; 74.32,139.52 74.99,139.52 C7038.2
EXP_TXN10_C: length 20.4
  BOTTOM w0.089: U7000.BH32 91.46,146.7 91.57,146.59 91.57,146.42 91.44,146.3 91.03,146.3 90.93,146.4 90.73,146.4 90.44,146.11 89.87,146.11
  BOTTOM w0.114: 89.87,146.11 89.74,146.11 89.67,146.19 82.52,146.19 ; 82.52,146.19 v1(82.52,145.94) ; 82.52,146.19 81.76,146.19 80.87,145.3 80.87,144.31 79.02,142.46 79.02,141.8 76.69,139.47 76.46,139.47 76.19,139.21 C7038.1
EXP_TXN11: length 12.1
  BOTTOM w0.076: U0300.A21 62,139.64 61.91,139.55 61.91,139.39 61.96,139.34 62.48,139.34 62.68,139.53 63.55,139.53 63.56,139.52
  BOTTOM w0.114: C7040.2 72.01,141.11 71.49,141.11 70.09,139.72 66.78,139.72 66.57,139.52 65.79,139.52 ; 65.79,139.52 v1(65.79,139.74) ; 65.79,139.52 63.56,139.52
EXP_TXN11_C: length 20.9
  BOTTOM w0.114: C7040.1 73.56,141.19 76.87,141.19 77.62,141.94 77.62,142.56 79.5,144.44 79.5,145.3 81.39,147.19 81.71,147.19 ; 81.71,147.19 v1(81.71,147.46) ; 81.71,147.19 90,147.19 U7000.BJ33
EXP_TXN12: length 16.5
  BOTTOM w0.076: 63.63,140.32 63.43,140.12 62.09,140.12 61.9,140.3 61.9,140.56 61.71,140.75 61.23,140.75 U0300.C22
  BOTTOM w0.114: 70.7,141.28 71.88,142.47 74.94,142.47 C7042.2 ; 70.7,141.28 v1(70.51,141.47) ; 70.7,141.28 69.82,140.4 66.83,140.4 66.65,140.58 63.9,140.58 63.63,140.32
EXP_TXN12_C: length 19.5
  BOTTOM w0.114: 78.78,145.53 78.78,145.86 81.38,148.46 84.35,148.46 84.89,147.92 89.42,147.92 89.63,148.13 90.52,148.13 90.76,147.89 91.51,147.89 U7000.BG33 ; 78.78,145.53 78.78,144.84 76.78,142.84 C7042.1 ; 78.78,145.53 v1(78.51,145.53)
EXP_TXN13: length 12.5
  BOTTOM w0.076: 63.53,141.19 63.51,141.16 62.76,141.16 62.51,140.91 62.01,140.91 61.92,141 61.92,141.16 61.98,141.22 U0300.A23
  BOTTOM w0.114: C7044.2 72.03,143.67 71.87,143.67 71.41,143.21 ; 71.41,143.21 70.71,142.51 67,142.51 65.82,141.32 63.67,141.32 63.53,141.19 ; 71.41,143.21 v1(71.25,143.38)
EXP_TXN13_C: length 22.7
  BOTTOM w0.114: C7044.1 73.5,143.79 76.51,143.79 77.67,144.95 77.67,145.96 81.28,149.57 84.25,149.57 ; 84.25,149.57 v1(84.25,149.8) ; 84.25,149.57 84.43,149.57 85.37,148.63 90.41,148.63 90.66,148.88 90.66,149.3 90.88,149.52 91.14,149.52 91.24,149.42 91.24,149.24 U7000.BH35
EXP_TXN14: length 16.8
  BOTTOM w0.076: U0300.C24 61.22,142.31 61.69,142.31 61.9,142.1 61.9,141.89 62.1,141.69 62.6,141.69 62.76,141.53 63.02,141.53 63.41,141.93 63.9,141.93 63.96,141.98
  BOTTOM w0.114: C7050.2 74.95,145.06 71.92,145.06 70.03,143.18 69.47,143.18 ; 63.96,141.98 65.53,141.98 66.73,143.18 69.47,143.18 ; v1(69.47,143.4) 69.47,143.18
EXP_TXN14_C: length 18.3
  BOTTOM w0.114: 77.01,146.68 77.01,145.35 76.8,145.15 76.45,145.15 C7050.1 ; 77.01,146.68 77.01,147 80.59,150.59 84.86,150.59 85.85,149.6 90,149.6 U7000.BJ36 ; 77.01,146.68 v1(76.71,146.68)
EXP_TXN15: length 13.7
  BOTTOM w0.076: 64.01,142.72 63.42,142.72 63.26,142.56 62.6,142.56 62.52,142.47 62.08,142.47 61.87,142.68 61.87,142.73 61.93,142.79 U0300.A25
  BOTTOM w0.114: v1(67.82,144.08) 67.82,143.83 ; 67.82,143.83 66.45,143.83 65.33,142.72 64.01,142.72 ; 67.82,143.83 68.61,143.83 68.86,144.09 69.79,144.09 72.16,146.46 72.78,146.46 C7052.2
EXP_TXN15_C: length 21.1
  BOTTOM w0.089: U7000.BG36 91.57,150.23 91.23,150.23 91.1,150.36 90.92,150.36 90.71,150.57 87.99,150.57 87.96,150.6 87.94,150.6
  BOTTOM w0.114: C7052.1 74.45,146.7 75.66,147.91 75.66,148.23 ; 75.66,148.23 75.66,148.53 78.41,151.28 85.14,151.28 85.82,150.6 87.94,150.6 ; 75.66,148.23 v1(75.41,148.23)
EXP_TXP0: length 16.5
  BOTTOM w0.076: 63.15,130.23 62.84,130.23 62.57,130.51 61.39,130.51 U0300.C10
  BOTTOM w0.114: 73.05,126.91 74.91,126.91 C7004.2 ; 73.05,126.91 71.52,126.91 68.68,129.75 65.72,129.75 65.24,130.23 63.15,130.23 ; 73.05,126.91 v1(73.05,126.68)
EXP_TXP0_C: length 20.2
  BOTTOM w0.089: U7000.BH21 90.91,138.09 90.66,138.09 90.49,138.26
  BOTTOM w0.114: 90.49,138.26 89.81,138.26 87.61,136.06 86.73,136.06 77.55,126.88 77.14,126.88 ; 77.14,126.88 76.55,126.88 C7004.1 ; 77.14,126.88 v1(77.14,126.61)
EXP_TXP1: length 12
  BOTTOM w0.114: 70.49,129.32 70.01,129.79 70.01,130.18 69.14,131.05 68.45,131.05 68.27,130.87 65.89,130.87 65.54,131.22 63.81,131.22 63.33,131.69 62.29,131.69 U0300.A11 ; 70.49,129.32 v1(70.65,129.47) ; 70.49,129.32 71.01,128.79 C7015.2
EXP_TXP1_C: length 24
  BOTTOM w0.076: U7000.BG23 91.9,139.5 91.59,139.82 90.96,139.82 90.7,139.57 90.7,139.35
  BOTTOM w0.089: 90.59,139.24 90.59,139.24
  BOTTOM w0.114: 77.09,128.47 73.94,128.47 73.61,128.79 C7015.1 ; 77.09,128.47 77.24,128.47 77.27,128.49 78.26,129.48 79.81,131.03 81.96,133.19 84.43,135.65 86.21,137.43 87.78,137.43 89.46,139.11 90.46,139.11 90.59,139.24 ; 77.09,128.47 v1(77.09,128.72) ; 90.7,139.35 90.59,139.24
EXP_TXP2: length 16.3
  BOTTOM w0.076: U0300.C12 61.04,132.43 61.04,132.22 61.17,132.08 62.56,132.08 62.62,132.02 63.64,132.02 63.97,131.7 64.05,131.7
  BOTTOM w0.114: 64.05,131.7 65.72,131.7 66.08,131.34 68.08,131.34 68.23,131.48 69.35,131.48 71.47,129.37 74.35,129.37 ; 74.35,129.37 74.99,129.37 C7009.2 ; 74.35,129.37 v1(74.35,129.15)
EXP_TXP2_C: length 18.9
  BOTTOM w0.114: 86.56,138.57 86.28,138.57 82.12,134.41 80.82,133.11 80.1,132.39 78.74,131.03 77.09,129.38 76.5,129.38 76.45,129.32 C7009.1 ; 86.56,138.57 88.21,138.57 89.38,139.73 90.07,139.73 U7000.BJ23 ; 86.56,138.57 v1(86.56,138.32)
EXP_TXP3: length 12.2
  BOTTOM w0.076: 64.06,132.84 63.76,133.14 62.42,133.14 U0300.A13
  BOTTOM w0.114: 71.09,131.03 71.45,130.68 71.84,130.68 71.96,130.8 71.96,130.95 71.83,131.09 71.83,131.25 71.91,131.33 C7020.2 ; 71.09,131.03 v1(71.26,131.2) ; 71.09,131.03 69.29,132.84 64.06,132.84
EXP_TXP3_C: length 23.9
  BOTTOM w0.089: 88.32,140.01 88.43,140.12 88.65,140.12 89.38,140.86 90.52,140.86 90.72,140.66 91.49,140.66 91.57,140.58 91.57,140.4 91.46,140.3 U7000.BH24
  BOTTOM w0.114: 87.2,139.74 v1(87.2,139.97) ; 87.2,139.74 85.67,139.74 83.82,137.89 82.73,136.8 79.21,133.28 78.1,132.17 78.1,131.87 77.19,130.96 74.28,130.96 74.2,130.88 73.6,130.88 73.52,130.96 73.52,131.07 C7020.1 ; 87.2,139.74 88.05,139.74 88.32,140.01
EXP_TXP4: length 15.8
  BOTTOM w0.076: U0300.C14 61.07,133.97 61.07,133.83 61.26,133.65 62.51,133.65 62.62,133.54 64.14,133.54 64.28,133.4 64.29,133.4 64.34,133.35 64.35,133.35
  BOTTOM w0.114: C7022.2 74.32,131.59 73.79,132.12 71.35,132.12 70.51,132.96 ; v1(70.35,132.8) 70.51,132.96 ; 70.51,132.96 70.12,133.35 64.35,133.35
EXP_TXP4_C: length 20.9
  BOTTOM w0.089: 88.58,140.86 88.6,140.87 88.56,140.9 88.6,140.95 88.6,140.96 88.76,141.12 90.63,141.12 91.03,141.52 91.52,141.52 U7000.BG26
  BOTTOM w0.114: 88.58,140.86 88.45,140.73 85.5,140.73 ; 85.5,140.73 v1(85.5,140.45) ; 85.5,140.73 85.16,140.73 84.35,139.92 84.35,139.26 82.12,137.02 78.26,133.16 77.42,132.32 77.42,132 77.01,131.59 C7022.1
EXP_TXP5: length 11.9
  BOTTOM w0.076: U0300.A15 62.43,134.7 63.28,134.7 63.44,134.54 63.53,134.54
  BOTTOM w0.114: 69.49,134.28 70.49,134.28 71.55,133.22 71.84,133.22 71.95,133.33 71.95,133.46 71.78,133.62 71.78,133.8 71.85,133.87 C7024.2 ; 69.49,134.28 v1(69.49,134.5) ; 69.49,134.28 68.51,134.28 68.25,134.54 63.53,134.54
EXP_TXP5_C: length 23
  BOTTOM w0.114: 80.87,137.66 80.87,138.09 84.53,141.75 89.65,141.75 89.73,141.83 89.73,142.29 89.77,142.33 90.19,142.33 90.3,142.23 U7000.BJ26 ; 80.87,137.66 v1(80.62,137.66) ; 80.87,137.66 80.87,137.2 77.22,133.55 74.98,133.55 74.65,133.22 73.73,133.22 73.51,133.44 73.2,133.44 73.08,133.57 73.08,133.75 73.2,133.87 C7024.1
EXP_TXP6: length 15.4
  BOTTOM w0.076: 63.12,134.97 62.79,134.97 62.54,135.22 61.22,135.22 61.06,135.37 61.06,135.55 U0300.C16
  BOTTOM w0.114: 71.63,134.69 71.35,134.97 63.12,134.97 ; 71.63,134.69 v1(71.45,134.51) ; 71.63,134.69 71.88,134.44 75,134.44 75.03,134.4 75.04,134.4 C7029.2
EXP_TXP6_C: length 20
  BOTTOM w0.114: U7000.BH27 90.92,142.52 90.8,142.52 90.69,142.63 90.69,143.06 90.61,143.14 89.79,143.14 89.06,142.41 84.33,142.41 78.91,136.99 ; C7029.1 76.56,134.13 76.66,134.22 76.66,134.62 76.82,134.78 77.11,134.78 77.41,135.08 77.98,135.65 78.47,136.14 78.47,136.55 78.91,136.99 ; 78.91,136.99 v1(79.1,136.8)
EXP_TXP7: length 11.8
  BOTTOM w0.076: 63.82,135.98 63.8,135.95 63.39,135.95 63.06,136.28 62.43,136.28 U0300.A17
  BOTTOM w0.114: 63.82,135.98 66.77,135.98 67.2,136.41 68.28,136.41 68.73,135.96 70.66,135.96 ; 70.66,135.96 71.74,135.96 71.86,136.08 71.86,136.19 71.7,136.35 71.7,136.47 71.8,136.58 71.93,136.58 72.09,136.41 C7031.2 ; 70.66,135.96 v1(70.66,136.21)
EXP_TXP7_C: length 23.2
  BOTTOM w0.114: v1(87.02,143.78) 87.02,143.52 ; 87.02,143.52 83.45,143.52 81.76,141.82 81.76,141.29 76.59,136.12 73.55,136.12 C7031.1 ; 87.02,143.52 88.86,143.52 89.25,143.91 90.45,143.91 90.68,144.14 90.68,144.44 90.91,144.67 91.53,144.67 U7000.BG29
EXP_TXP8: length 15.4
  BOTTOM w0.076: U0300.B18 61.27,137.28 61.22,137.23 61.22,137 61.32,136.9 61.52,136.9 61.57,136.95 61.87,136.95 62.02,136.8 62.48,136.8 62.68,136.6 63.35,136.6 63.36,136.59
  BOTTOM w0.114: 74.32,137.01 67.11,137.01 66.7,136.59 63.36,136.59 ; 74.32,137.01 74.97,137.01 C7033.2 ; 74.32,137.01 v1(74.32,136.78)
EXP_TXP8_C: length 18.1
  BOTTOM w0.114: C7033.1 76.53,137.02 76.78,137.02 81.25,141.5 81.25,142.08 83.61,144.44 84,144.44 ; 84,144.44 v1(84,144.21) ; 84,144.44 88.54,144.44 88.75,144.64 89.96,144.64 U7000.BJ29
EXP_TXP9: length 11.6
  BOTTOM w0.114: 66.42,137.77 71.4,137.77 71.91,138.27 72.06,138.27 C7035.2 ; 66.42,137.77 v1(66.42,137.54) ; 66.42,137.77 62.67,137.77 62.61,137.71 62.05,137.71 61.69,138.07 U0300.B19
EXP_TXP9_C: length 22.1
  BOTTOM w0.114: U7000.BH30 90.95,145.1 90.52,145.53 83.13,145.53 81.67,144.07 ; C7035.1 73.66,138.34 77.13,138.34 77.92,139.14 77.92,139.56 80.39,142.03 80.39,142.79 81.67,144.07 ; 81.67,144.07 v1(81.86,143.88)
EXP_TXP10: length 15.5
  BOTTOM w0.076: U0300.B20 61.31,138.85 61.21,138.75 61.21,138.62 61.3,138.54 63.16,138.54 63.29,138.66 63.41,138.66 63.43,138.68 63.48,138.68 63.5,138.7 63.51,138.7
  BOTTOM w0.114: 63.51,138.7 63.54,138.73 69.65,138.73 ; v1(69.65,138.96) 69.65,138.73 ; 69.65,138.73 70.34,138.73 71.36,139.76 74.97,139.76 C7037.2
EXP_TXP10_C: length 20.5
  BOTTOM w0.089: 89.87,146.35 89.88,146.35 89.92,146.3 89.94,146.3 89.96,146.29 90.37,146.29 90.65,146.58 90.66,146.58 90.66,146.58 90.68,146.6 90.68,146.75 90.98,147.06 91.55,147.06 U7000.BG32
  BOTTOM w0.114: 80.64,144.92 80.64,144.41 78.78,142.56 78.78,141.9 76.59,139.71 76.56,139.71 C7037.1 ; 80.64,144.92 80.64,145.4 81.66,146.42 89.76,146.42 89.84,146.35 89.87,146.35 ; 80.64,144.92 v1(80.39,144.92)
EXP_TXP11: length 12.2
  BOTTOM w0.076: U0300.B21 61.75,139.46 61.75,139.32 61.89,139.17 62.55,139.17 62.74,139.36 63.37,139.36 63.46,139.27 63.54,139.27 63.56,139.28
  BOTTOM w0.114: 67.74,139.48 66.87,139.48 66.67,139.28 63.56,139.28 ; 67.74,139.48 70.19,139.48 71.59,140.88 72.1,140.88 72.12,140.86 72.14,140.86 C7039.2 ; 67.74,139.48 v1(67.74,139.26)
EXP_TXP11_C: length 20.9
  BOTTOM w0.114: 77.85,142.16 77.85,142.46 79.73,144.34 79.73,145.2 81.49,146.96 90.04,146.96 U7000.BJ32 ; 77.85,142.16 77.85,141.84 76.97,140.96 73.61,140.96 C7039.1 ; 77.85,142.16 v1(78.13,142.16)
EXP_TXP12: length 16.4
  BOTTOM w0.076: 63.72,140.08 63.59,139.95 62.02,139.95 61.84,140.12 61.6,140.12 61.47,140 61.29,140 61.19,140.1 61.19,140.28 61.34,140.43 U0300.B22
  BOTTOM w0.114: 63.72,140.08 63.79,140.15 63.8,140.15 63.99,140.35 66.55,140.35 66.73,140.17 69.92,140.17 71.98,142.23 74.35,142.23 ; C7041.2 75.03,142.23 74.35,142.23 ; v1(74.35,141.98) 74.35,142.23
EXP_TXP12_C: length 19.5
  BOTTOM w0.114: 83.97,148.22 81.48,148.22 79.02,145.76 79.02,144.75 76.88,142.61 76.78,142.61 76.63,142.46 76.63,142.33 76.84,142.13 76.84,141.98 76.71,141.85 76.58,141.85 76.48,141.95 C7041.1 ; 83.97,148.22 v1(83.97,147.97) ; 83.97,148.22 84.26,148.22 84.79,147.69 89.51,147.69 89.72,147.9 90.42,147.9 90.68,147.64 90.96,147.64 U7000.BH33
EXP_TXP13: length 12.5
  BOTTOM w0.076: 63.7,141.02 63.67,141 62.83,141 62.58,140.75 61.94,140.75 61.76,140.93 61.76,141.02 U0300.B23
  BOTTOM w0.114: 66.79,141.96 65.91,141.09 63.77,141.09 63.7,141.02 ; 66.79,141.96 v1(66.95,141.8) ; 66.79,141.96 67.1,142.27 70.81,142.27 71.97,143.44 72.1,143.44 C7043.2
EXP_TXP13_C: length 22.7
  BOTTOM w0.114: C7043.1 73.66,143.55 76.61,143.55 77.9,144.85 77.9,145.86 81.38,149.34 82.55,149.34 ; 82.55,149.34 84.33,149.34 85.27,148.4 90.51,148.4 90.85,148.73 91.53,148.73 U7000.BG35 ; 82.55,149.34 v1(82.55,149.09)
EXP_TXP14: length 16.7
  BOTTOM w0.076: 63.96,141.75 63.47,141.75 63.09,141.37 62.69,141.37 62.53,141.52 62.03,141.52 61.83,141.72 61.75,141.72 61.62,141.6 61.29,141.6 61.21,141.67 61.21,141.93 61.29,142 U0300.B24
  BOTTOM w0.114: 74.32,144.83 75.02,144.83 C7049.2 ; 74.32,144.83 v1(74.32,144.61) ; 74.32,144.83 72.02,144.83 70.13,142.94 66.83,142.94 65.63,141.75 63.96,141.75
EXP_TXP14_C: length 18.3
  BOTTOM w0.114: 80.95,150.35 84.76,150.35 85.75,149.37 90.04,149.37 U7000.BJ35 ; 80.95,150.35 v1(80.95,150.11) ; 80.95,150.35 80.69,150.35 77.24,146.91 77.24,145.26 76.9,144.92 76.55,144.92 C7049.1
EXP_TXP15: length 13.7
  BOTTOM w0.076: 64.01,142.49 63.44,142.49 63.35,142.39 62.67,142.39 62.59,142.31 62.01,142.31 61.7,142.61 61.7,142.65 U0300.B25
  BOTTOM w0.114: v1(72.05,145.69) 71.89,145.85 ; 71.89,145.85 69.89,143.85 68.96,143.85 68.71,143.6 66.54,143.6 65.43,142.49 64.01,142.49 ; 71.89,145.85 72.26,146.22 72.62,146.22 C7051.2
EXP_TXP15_C: length 21.1
  BOTTOM w0.089: 87.94,150.37 87.96,150.37 87.99,150.4 90.63,150.4 90.84,150.19 91.03,150.19 91.1,150.11 U7000.BH36
  BOTTOM w0.114: 77.13,149.66 75.9,148.43 75.9,147.81 74.45,146.36 74.45,146.21 74.61,146.05 74.61,145.89 74.52,145.81 C7051.1 ; 77.13,149.66 v1(77.32,149.47) ; 77.13,149.66 78.51,151.05 85.04,151.05 85.72,150.37 87.94,150.37
EXT_SCI#: length 73.1
  TOP w0.102: R3082.1 115.92,48.58 115.99,48.5 115.99,47.59 116.49,47.1 116.49,46.62 v2(116.71,46.4)
  IN1 w0.102: v2(153.66,35.04) 153.45,34.83 146.65,34.83 145.96,35.52 130.82,35.52 130.31,35.01 130.31,33.88 129.96,33.52 129.21,33.52 128.28,34.46 117.32,34.46 117.07,34.2 v2(117.07,33.85)
  BOTTOM w0.089: 155.38,37.73 155.81,38.17 156.19,38.17 157.41,39.39 161.93,39.39 162.79,40.25 163.75,40.25 164.83,41.33 164.83,41.46 U2000.M44
  BOTTOM w0.102: v2(116.71,46.4) 116.27,46.4 115.75,45.87 v1(115.75,45.65) 116.31,45.09 116.31,40.76 117.25,39.82 117.25,38.17 117.07,37.99 117.07,36.03 117.2,35.9 117.2,34.87 117.07,34.74 v2(117.07,33.85) ; R2210.2 154.56,34.66 154.05,34.66 153.67,35.04 v2(153.66,35.04) 153.89,35.27 153.89,36.14 154.14,36.39 154.68,36.39 154.78,36.49 154.78,37.13 155.38,37.73
EXT_SCI#_D: length 2.8
  TOP w0.102: R3082.2 115.57,47.12 v1(115.88,46.82) 115.88,46.51 116.32,46.06 U3001.23
EXT_SMI#: length 91.2
  TOP w0.102: R3069.1 120.17,51.2 120.24,51.12 120.24,49.93 v2(120.07,49.75) ; v2(167.64,34.68) 167.4,34.68 R2365.2
  IN1 w0.102: v2(117.68,33.85) 117.98,34.15 122.31,34.15 123.17,33.29 130.02,33.29 130.44,33.72 130.92,33.72 131.17,33.96 131.17,34.77 131.72,35.32 143.69,35.32 144.39,34.63 154.6,34.63 154.95,34.28 167.24,34.28 v2(167.64,34.68) 168.04,34.28 173.7,34.28 174.02,34.59 174.02,35.49 174.33,35.81 176.01,35.81 v2(177.64,37.43)
  BOTTOM w0.089: 177.64,37.73 177.64,38.15 177.04,38.75 176.61,38.75 175.47,39.88 175.47,40.59 175.76,40.88 175.76,41.16 176.05,41.45 176.05,41.79 U2000.AN43
  BOTTOM w0.102: v2(117.68,33.85) 117.68,34.46 118.06,34.84 118.06,35.81 117.27,36.6 117.27,37.91 117.48,38.11 117.48,41.08 119.81,43.41 v1(119.81,45.15) 119.66,45.31 119.66,49.34 v2(120.07,49.75) ; 177.64,37.73 v2(177.64,37.43)
F_CS#_EC: length 4.5
  TOP w0.114: v1(129.39,30.85) 129.77,31.23 R3041.2 129.39,32.18 128.7,32.18 128.13,32.75 U3001.101
F_SCK_EC: length 3.3
  TOP w0.114: R3043.2 129.09,33.49 128.31,34.27 127.77,34.27 127.69,34.35 U3001.105
F_SDI_EC: length 3.2
  TOP w0.114: U3001.102 v1(128.7,33.15) 129.23,32.63 R3044.2
FAN0_PWM: length 146.7
  TOP w0.102: v2(111.94,46.55) 112.36,46.13 113.44,46.13 113.52,46.05 U3001.30
  IN2 w0.102: v2(111.94,46.55) 111.68,46.29 108,46.29 107.77,46.52 107.77,47.16 104.12,50.82 76.44,50.82 75.94,51.33 65.75,51.33 64.87,52.2 55.57,52.2 53.99,53.79 53.99,56.41 53.24,57.16 41.04,57.16 40.01,58.19 40.01,60.32 40.67,60.98 40.67,63.01 40.41,63.26 39.49,63.26 35.94,66.82 35.94,68.41 34.99,69.36 34.99,76.51 32.31,79.19 32.31,93.16 v2(33.45,94.3)
  BOTTOM w0.102: R5006.1 R5000.2 42.5,111.7 v1(42.7,111.5) 42.7,110.99 42.13,110.42 42.13,108.67 41.43,107.97 38.99,107.97 33.45,102.43 v2(33.45,94.3)
