# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VSUS_CHARGING:
  vias: v1(253.85,55.5) v3(255.7,38.96) v3(255.7,38.07) v3(256.6,38.99) v3(256.6,38.12) v3(258.03,53.18) v3(258.06,54.12)
+5VSUS_PVDD: length 22.9
  TOP w0.457: R3714.1 198.31,28.58 v2(197.92,28.97)
  TOP w0.508: R3714.1 198.64,28.74 R3713.1 197.9,30.65 C3701.1 ; C3700.1 196.95,31.72 v2(198.04,31.72)
  IN3 w0.457: v2(204.39,32.94) 204.39,33.41 204.01,33.79 203.33,33.79 201.46,31.92 199.34,31.92 199.14,31.72 v2(198.04,31.72) 198.04,31.08 198.55,30.57 198.55,29.4 198.12,28.97 v2(197.92,28.97)
  BOTTOM w0.102: v2(204.39,32.94) 203.83,33.5 v1(203.83,34.41)
  BOTTOM w0.254: U3700.4 198.16,32.07 198.04,31.95 v2(198.04,31.72) 198.14,31.62 U3700.3 ; v2(204.39,32.94) 204.27,32.81 R3707.2 R3708.2
+5VSUS_PWR: length 56.1
  TOP w0.254: v1(179.76,171.67) 179.88,171.8 PR701.2 179.04,172.65 v2(178.87,172.47) ; PR703.2 198.17,176.79 198.41,177.03 198.41,178.42 199.63,179.64 v2(199.63,181.14)
  TOP w0.279: PCON702.1 v2(211.4,177.46) ; PCON700.3 v2(174,172.47) ; CON402.19 v2(186.2,176.37)
  IN2 w0.381: v2(174,172.47) v2(178.87,172.47) 180.43,172.47 182.01,174.05 184.58,174.05 186.2,175.67 v2(186.2,176.37) 186.23,176.4 186.23,178.61 188.76,181.14 v2(199.63,181.14) 209.08,181.14 211.4,178.81 v2(211.4,177.46)
+5VSUS_TYPEC: length 7.6
  TOP w0.254: U1201.H10 242.99,53.12 243.37,52.74 243.47,52.74 v4(243.53,52.67)
  BOTTOM w0.508: v2(240.73,54.31) 241.47,53.56 242.64,53.56 v4(243.53,52.67) ; v2(236.63,54.33) 237.38,55.08 238.49,55.08 239.18,54.38 v2(239.18,54.21)
  vias: v1(235.64,55.08)
+12V: length 2.6
  TOP w0.432: T9110.1 145.44,32.48 R9108.1
  TOP w0.508: Q9103.4 145.55,32.33 T9110.1
+12VS: length 197.6
  TOP w0.254: R5136.1 155.16,27.49 154.58,27.49 154.36,27.27 153.3,27.27 153.08,27.49 150.32,27.49 149.28,28.54 149.28,31.2 150.42,32.34 150.42,34.26 149.5,35.17 v2(149.5,35.23)
  TOP w0.305: v2(149.5,35.23) T9107.1 149.38,36.69 149.38,37.72 R9107.1 149.61,38.67 Q9102.4 ; v2(249.48,80.1) 247.07,80.1 246.69,80.48 246.69,82.14 247.32,82.77 247.74,82.77 Q4804.1
  TOP w0.381: v2(258.62,88.74) 258.24,89.12 R4629.1
  IN1 w0.381: v2(249.48,80.1) 251.77,82.39 254.56,82.39 255.7,83.53 255.7,87.67 257.03,88.99 258.1,88.99 258.36,88.74 v2(258.62,88.74)
  IN2 w0.305: v2(216.13,71.16) 216.61,71.64 218.23,71.64 219.63,70.23 219.63,69.4 219.68,69.35 219.68,60.47 219.63,60.42 219.63,58.55 217.83,56.75 217.83,52.95 214.68,49.79 214.68,49.59 213.28,48.19 213.28,45.36 212.57,44.65 212.57,42.38 212.53,42.34 212.53,42.33 212.23,42.03 212.22,42.03 210.57,40.38 210.57,39.93 209.84,39.2 209.84,36.18 208.43,34.77 205.66,34.77 204.96,34.07 203.23,34.07 202.49,33.33 201.6,33.33 201.05,32.78 196.53,32.78 194.48,30.73 191.05,30.73 190.25,29.94 177.42,29.94 176.4,30.95 174.9,30.95 174.26,31.59 173.11,31.59 172.86,31.84 168.6,31.84 168.08,31.32 167.49,31.32 167.06,31.75 167.06,32.96 166.05,33.97 151.46,33.97 150.7,34.73 150.01,34.73 v2(149.5,35.23)
  IN3 w0.305: v2(249.48,80.1) 247.69,81.9 242.11,81.9 239.06,84.95 224.32,84.95 223.57,84.21 223.57,78.78 224.14,78.22 224.14,75.2 220.86,71.93 218.57,71.93 218.45,72.05 217.01,72.05 v2(216.13,71.16)
+12VSUS: length 207.8
  TOP w0.254: v2(146.86,46.7) 147.12,46.7 147.86,45.96 Q9101.3 ; Q9102.3 147.76,39.32 148.03,39.59 148.03,41.04 146.2,42.87 v2(146.13,42.87)
  TOP w0.305: Q9103.3 142.71,32.33 143.28,32.91 143.28,33.65 143.94,34.31 145.44,34.31 146.45,35.32 v2(147.49,35.32) 147.88,35.71 147.88,38.42 147.06,39.25 Q9102.3
  TOP w0.508: v2(251.13,68.06) 252.25,66.94 T8127.1
  IN1 w0.254: v2(146.86,46.7) 146.13,45.97 v2(146.13,42.87)
  IN2 w0.305: v2(147.49,35.32) 148.72,36.56 167.11,36.56 167.65,36.02 196.73,36.02 197.03,35.72 198.77,35.72 198.77,35.72 199.19,35.72 199.25,35.78 199.3,35.78 199.94,36.43 201.56,36.43 202.46,37.33 203.73,37.33 207.16,40.76 208.04,40.76 210.08,42.8 210.08,46.36 210.51,46.78 210.51,47.88 211.79,49.16 211.79,50.48 213.49,52.19 213.49,59.55 216.5,62.56 216.5,64.53 212.49,68.53 212.49,78.43 211.86,79.06 211.86,79.59 211.13,80.32 v2(211.13,84)
  IN2 w0.508: v2(223.63,87.24) 223.85,87.24 224.51,87.9 225.15,87.9 226.51,89.26 226.51,90.63 226.97,91.08 229.56,91.08 230.5,92.02 233.91,92.02 234.25,91.69 239.53,91.69 241.5,89.71 241.5,87.64 244.01,85.13 245.35,85.13 248.78,81.7 249.88,81.7 252.07,79.52 252.07,71.08 254.15,69 254.15,67.95 253.68,67.48 251.74,67.48 251.16,68.06 v2(251.13,68.06)
  IN3 w0.508: v2(223.63,87.24) 222.18,87.24 221.41,88 221.41,88.11 220.63,88.89 217.04,88.89 215.82,88.23 213.41,88.23 211.13,85.95 v2(211.13,84)
  BOTTOM w0.305: Q9104.3 211.24,83.88 v2(211.13,84)
+AVDDH: length 18
  TOP w0.102: v1(222.9,95.57) 222.9,95.25 223.32,94.83
  TOP w0.229: U3300.9 230.58,94.76 230.81,94.99 230.81,95.21 C3318.1 ; C3319.1 224.38,94.76 U3300.22
  TOP w0.432: C3318.1 C3317.1 232.69,96.21 v2(233.22,96.21)
  TOP w0.508: v2(223.32,94.84) 223.32,94.83 C3319.1
  IN3 w0.508: v2(223.32,94.84) 223.32,94.83 223.65,94.83 224.42,94.06 230.34,94.06 232.1,95.83 232.84,95.83 v2(233.22,96.21)
+AVDDL: length 35.4
  TOP w0.229: C3308.2 224.38,89.93 225.25,89.93 226.09,90.77 U3300.31 ; v2(228.89,96.41) U3300.13 ; v2(226.49,96.53) U3300.19 ; U3300.6 231.91,93.56 231.95,93.51 C3316.1
  TOP w0.457: C3316.1 232.75,93.35 C3315.1 233.39,93.75 v2(233.12,94.02)
  TOP w0.508: v2(224.74,90.64) 224.38,90.64 C3308.2
  IN3 w0.508: v2(233.12,94.02) 232.99,93.9 232.99,93.88 232.64,93.52 232.61,93.52 231.8,92.71 231.22,92.71 229.47,90.95 225.06,90.95 224.75,90.64 v2(224.74,90.64)
  BOTTOM w0.508: L3302.1 228.79,90.22 228.04,90.97 v1(227.91,90.97) 225.07,90.97 v2(224.74,90.64) 224.46,90.92 L3301.2 ; C3320.1 229.48,97.14 229.69,96.93 229.69,95.5 230.28,94.91 232.64,94.91 233.12,94.43 v2(233.12,94.02) ; C3320.1 228.43,97.14 228.33,97.25 C3321.1 226.67,96.72 v2(226.49,96.53) ; C3320.1 229.07,96.59 v2(228.89,96.41)
+AVDDVCO: length 8.4
  TOP w0.229: U3300.34 227.29,90.29 v2(227.19,90.18)
  BOTTOM w0.508: v1(228.22,89.12) 227.99,89.35 C3303.1 ; C3303.1 C3304.1 225.51,89.35 C3305.1 224.84,90.02 223,90.02 222.6,90.43 L3301.1 ; C3303.1 227.25,90.12 v2(227.19,90.18)
+DVDDIO_AUDIO_W10MIL: length 16.4
  TOP w0.254: v2(179.17,56.55) 179.17,56.62 179.64,57.09 179.93,57.09 180.62,57.78 180.95,57.78 181.31,58.13 C2629.1 181.44,58.24 182.05,58.24 v1(182.7,58.89) v2(183.18,59.36)
  TOP w0.508: R2608.2 188.38,65.64 188.65,65.37 v2(188.65,65.12)
  IN1 w0.254: v2(183.18,59.36) 183.18,60.61 185.15,62.58 187.58,62.58 187.88,62.88 187.88,64.36 v2(188.65,65.12)
  BOTTOM w0.254: U2000.BA15 179.17,56.38 v2(179.17,56.55)
+DVDDL: length 1
  TOP w0.203: U3300.37 228.49,90.17 228.64,90.02
  vias: v1(230.2,85.29) v2(229.42,87.37) v2(230.04,87.38)
+V1P0A_VCCAMPHYPLL_W25MIL:
  vias: v1(154.4,40.87)
+V1P0A_VCCAPLL_W15MIL: length 14.2
  TOP w0.254: v2(174.07,60.75) 174.07,61.8 C2619.1 173.41,61.7 v1(173.41,60.04) 173.41,56.61 172.97,56.17 172.89,56.17 R2607.2 172.99,55.8 174.03,54.77 174.03,54.57 C2618.1 174.99,53.93 v2(175.44,54.37)
  BOTTOM w0.254: U2000.AL5 174.11,60.79 v2(174.07,60.75) 174.02,60.79 U2000.AJ5
  BOTTOM w0.381: v2(175.44,54.37) 175.44,54.03 U2000.AN19
+V1P0A_VCCF24_W15MIL: length 1.3
  BOTTOM w0.203: U2000.K3 164.28,62.13 164.18,62.23 U2000.K2 164.17,62.39 164.17,63.12 v2(164.17,63.12)
  vias: v1(162.87,68.04)
+VBUS1: length 44.3
  TOP w0.279: CON1201.A9 267.45,27.3 CON1201.B4
  IN1 w0.762: v3(244.14,54.63) 243.96,54.45 243.75,54.45 242.82,53.52 240.17,53.52 239.32,52.67
  IN1 w1.778: 248.84,54.07 249.99,52.93 252.53,52.93 254.05,51.4 254.05,37.43 254.69,36.8 254.69,34.46 253.09,32.86 253.09,30.14 255.19,28.03 255.19,24.99 255.07,24.86
  IN2 w0.508: 266.81,27.25 CON1201.B4 267.5,27.94 ; 266.81,24.85 CON1201.B9 267.5,24.16
  vias: v1(248.82,53.78) v2(237.97,52.71) v2(238.71,52.83) v2(247.26,54.94) v2(247.89,54.94) v3(248.46,54.45) v3(253.8,23.97) v3(253.8,23.08) v3(253.8,22.19) v3(258.66,21.52) v3(258.68,20.64) v3(258.74,19.74)
+VCC_RTC: length 137.3
  TOP w0.508: R2609.1 191.91,61.01 v2(192.2,60.72) 192.2,60.42 192.64,59.99 198.03,59.99 201.92,63.87 206.43,63.87 212.5,69.94 v1(213.87,69.94) 215.98,69.94 v2(216.1,69.82)
  IN1 w0.508: v2(222.3,59.66) 221.48,60.48 221.48,65.32 219.79,67.01 219.79,69.03 219.53,69.28 219.53,70.62 218.62,71.54 217.02,71.54 216.75,71.27 216.75,70.82 216.1,70.17 v2(216.1,69.82)
  IN3 w0.508: v2(258.05,58) 256.45,59.6 256.45,67.43 254.74,69.14 254.74,71.54 252.65,73.63 252.65,74.09 245.4,81.34 241.73,81.34 238.63,84.44 224.53,84.44 224.08,84 224.08,79.47 224.65,78.9 224.65,73.74 222.02,71.11 218.66,71.11 218.23,71.54 217.34,71.54 216.75,70.94 216.75,70.69 216.1,70.05 v2(216.1,69.82)
  BOTTOM w0.457: v2(192.2,60.72) 191.82,61.1 R2448.1
  BOTTOM w0.508: R6006.1 251.03,65.17 251.03,64.35 252.68,62.7 253.46,62.7 258.05,58.12 v2(258.05,58) ; v2(222.3,59.66) 222.05,59.4 C2826.1 ; C2826.1 222.38,58.44 223.53,57.28 D2801.3 ; C2826.1 R2810.1 R2812.1
+VCC_SYS_HV: length 11.7
  BOTTOM w0.102: v2(239.04,51.94) 238.54,51.44 238.18,51.44 237.68,51.94 236.78,51.94 235.97,52.75 T1206.1 230.71,52.37 230.38,52.04 228.96,52.04 T1205.1
+VCCGT: length 49.6
  IN2 w0.102: 33.8,143.27 33.39,143.27 ; 23.43,142.55 23.05,142.55 ; 23.43,136.25 23.06,136.25 ; 24.05,147.28 23.69,147.28 ; 26.86,142.17 26.52,142.17 ; 24.09,148.07 23.68,148.07 ; 23.39,141.77 23.05,141.77 ; 23.43,139.41 23.05,139.41 ; 23.03,138.63 23.41,138.63 ; 38.49,144.79 38.1,144.79 ; 29.46,144.03 29.08,144.03 ; 29.47,144.79 29.09,144.79 ; 33.79,144.79 33.4,144.79 ; 38.48,144.03 38.1,144.03 ; 38.5,142.51 38.11,142.51 ; 24.05,133.89 23.66,133.89 ; 38.5,143.27 38.09,143.27 ; 33.81,142.51 33.41,142.51 ; 29.48,143.27 29.07,143.27 ; 29.49,142.51 29.09,142.51 ; 33.78,144.03 33.4,144.03 ; 24.34,138.61 24.79,138.61 ; 24.05,148.87 23.69,148.87
  IN3 w0.102: 20.6,141.83 20.6,141.39 ; 23.01,141.79 23.44,141.77 ; 23.03,140.19 24.06,140.2 ; 23.04,142.58 23.46,142.55 ; 26.52,142.16 26.87,142.18 ; 23.04,138.63 23.41,138.63 ; 23.05,139.42 23.41,139.42 ; 16.56,146.27 16.61,145.86 ; 23.7,147.29 24.06,147.29 ; 23.66,148.87 24.09,148.87 ; 24.33,138.64 24.68,138.61 ; 23.01,136.26 23.47,136.26 ; 23.68,148.08 24.09,148.07
  IN3 w0.508: v2(26.98,159.4) 32.79,159.4 34.95,161.56 34.95,166.94 29.23,172.66 26.77,172.66 25.24,174.19 24.28,174.19 21.77,176.71 v2(21.77,177.93)
  IN4 w0.102: 26.5,142.16 26.89,142.16 ; 16.56,146.29 16.61,145.89 ; 23.69,148.08 24.07,148.08 ; 23.7,148.85 24.12,148.85
  BOTTOM w0.381: R8019.1 v2(21.77,177.93)
  vias: v1(22.78,156.05) v2(12.25,146.59) v2(13.39,147.53) v2(14.09,147.25) v2(14.45,147.92) v2(32.21,154.55) v2(33.55,154.55) v2(34.54,154.57) v3(11.72,153.45) v3(11.71,152.58) v3(11.95,150.99) v3(12.32,154.07) v3(12.27,151.92) v3(12.63,147.23) v3(12.9,153.42) v3(12.9,152.56) v3(12.87,146.15) v3(13.18,154.24) v3(13.51,146.79) v3(13.69,155.81) v3(13.69,154.94) v3(13.72,148.2) v3(13.78,153.45) v3(13.84,150.83) v3(13.84,149.97) v3(13.77,149.1) v3(14.4,154.05) v3(14.55,155.77) v3(14.55,154.9) v3(14.63,151.35) v3(14.63,150.46) v3(14.63,149.57) v3(14.63,148.68) v3(15.15,152.08) v3(24.77,153.46) v3(25.25,154.22) v3(25.65,153.46) v3(25.76,155.01) v3(26.14,154.22) v3(26.19,155.77) v3(26.54,153.46) v3(26.64,155.01) v3(27.03,154.22) v3(27.08,155.77) v3(27.43,153.46) v3(27.53,155.01) v3(27.91,154.22) v3(27.97,155.77) v3(28.32,153.46) v3(28.42,155.01) v3(28.8,154.22) v3(28.85,155.77) v3(29.21,153.46) v3(29.31,155.01) v3(29.72,155.77) v3(29.69,154.22) v3(30.1,153.46) v3(30.2,155.01) v3(30.61,155.77) v3(30.58,154.22) v3(30.99,153.46) v3(31.12,155.01) v3(32.61,153.08) v3(33.5,153.08) v3(34.52,153.08) v3(35.43,152.95) v3(35.64,153.84) v3(36.32,153.28) v6(23.29,152.37) v6(26.21,152.37) v6(26.93,150.74) v6(26.93,150.09) v6(26.93,149.44) v6(26.93,147.48) v6(26.93,146.83) v6(27.72,150.74) v6(27.72,150.09) v6(27.72,149.44) v6(27.72,147.48) v6(27.72,146.83) v6(28.5,152.37) v6(28.92,134.24) v6(28.92,133.23) v6(29.29,150.74) v6(29.29,150.09) v6(29.29,149.44) v6(29.29,147.49) v6(29.29,146.84) v6(30.08,150.74) v6(30.08,150.09) v6(30.08,149.44) v6(30.08,147.49) v6(30.08,146.84) v6(30.79,144.41) v6(30.79,143.65) v6(30.79,142.89) v6(30.79,142.13) v6(30.75,133.22) v6(31.17,139.46) v6(31.17,138.83) v6(31.66,150.74) v6(31.66,150.09) v6(31.66,149.44) v6(31.66,147.49) v6(31.66,146.84) v6(31.67,136.79) v6(31.67,136.16) v6(31.67,135.52) v6(31.67,134.89) v6(31.67,134.23) v6(31.67,133.24) v6(32.06,145.18) v6(32.06,144.41) v6(32.06,143.65) v6(32.06,142.89) v6(32.06,142.13) v6(32.44,150.74) v6(32.44,150.09) v6(32.44,149.44) v6(32.44,147.49) v6(32.44,146.84) v6(32.56,136.79) v6(32.56,136.16) v6(32.56,135.52) v6(32.56,134.89) v6(32.56,133.24) v6(33.07,139.46) v6(33.07,138.83) v6(33.2,152.37) v6(33.23,150.74) v6(33.23,150.09) v6(34.02,150.74) v6(34.02,150.09) v6(34.02,149.44) v6(34.02,147.49) v6(34.02,146.84) v6(34.21,134.23) v6(34.81,150.74) v6(34.81,150.09) v6(34.81,149.44) v6(34.81,147.49) v6(34.81,146.84) v6(35.23,145.05) v6(35.23,144.41) v6(35.23,143.65) v6(35.23,142.89) v6(35.23,142.13) v6(35.31,134.23) v6(36.38,150.74) v6(36.38,150.09) v6(36.38,149.44) v6(36.38,147.49) v6(36.38,146.84) v6(36.63,139.46) v6(36.63,138.83) v6(36.75,145.05) v6(36.75,144.41) v6(36.75,143.65) v6(36.75,142.89) v6(36.75,142.13) v6(37.17,150.74) v6(37.17,150.09) v6(37.17,149.44) v6(37.17,147.49) v6(37.17,146.84) v6(37.26,136.79) v6(37.26,136.16) v6(37.26,135.52) v6(37.26,134.89) v6(37.26,134.25) v6(38.02,152.24) v6(37.96,150.74) v6(37.96,150.09) v6(38.07,133.22) v6(38.74,150.74) v6(38.74,150.09) v6(38.74,149.44) v6(38.74,147.49) v6(38.74,146.84) v6(38.98,133.22) v6(39.53,150.74) v6(39.53,150.09) v6(39.53,149.44) v6(39.53,147.49) v6(39.53,146.84) v6(39.8,145.05) v6(39.8,144.41) v6(39.8,143.65) v6(39.8,142.89) v6(39.8,142.13) v6(39.8,136.79) v6(39.8,136.16) v6(39.8,135.52) v6(39.8,134.89) v6(39.8,134.25) v6(39.88,133.22) v6(40.06,139.46) v6(40.06,138.83) v6(41.11,150.74) v6(41.11,150.09) v6(41.11,149.44)
+VCCIO: length 114.9
  TOP w0.254: R0745.1 20.25,138.75 19.59,139.41 16.91,139.41 R0700.1 15.41,140.25 v2(15.4,140.26) ; R0300.1 62.61,150.56 64.41,150.56 64.64,150.79 v6(64.64,151.02)
  IN1 w0.102: 60.21,139.64 58.47,139.64 ; 59.13,136.5 59.54,136.5 ; 58.39,142.79 61.06,142.79 61.19,142.66 ; 58.45,134.92 60.2,134.92 ; 59.11,135.7 60.3,135.7 ; 58.46,141.99 59.53,141.99 ; 60.24,140.43 58.44,140.43 ; 59.5,141.21 58.47,141.21
  IN1 w0.254: v2(7.29,129.68) 7.52,129.68 8.73,130.89 8.73,133.3 15.4,139.97 v2(15.4,140.26) 16.26,140.26 16.82,140.81 16.82,142.54 15.44,143.92 v2(14.77,143.92) ; 56.41,133.7 45.06,133.7 43.99,132.63 v6(43.56,132.63)
  IN2 w0.102: 59.74,130.99 60.2,130.99 ; 58.44,139.63 60.17,139.63 ; 58.47,141.22 59.56,141.22 ; 58.58,142.79 59.43,142.79 ; 59.1,136.5 59.53,136.5 ; 58.44,142.01 59.52,142.01 ; 57.86,132.55 58.18,132.55 ; 59.11,132.55 59.61,132.55 ; 58.46,140.43 60.16,140.43
  IN2 w0.305: 62.59,131.13 62.59,128.95 63.14,128.39 65.61,128.39 66.65,127.35 v2(66.65,124.02)
  IN3 w0.102: 24.75,132.32 24.75,132.33 24.32,132.33 ; 23.67,133.91 24.07,133.91 ; 23.63,132.33 24.07,132.33 24.07,132.33 ; 24.09,131.55 23.64,131.55 ; 24.92,132.15 24.92,131.75 ; 23.68,133.11 24.03,133.11 ; 24.25,133.12 24.73,133.12
  IN3 w0.508: 19.08,134.28 19.08,135.05 15.4,138.73 v2(15.4,140.26)
  IN4 w0.102: 59.57,143.59 58.35,143.59 ; 58.45,139.63 60.26,139.63 ; 58.43,141.21 59.51,141.21 ; 59.49,142 58.27,142 ; 59.04,136.5 59.5,136.5 ; 60.26,140.43 58.44,140.43 ; 59.72,142.79 59.71,142.79 58.41,142.79
  BOTTOM w0.254: R0744.1 14.13,143.05 14.13,143.28 v2(14.77,143.92) ; v6(43.56,132.63) 43.18,132.25 U0300.AG12 ; R4409.1 8.94,125.01 8.56,125.39 7.77,125.39 7.24,125.92 7.24,126.98 7.37,127.11 7.37,129.41 7.29,129.48 v2(7.29,129.68)
  BOTTOM w0.305: R0600.1 68.62,121.78 68.89,121.51 69.39,121.51 69.95,122.07 69.95,122.88 69.6,123.23 67.43,123.23 v2(66.65,124.02)
  BOTTOM w0.381: v6(64.64,151.02) 64.64,150.97 64.67,150.94 66.26,150.94 67.82,149.38 69.32,149.38
  vias: v3(67.13,141.01) v3(67.77,141.62) v3(68.4,141.01) v3(68.96,141.67) v3(69.19,147.07) v3(69.17,146.17) v3(69.17,145.31) v3(69.52,141.01) v3(70.07,147.07) v3(70.07,146.2) v6(56.44,144.03) v6(56.44,143.4) v6(56.44,136.7) v6(56.54,139.26) v6(56.52,138.45) v6(56.52,136.09) v6(56.52,135.32) v6(57.99,139.25) v6(57.99,136.1) v6(57.99,135.31)
+VCCIO_PWRGD: length 168.1
  TOP w0.102: v2(111.33,55.42) 112.3,56.39 116.29,56.39 117.15,55.53 126.53,55.53 T9209.1 127.77,53.8 127.77,50.65 R9212.1 ; v2(81.2,128.49) 80.07,127.36 70.27,127.36 v2(69.49,128.14)
  IN1 w0.102: v2(69.49,128.14) 71.58,126.05 71.58,122.47 77.81,116.25 77.81,111.53 98.52,90.82 98.52,88.06 99.9,86.68 99.9,74.22 100.51,73.61 100.51,72.76 100.96,72.31 102.25,72.31 102.99,71.57 102.99,68.21 105.52,65.68 v2(106.37,65.68)
  IN4 w0.102: v2(76.81,161) 80.64,161 81.03,160.61 81.03,159.75 77.42,156.15 77.42,150.54 80.75,147.21 80.75,128.95 v2(81.2,128.49)
  BOTTOM w0.102: v2(76.81,161) 77.37,161 77.62,160.75 77.62,160.29 77.15,159.82 U9400.12 ; v2(106.37,65.68) 106.73,65.31 106.73,64.9 108.51,63.12 108.51,58.24 v2(111.33,55.42)
+VCCPFUSE_W20MIL: length 15.4
  TOP w0.406: C2610.1 182.04,61.97 v2(181.93,62.08)
  TOP w0.508: R2605.2 185.03,65.64 v1(184.79,65.88) 184.34,65.43 v2(184.07,65.43)
  IN1 w0.508: v2(181.93,62.08) 182.68,62.08 183.57,62.96 183.57,64.93 v2(184.07,65.43)
  IN2 w0.254: v2(176.33,60.47) 176.33,61.44 177.14,62.24 180.62,62.24 180.79,62.08 v2(181.93,62.08)
  BOTTOM w0.254: v2(176.33,60.47) 176.06,60.74 U2000.AN5
+VCCPGPPCD_W15MIL: length 6.2
  BOTTOM w0.457: 181.27,40.21 181.52,39.97 183.19,39.97 183.71,39.45 v1(184.47,39.45) 184.47,37.44 184.07,37.05 R2603.2
+VCCPLL_OC: length 67.2
  IN3 w0.254: v6(57.99,131.37) 57.49,130.87 57.49,129.6 57.96,129.13 57.96,128.66 60.42,126.2 64.32,126.2 64.72,125.81 64.72,125.43 55.29,116 33.67,116 27.8,121.87 27.8,127.67 26.64,128.83 26.64,131.74 26.64,131.75 26.64,132.15 v6(27.09,132.6)
  BOTTOM w0.305: v6(27.09,132.6) 26.99,132.6 26.69,132.9 U0300.BH13 ; U0300.G11 58.31,131.71 v6(57.99,131.37)
  vias: v1(25.48,129.86)
+VCCRTC_W8MIL: length 20.1
  TOP w0.254: v2(183.29,52.03) 183.29,52.19 183.08,52.39 C2625.1 182.3,52.39 182.17,52.52 181.76,52.52 181.63,52.39 C2624.1 180.21,52.39 180.09,52.51 179.44,52.51 179.12,52.2 v2(179.12,52.02) ; v1(192.33,59.41) 192.07,59.67 R2609.2 190.31,59.67 v2(190.02,59.96)
  IN2 w0.254: v2(183.29,52.03) 183.29,52.66 184.96,54.34 184.96,56.56 186.33,57.93 187.3,57.93 188.82,59.45 189.84,59.45 190.02,59.63 v2(190.02,59.96)
  BOTTOM w0.254: v2(179.12,52.02) 179.12,52.2 U2000.BA22
+VCCSA: length 102.5
  TOP w0.102: 58.83,150.27 58.83,149.17 ; 59.76,147.53 60.19,147.53
  TOP w0.508: v2(3.23,174.13) 2.66,174.13 2.41,174.38 R8075.2
  TOP w2.794: 67.92,153.3 70.39,155.77 70.39,155.79
  IN2 w1.016: 58.85,156.05 58.83,156.05 55.3,152.52 55.3,152.49
  IN2 w1.27: 60.38,154.91 56.82,151.35
  IN3 w0.508: v2(26.98,164.48) 25.53,164.48 19.66,170.35 14.32,170.35 12.88,171.8 10.41,171.8 9.29,172.92 9.29,175.58 8.11,176.76 3.87,176.76 3.23,176.11 v2(3.23,174.13) ; v2(48.9,166.36) 48.9,165.63 50.22,164.3 54.77,164.3 58.17,167.71 64.06,167.71 66.78,164.99 66.78,158.79
  BOTTOM w0.508: v2(48.9,166.36) 47.99,167.26 42.19,167.26 41.41,168.04 30.56,168.04 28.57,166.05 26.87,166.05 26.49,165.66 26.49,164.96 v2(26.98,164.48)
  vias: v1(74.85,164.05) v3(73.2,162.78) v3(73.33,166.51) v3(73.33,165.62) v3(74.22,166.51) v3(74.22,165.62) v3(74.22,162.78) v3(75.11,167.4) v3(75.11,166.51) v3(75.11,165.62) v3(76,167.4) v3(76,166.51) v3(76,165.62) v6(55.28,150.74) v6(55.28,150.09) v6(55.28,148.78) v6(55.28,148.13) v6(55.27,146.83) v6(55.82,152.32) v6(56.07,149.43) v6(56.07,148.13) v6(56.07,147.48) v6(56.07,146.84)
AGND: length 259.8
  TOP w0.203: v2(16.31,72.28) 16.18,72.15 16.18,71.91 16.38,71.71 U3600.25 ; v2(17.16,66) 17.35,66 17.5,66.15 U3600.38
  TOP w0.381: v2(18.77,77.72) 18.21,78.28 C3646.2
  TOP w0.457: v2(20.53,77.23) 20.28,77.23 20.2,77.31 20.19,77.31 19.61,77.89 C3607.2
  TOP w0.508: C3600.2 13.48,70.91 v2(13.26,71.12) ; v2(8.62,72.29) 8.81,72.48 C3647.2 ; v2(16.31,72.91) 16.23,72.99 C3606.2 ; C3605.2 15.66,74.73 v2(16,74.39) ; v2(10.72,69.48) 10.41,69.79 C6705.2 ; v2(12.24,71.01) 12.62,70.63 C6704.2
  IN1 w0.508: v2(202.13,34.84) 202.13,33.62 203.71,32.04 v2(203.71,29.61)
  IN4 w0.508: v2(19.86,73.42) 19.86,70.71 21.11,69.46 21.11,68.65 22.49,67.28 22.86,67.28 23.26,66.88 23.26,62.24 28.8,56.7 28.8,46.92 30.05,45.68 30.05,37.36 34.53,32.87 50.05,32.87 51.63,34.45 67.11,34.45 69.63,31.94 110.74,31.94 115.49,27.19 153.3,27.19 156.67,23.82 198.4,23.82 201.37,26.79 201.37,28.59 201.6,28.82 203.18,28.82 203.63,29.28 203.63,29.53 v2(203.71,29.61)
  BOTTOM w0.254: CON6700.23 8.83,72.75 8.62,72.55 v2(8.62,72.29) ; v2(10.72,69.48) 10.54,69.3 10.36,69.3 10.3,69.25 CON6700.16 8.7,69.25 v2(8.62,69.33)
  BOTTOM w0.381: 203.71,29.3 203.76,29.25 204.37,29.25 R3709.1 ; 203.71,29.3 v2(203.71,29.61) ; 203.71,29.3 203.15,28.75 201.42,28.75 200.94,29.23 R3710.1
  BOTTOM w0.457: v2(20.19,76.07) 20.09,76.16 R3711.2 ; v2(20.41,77.94) 19.95,78.4 C3645.2 ; R3712.2 v2(15.93,77.61)
  BOTTOM w0.508: D3600.2 18.09,72.2 16.38,72.2 v2(16.31,72.28) ; R3631.2 v2(14.15,68.05) ; R3630.2 19.61,73.17 v2(19.86,73.42) ; v1(202.49,36.49) C3709.2 202.49,35.1 202.24,34.84 v2(202.13,34.84) ; v2(17.16,66) 17.16,66.29 17.42,66.56 C3613.2 ; v2(16.54,65.95) 16.27,65.95 15.88,66.34 C3612.2
  vias: v2(12.15,74.54) v2(12.76,74.52) v2(14,74.11)
GND: length 3073
  TOP w0.102: 107.11,155.28 107.11,154.86 ; 104.7,156.89 104.7,156.47 ; 120.97,157.93 121.35,157.94 ; v6(145.94,178.63) 145.94,178.63 146.34,178.23 146.34,177.52 146.74,177.12 146.74,177.07 146.75,177.06 v6(146.76,177.06) ; 107.37,154.73 107.81,154.73 ; 105.54,157.7 105.54,157.29 ; 106.3,157.7 106.35,157.24 ; 101.51,155.72 101.51,156.16 ; 104.93,155.5 105.33,155.5 ; 102.29,157.69 102.29,157.33 ; 107.09,153.54 107.11,153.28 ; 104.11,155.52 104.47,155.49 ; 105.49,153.71 105.51,153.31
  TOP w0.127: v4(242.45,39.31) U1101.M1 U1101.M2 ; U1101.H1 U1101.H2 244.29,38.19 v4(244.06,37.97) ; v4(243.37,39.31) 243.37,39.31 U1101.K1 U1101.K2 ; v4(240.61,39.3) 240.61,39.3 U1101.T1 U1101.T2 ; U1101.P2 U1101.P1 v4(241.53,39.31)
  TOP w0.152: U1101.B20 U1101.A20 v4(248.07,30.07) ; U1101.AA23 v4(238.31,28.19) ; v4(241.07,28.19) U1101.R23 U1101.R22 241.07,29.28 v4(240.82,29.53) ; v4(244.75,28.19) U1101.G23 U1101.G22 ; U1101.AB16 U1101.AC16 ; U1101.L22 U1101.L23 v4(242.91,28.19) ; U1101.N23 v4(241.99,28.19) ; v4(239.23,28.19) U1101.W23 U1101.W22 ; U1101.AB18 U1101.AC18 ; U1101.AB14 U1101.AC14 ; v4(243.83,28.19) U1101.J23 U1101.J22 ; U1101.AB22 U1101.AC22 ; v4(245.67,28.19) U1101.E23 U1101.E22 ; U1101.AB12 U1101.AC12 ; U1101.AB8 U1101.AC8 ; v4(240.15,28.19) U1101.U23 U1101.U22 ; U1101.AB10 U1101.AC10
  TOP w0.178: v4(248.07,32.83) 248.02,32.89 247.63,32.89 ; U1101.B22 U1101.A22 v4(248.07,29.15) ; U1101.AC16 236.84,31.91 236.82,31.88 v4(236.82,31.83) ; v2(123.35,41.06) 123.44,41.15 U3001.122 ; U3001.1 125.12,44.44 124.87,44.19 v2(124.87,44.01) ; U1101.B18 U1101.A18 248.22,30.99 v4(248.22,30.98) ; U1101.A12 248.06,33.75 ; U1101.B16 U1101.A16 v4(248.07,31.91) ; U1101.Y9 238.17,34.67 U1101.AB10 ; U3001.113 128.62,37.55 v2(128.78,37.71) ; v4(236.82,30.94) 236.87,30.99 U1101.AC18 ; v4(236.83,29.11) 236.86,29.15 U1101.AC22 ; U1101.AB6 U1101.AC6 236.84,36.51 v4(236.82,36.53) ; U1101.AC10 236.84,34.67 236.82,34.64 v4(236.82,34.65) ; v4(236.82,32.79) 236.82,32.78 236.87,32.83 U1101.AC14 ; v2(109.96,37.15) 109.98,37.15 109.98,37.15 U3001.49 ; v4(236.82,30.05) 236.84,30.07 U1101.AC20 U1101.AB20 ; U1101.AC12 v4(236.82,33.75) ; v4(236.82,35.64) 236.87,35.59 U1101.AC8 ; U3001.27 v2(114.72,46.5) ; U1101.B6 U1101.A6
  TOP w0.191: U3001.91 123.12,30.79
  TOP w0.203: U9600.14 82.05,174.42 81.63,174.85 v2(81.2,174.85) ; CON4301.18 99.27,182.06 99.09,182.24 99.09,183.08 v2(99.75,183.74) ; U9101.11 195.76,65.35 v2(195.58,65.17) ; v2(133.93,64.43) 134.14,64.22 U8300.14 ; U8300.1 133.74,60.35 133.38,59.98 v2(133.27,59.98) ; U8300.3 v2(134.54,59.98) ; v2(238.29,61.74) 238.03,61.48 U9103.11 ; 123.12,30.79 123.12,31.51 122.35,32.28 v2(121.92,32.28)
  TOP w0.229: v2(180.14,83.42) 180.14,83.4 179.79,83.74 U8900.5 ; v2(224.71,92.67) 224.8,92.76 U3300.27
  TOP w0.254: C09103.2 32.94,147.85 v6(33.23,148.14) ; CON4301.1 90.77,180.4 v2(90.98,180.18) 92,180.18 92.27,180.45 CON4301.4 ; U1101.L5 243.1,37 v4(242.77,36.67) 242.45,37 U1101.M5 ; v2(123.11,64.2) 123.3,64.39 C9511.2 ; 56.25,180.26 CON4500.29 56.25,182.1 56.34,182.19 v2(56.34,182.41) ; v2(93.14,179.67) 93.14,180.05 93.77,180.67 CON4301.7 ; v2(165.79,40.45) 165.79,40.46 166.29,40.96 R2260.2 ; U1101.N5 241.8,37 v4(241.47,36.67) 241.15,37 U1101.R5 ; v6(45.04,148.78) 44.76,149.07 C0938.2 ; v2(244.97,48.38) 244.65,48.7 U1201.L1 ; v6(95.38,129.1) 95.38,129.3 95.77,129.69 C7224.2 ; CON4500.1 70.25,182.43 70.61,182.8 v2(70.89,182.8) ; C8006.1 v2(0.78,175.78) ; U1101.E11 245.7,34.4 v4(246.02,34.07) 246.35,34.4 U1101.D11 ; C0987.2 31.17,147.84 v6(30.87,148.14) ; v4(246.02,32.12) 245.7,32.45 U1101.E15 ; v4(246.02,32.12) 246.35,32.45 U1101.D15 ; v4(246.02,32.12) 246.34,31.8 U1101.D16 ; v4(246.02,32.12) 245.7,31.8 U1101.E16 ; CON4500.10 v2(65.75,182.29) ; C0999.2 31.17,149.09 v6(30.87,148.79) ; C0956.2 51.87,149.05 v6(52.13,148.78) ; v2(261.4,23.13) 261.51,23.24 D1202.2 ; 53.75,180.39 CON4500.34 53.75,182.1 v2(53.57,182.28) 53.25,181.96 CON4500.35 53.25,180.4 ; C3627.2 26.9,66.61 26.62,66.89 v2(26.44,66.89) ; 60.25,180.44 CON4500.21 60.25,182.09 60.02,182.32 v2(60.02,182.45) ; C09107.2 35.87,147.87 v6(35.59,148.14) ; v2(138.4,24.21) 138.38,24.18 U3102.19 ; C09116.2 28.25,149.05 v6(28.51,148.79) ; 59.75,180.44 CON4500.22 59.75,182.35 ; C0929.2 44.76,147.84 v6(45.04,148.13) ; CON4500.13 v2(64.25,182.26) ; 58.75,180.45 CON4500.24 58.75,182.34 ; U1101.N8 241.8,35.7 v4(242.12,35.37) 241.8,35.05 U1101.N9 ; R8084.1 34.16,176.22 34.68,175.7 v2(34.68,175.53) ; C09129.2 37.67,149.07 v6(37.96,148.79) ; v6(28.51,148.14) 28.25,147.88 C0986.2 ; v6(35.59,148.79) 35.87,149.06 C0998.2 ; v2(119.78,63.65) 119.78,63.88 R9506.1 ; U1401.18 216.28,39.64 v2(216.28,39.64) ; C0908.2 51.87,147.87 v6(52.13,148.13) ; v2(26.44,64.33) 26.9,64.78 C3628.2 ; 59.25,180.43 CON4500.23 59.25,182.16 59.39,182.3 ; v6(47.41,148.13) 47.17,147.9 C0946.2 ; v6(37.96,148.14) 37.67,147.85 C09108.2 ; U1101.F5 245.05,37 v4(245.38,37.33) ; v6(40.32,148.14) 40.56,147.89 C0977.2 ; C7220.2 96.65,131.56 96.3,131.9 v6(96.3,131.93) ; v6(33.23,148.79) 32.94,149.07 C09117.2 ; C0955.2 49.48,147.84 v6(49.77,148.13) ; v2(262.31,29.43) 262.05,29.18 D1207.2 ; 58.25,180.46 CON4500.25 58.25,182.25 58.31,182.32 ; 238.94,48.38 239.17,48.38 U1201.A1 ; v2(181.42,37.42) 181.42,36.78 C2304.2 ; v6(49.77,148.78) 49.48,149.07 C0920.2 ; U1101.D12 246.35,33.74 v4(246.03,33.42) U1101.D13 ; C0900.2 47.17,149.02 v6(47.41,148.78) ; v2(180.52,37.42) C2307.2 ; v2(133.24,66.02) 133.78,66.56 C8318.2 ; D1208.2 v2(262.69,27.22) ; U1101.W18 239.2,31.15 v4(239.52,31.47) ; CON4500.7 v2(67.25,182.26) ; R6114.2 v2(161.34,35.32) ; C09118.2 40.56,149.03 v6(40.32,148.79) ; R8039.1 23.78,172.83 v2(23.78,172.07) ; D1201.2 v2(261.42,24.87) ; v2(180.92,25.77) 180.92,24.75 181.52,24.15 U6200.18 ; CON4500.4 v2(68.75,182.3)
  TOP w0.279: v2(217.32,56.61) 217.32,56.61 U1301.24 ; U4601.31 245.42,110.83 244.96,111.3 C4612.2 244.96,112.41 v2(245.03,112.49) ; v2(264.66,23.25) 264.71,23.3 CON1201.A1 ; v2(253.09,56.63) 252.99,56.53 U5200.14 251,56.53 U5200.17 ; v2(210.52,35.8) U1401.3 ; U4601.18 249.74,106.27 v2(249.86,106.39) ; v2(250.8,128.32) 250.75,128.27 U5800.8 ; U1301.3 211.41,51.13 v2(211.28,51.26) ; U5800.4 251.25,125.52 v2(251.28,125.49) ; U1301.18 v2(215.47,53.61) ; U1401.24 216.17,42.64 v2(216.28,42.53) ; U4601.3 v2(243.92,102.36) ; v2(212.02,42.54) U1401.31 ; U1301.31 v2(212.91,56.5) ; U8800.14 v2(222.17,25.32) ; v2(250.14,128.34) 250.25,128.22 U5800.9 ; U5800.1 249.75,125.54 v2(249.73,125.52) ; CON1201.B1 267.45,28.8 CON1201.A12 v2(265.3,28.8) ; U4601.24 v2(249.82,109.27)
  TOP w0.305: CON1600.180 80.37,78.23 v2(80.72,78.57) ; CON1700.68 50.38,66.57 ; CON1700.167 77.13,55.96 77.25,55.84 ; CON1600.218 89.88,78.57 ; 94.13,67.97 CON1600.235 ; CON1700.196 84.38,66.62 ; v2(176.01,69.23) 176.1,69.23 176.51,68.82 176.51,68.33 R2127.2 ; 57.88,79.28 58.09,79.49 ; U8006.28 11.61,164.22 v2(11.99,163.84) ; CON1600.73 51.63,67.54 ; CON1700.103 59.13,56.03 59.49,55.67 ; 51.63,67.56 C1836.2 ; 51.38,78.88 50.99,79.26 v2(50.34,79.26) 49.96,79.26 49.38,78.68 ; CON1700.23 39.13,55.68 ; CON1600.222 90.88,78.75 ; R4610.2 252.14,114.97 251.74,114.57 v2(251.74,114.57) ; v2(95.05,67.83) 95.13,67.91 CON1600.239 ; R3063.1 116.96,48.86 116.99,48.86 117.21,49.08 v2(117.53,49.08) ; Q8106.1 v2(217.87,87.11) ; 38.86,66.56 38.88,66.55 CON1700.22 ; 54.88,78.92 54.53,79.26 54.03,79.26 v2(53.9,79.39) 53.77,79.26 53.39,79.26 52.88,78.75 ; 42.38,78.44 CON1600.36 ; 40.92,67.91 41.13,68.11 CON1600.31 ; 58.88,66.59 58.88,66.59 CON1700.102 ; v2(69.37,168.17) 69.27,168.26 U8003.28 68.01,168.26 67.08,169.2 U8003.35 ; CON1201.B12 267.45,23.3 CON1201.A1 ; 37.2,78.67 36.88,78.34 CON1600.14 ; C2305.2 182.37,35.42 v2(182.47,35.32) 182.8,35.32 183.26,35.78 R2348.1 ; C7924.2 120.45,102.99 v6(120.65,102.78) ; CON1700.15 37.13,55.63 ; CON1700.185 81.63,55.68 v2(81.64,55.67) 80.98,55.67 80.63,56.02 CON1700.181 ; CON1600.52 46.38,78.24 46.1,78.51 ; 81.63,68.02 CON1600.185 ; CON1600.106 59.88,78.22 59.56,78.54 ; v2(96.37,55.42) 97.13,56.17 CON1700.247 ; 35.88,78.59 CON1600.10 ; CON1600.172 78.38,78.64 v2(78.49,78.75) ; CON1600.205 86.63,67.77 ; CON1600.77 52.63,68.16 52.97,67.82 ; CON1700.57 v2(47.63,55.66) ; CON1600.247 97.13,67.96 v2(97.28,67.81) ; 83.31,66.59 83.38,66.53 CON1700.192 ; CON1600.184 81.37,78.52 ; CON1700.176 79.38,66.39 ; CON1600.90 55.88,78.35 v2(56.35,78.82) 56.88,78.3 CON1600.94 ; CON1700.27 40.13,55.57 ; v2(85.8,67.81) 85.63,67.98 CON1600.201 ; CON1600.15 37.13,67.93 37.06,67.93 ; v2(78.13,55.64) CON1700.171 ; 59.66,66.44 59.88,66.23 CON1700.106 ; CON1700.235 94.13,55.71 ; CON1600.69 50.62,67.86 ; 87.63,67.94 CON1600.209 ; 86.88,78.9 CON1600.206 ; CON1700.201 85.63,55.66 86.23,55.06 v2(86.67,55.06) 87.2,55.06 87.63,55.48 CON1700.209 ; v2(34.54,55.68) 34.63,55.77 CON1700.5 ; CON1600.176 79.38,78.73 ; 53.63,67.86 53.62,67.86 ; CON1600.64 49.38,78.65 ; CON1600.234 93.88,78.57 ; CON1600.181 80.63,67.99 ; CON1700.30 40.88,66.65 ; CON1700.78 52.88,66.48 v2(52.97,66.57) ; CON1700.172 78.38,66.58 ; CON1700.36 42.38,66.41 v2(42.52,66.56) ; CON1700.89 55.63,56.07 55.98,55.72 ; 56.63,55.56 CON1700.93 ; C1839.2 57.88,66.81 CON1700.98 ; 84.31,67.72 84.62,68.03 84.63,68.03 CON1600.197 ; CON1600.65 49.62,67.81 ; v2(40.01,66.57) 39.88,66.44 CON1700.26 ; v2(81.64,55.01) 81.99,55.01 82.63,55.64 CON1700.189 ; U2401.3 177.33,23.25 176.9,22.82 v2(176.9,21.7) ; 86.88,66.49 CON1700.206 ; CON1700.210 87.88,66.5 ; U8002.28 35.87,172.6 36.12,172.86 v2(36.12,173.12) ; v2(88.82,78.63) 88.88,78.58 CON1600.214 ; CON1600.89 55.63,67.86 ; v2(46.28,55.64) 46.13,55.79 CON1700.51 ; CON1600.23 39.13,68.02 ; CON1700.9 35.63,55.5 ; 56.63,67.93 v2(56.71,67.84) ; CON1600.22 38.88,78.77 ; CON1700.205 86.63,55.71 v2(86.67,55.67) ; v2(91.87,78.63) 91.88,78.62 CON1600.226 ; U3102.24 141.63,23.87 v2(141.58,23.92) ; CON1600.39 43.13,67.96 ; CON1600.175 79.13,67.7 v2(79.27,67.55) ; CON1700.227 92.13,55.82 v2(91.88,55.57) ; CON1700.86 54.88,66.47 ; CON1700.222 90.88,63.89 v2(90.63,63.64) 90.3,63.64 89.88,64.06 CON1700.218 ; v2(40.01,67.84) 40.13,67.96 CON1600.27 ; U6200.11 181.52,26.98 180.92,26.37 v2(180.92,25.77) ; 84.38,78.76 83.74,79.39 v2(82.98,79.39) ; v2(96.38,58.75) 96.13,58.5 CON1700.243 ; CON1600.99 58.13,67.77 ; CON1700.2 33.88,66.44 34,66.56 v2(34.6,66.56) 34.88,66.28 CON1700.6 ; CON1700.197 84.63,56.09 v2(84.1,55.56) 83.63,56.04 CON1700.193 ; 98.13,67.99 CON1600.251 ; v2(82.6,67.2) 83.24,67.2 83.63,67.59 ; CON1600.244 96.38,78.71 ; 95.77,132.98 C7596.2 95.77,133.75 95.62,133.9 v6(95.3,133.9) ; CON1700.85 54.63,55.88 v2(54.46,55.72) ; CON1700.94 56.88,66.41 v2(56.71,66.57) ; CON1600.18 37.88,78.48 ; v2(46.32,172.34) 46.19,172.48 U8001.28 ; CON1600.1 33.63,67.66 ; CON1600.189 82.63,67.86 ; 53.85,66.59 53.88,66.56 CON1700.82 ; CON1700.188 82.38,66.59 ; CON1700.48 45.38,66.6 ; 34.63,67.84 CON1600.5 ; CON1700.231 93.13,55.69 ; 92.88,78.64 92.25,79.26 v2(91.87,79.26) 91.36,79.26 90.88,78.77 ; v2(60.18,67.86) 60.18,67.89 60.13,67.94 CON1600.107 ; CON1700.69 50.63,55.99 v2(50.98,55.64) ; CON1600.192 83.38,78.69 83.37,78.69 ; CON1700.202 85.88,66.64 ; 46.13,68.06 CON1600.51 ; v2(53.9,78.75) 53.88,78.73 CON1600.82 ; 41.13,55.84 CON1700.31 ; 91.13,68.05 CON1600.223 ; CON1600.93 56.63,67.9 ; 48.62,68.05 CON1600.61 ; CON1700.234 93.88,66.52 ; CON1700.10 35.88,66.88 C1837.2 ; CON1600.248 97.38,78.48 v2(97.53,78.63) ; CON1700.175 79.13,55.67 ; 53.8,55.64 53.63,55.81 CON1700.81 ; v2(50.34,78.63) 50.38,78.6 ; 89.64,55.08 v2(89.46,55.08) 89.1,55.08 88.63,55.56 CON1700.213 ; CON1600.231 93.13,67.79 ; v2(92,66.56) 91.88,66.44 CON1700.226 ; 47.38,78.52 CON1600.56 ; v2(98.63,66.54) 98.48,66.54 98.38,66.43 CON1700.252 ; CON1600.35 42.13,67.98 42.27,67.83 v2(42.52,67.83) ; CON1600.103 59.13,67.83 ; 58.88,78.73 59.32,79.17 v2(59.56,79.17) ; U8004.28 24.31,169.3 v2(24.56,169.05) ; v6(119.33,179.47) 118.92,179.06 R7612.1 ; 45.38,78.77 44.9,79.24 v2(44.37,79.24) 43.97,79.24 43.38,78.65 ; U6200.25 186.07,24.34 185.57,24.83 v2(185.57,25.82) 185.57,26.33 186.07,26.83 U6200.4 ; 58.04,55.59 58.13,55.68 CON1700.99 ; v2(98.21,58.66) 98.13,58.57 CON1700.251 ; CON1600.243 96.13,68.08 96.34,67.86 ; U0703.3 114.8,53.7 114.53,53.97 R0751.2 ; 50.63,67.89 50.6,67.86 ; CON1700.47 45.13,55.79 v2(45.2,55.71) ; 97.16,66.45 97.38,66.23 CON1700.248 ; CON1600.86 54.88,78.9 ; CON1600.57 47.62,67.98 ; CON1600.238 94.88,78.58 v2(94.92,78.63) ; v2(33.93,55.69) 33.63,56 CON1700.1 ; v2(216.57,87.11) Q8106.4 ; 85.88,78.38 CON1600.202 ; CON1600.98 57.88,79.2 ; v2(94.92,79.26) 94.54,79.26 93.88,78.6 ; CON1700.56 47.38,66.34 ; 52.88,78.72 CON1600.78 ; 77.57,67.68 77.13,68.13 CON1600.167 ; CON1700.18 37.88,66.36 37.67,66.56 v2(37.52,66.56) 37.13,66.56 36.88,66.31 CON1700.14 ; v2(91.13,55.66) CON1700.223 ; CON1600.44 44.38,78.63 v2(44.37,78.63) ; 79.38,78.76 79.38,79.47 ; CON1600.30 40.88,78.6 v2(40.69,78.79) ; CON1700.52 46.38,66.43 ; CON1600.102 58.88,78.7 ; CON1600.47 45.13,67.92 ; CON1700.60 48.38,66.31 v2(48.13,66.55) ; 87.88,78.67 CON1600.210 ; 83.63,67.56 CON1600.193 ; 98.38,78.62 CON1600.252 ; v2(34.6,67.83) 34.63,67.86 ; CON1600.43 44.13,67.94 ; 49.63,67.84 49.63,67.83 ; 48.38,79.2 47.68,79.9 v2(47.3,79.9) ; CON1700.107 60.13,55.43 60.27,55.29 ; CON1600.6 34.88,78.42 ; CON1600.168 77.38,78.22 77.88,78.72 ; CON1700.230 92.88,66.73 ; 80.8,66.72 80.38,66.3 CON1700.180 ; 45.38,78.74 CON1600.48 ; CON1700.184 81.38,66.56 ; CON1600.85 54.63,67.84 ; CON1600.81 53.63,67.84 ; CON1700.217 89.63,55.61 ; 92.88,78.61 CON1600.230 ; U5102.3 v2(26.61,32.69) ; 39.88,78.98 CON1600.26 ; 51.38,78.86 CON1600.72 ; v2(95.39,58.57) 95.13,58.31 CON1700.239 95.13,55.34 ; CON1700.65 49.63,55.52 ; CON1700.19 38.13,55.79 ; 94.88,66.58 CON1700.238 ; CON1700.43 44.13,55.76 v2(44.25,55.64) ; 84.38,78.73 CON1600.196 ; CON1600.213 v2(88.63,67.83) ; CON1700.244 96.38,66.65 ; CON1700.61 48.63,55.71 v2(48.69,55.64) ; v2(92,67.83) 92.13,67.96 CON1600.227 ; CON1700.40 43.38,66.53 ; 48.38,79.17 CON1600.60 ; CON1700.168 77.38,66.59 ; CON1600.2 33.88,78.52 ; CON1700.39 43.13,55.65 ; 52.63,55.59 CON1700.77 ; CON1600.217 89.63,68 ; 51.38,66.57 CON1700.72 ; v6(149.25,160.26) 149.25,160.55 149.58,160.88 C7733.2 ; CON1600.40 43.38,78.62 ; 44.38,66.62 CON1700.44 ; CON1600.171 78.13,67.58 ; 50.38,78.57 CON1600.68 ; 38.13,67.89 CON1600.19 ; CON1700.73 51.63,55.43 ; 82.37,78.38 CON1600.188 ; 89.88,78.59 89.21,79.26 v2(88.82,79.26) 88.44,79.26 87.88,78.7 ; CON1700.35 42.13,55.63 ; CON1700.214 88.88,66.56 ; CON1700.90 55.88,66.53 ; CON1700.64 49.38,66.57 ; 35.63,67.95 CON1600.9
  TOP w0.356: Q9200.1 v2(139.2,50.32) ; Q9200.4 140.26,49.02 139.6,48.37 v2(139.19,48.37) ; 0.81,68.29 1.83,68.29 2.07,68.53 Q3601.4 ; v2(215.79,46.31) 215.81,46.33 Q1302.4 ; U8702.17 120.63,72.22 U8702.3 120.63,74.49 120.9,74.76 v2(121.7,74.76) ; v2(145.29,49.07) 145.21,48.99 144.56,48.99 144.4,49.15 U9201.3 ; U3102.10 138.38,26.89 138.63,26.64 v2(138.63,26.23) ; v2(183.08,31.51) 183.08,31.26 182.6,30.77 C6202.2 ; v2(158.42,28.69) 158.42,28.8 158.74,29.11 158.74,29.29 C5173.2 ; U5000.5 v2(175.74,74.08) ; U9200.3 131.74,49.02 v2(131.51,49.25)
  TOP w0.381: 170.68,21.56 U5103.6 168.61,21.56 ; v2(136.31,59.98) 136.56,59.73 C8303.2 ; R2143.2 165.91,32.78 v2(165.79,32.65) ; v6(126.52,179.47) 126.27,179.72 126.27,179.75 125.93,180.09 C7632.2 ; C3020.2 113.67,48.53 113.67,49.02 113.82,49.18 ; v2(179.41,89.47) 179.79,89.09 C8912.2 ; 113.82,49.18 113.93,49.18 C3024.2 ; 113.82,49.18 v2(113.82,49.18) ; R0718.2 21.41,137.05 v6(20.75,137.05) ; v2(114.99,55.59) 114.53,55.14 R0751.2 ; v6(20.87,139.41) 20.87,139.76 R0703.2 ; C9116.2 C9117.2 196.22,63.46 v2(196.52,63.77) ; v2(249.35,101.44) 249.02,101.44 248.34,100.75 R4609.2 ; R9103.2 155.63,43.4 v2(155.6,43.37) ; v6(20.88,134.53) 21.23,134.89 21.23,135.43 21.44,135.63 R1010.1 ; v2(256.59,70.75) U5502.3 253.98,70.75 v2(253.88,70.86) ; C7710.2 153.9,176.95 v6(153.9,177) ; C4636.1 v2(250.93,110.2) ; C2625.2 182.46,51.53 v2(181.96,52.03) 181.45,51.53 C2624.2 ; R1004.2 26.42,142.31 v6(26.67,142.56) ; 170.68,24.1 U5103.8 168.61,24.1 ; C1006.1 58.27,145.18 v6(58.64,145.55) 58.64,145.85 58.42,146.06 C1003.1 ; R7911.1 124.31,105.04 v6(124,105.35) 124.59,105.93 C7903.2 ; v6(129.9,177.61) 130.33,177.18 R7616.2 ; R0307.2 62.87,145.56 63.27,145.15 v6(63.3,145.15) ; R1713.2 R1712.2 108.77,56.17 109.01,55.92 v2(109.01,55.92) ; v6(95.5,150.3) 95.73,150.53 C75021.2 C75017.2 ; v2(180.4,80.15) 180.24,80.31 R8903.2 ; U8700.28 150.24,82.74 R8716.2 ; R1005.1 24.46,142.69 24.51,142.74 v6(24.51,142.95) 24.51,143.62 R0702.2 ; R1009.2 22.92,137.94 v6(23.21,138.23) ; R3114.2 158.14,29.28 157.79,28.92 v2(157.79,28.67) ; v2(179.25,80.79) 179.43,80.96 C8904.2 ; R0723.2 21.97,142.69 22.49,142.17 v6(23.22,142.17) ; v2(117.53,49.08) R3064.1 ; v2(242.2,99.32) 242.2,99.32 R4626.2 ; C8747.2 120.4,76.51 v2(120,76.91) ; v2(135.94,65.67) 135.94,66.44 136.22,66.72 R8303.2 ; U7002.3 98.75,113.69 98.77,113.72 v2(98.98,113.93) ; R1128.2 230.24,45.69 v2(229.92,45.37) ; v2(170.41,40.28) 170.41,40.79 170.33,40.86 C2604.2 ; C7804.2 142.9,146.95 142.85,146.9 v6(142.85,146.68) ; 168.61,22.83 U5103.7 170.68,22.83 ; v2(174.6,40.23) 174.6,40.92 C2602.2 ; v6(149.98,180.18) 149.83,180.33 C7707.2 ; v6(123.96,107.67) 124.38,107.67 C7905.2 ; C9504.2 117.78,63.77 117.78,63.73 117.98,63.53 118.27,63.53 v2(118.42,63.39) ; 170.68,20.29 U5103.5 168.61,20.29 ; v6(23.86,136.66) 23.86,136.82 23.62,137.06 R0713.2 ; v2(237.88,111.68) 237.79,111.68 237.16,111.04 R4602.2 ; R2149.2 178.74,66.39 178.49,66.13 v2(178.49,65.27) ; C8003.1 v2(3.96,174.89) ; R1014.2 19.66,146.63 v6(20.03,146.26) 20.03,146.05 R0701.2 ; 184.53,19.27 C6203.2 ; 181.23,19.19 C6204.2 ; R0305.2 65.04,145.22 65.07,145.22 65.15,145.14 66.35,145.14 66.65,145.43 v2(66.65,145.68) ; v2(27.37,45.55) 26.79,45.55 C5174.2 ; R4624.2 v2(245.42,99.41) ; C6205.2 187.05,19.27 ; U0702.3 110.4,54.26 110.85,54.72 v2(110.85,54.98) ; C1002.2 29.44,132.63 ; v2(15.29,79.82) 15.29,79.55 15.71,79.14 C3646.1
  TOP w0.406: C7624.2 v6(110.33,180.56) C7609.2 ; R7119.1 v6(126.37,119) ; v6(150.14,174.14) 149.64,174.64 R7714.2 ; C7592.2 97.33,136.16 v6(97.84,136.67) ; v2(133.83,123.92) 133.67,124.08 R7117.1 ; C3025.2 131.04,43.53 v2(131.57,44.06) ; v6(154.79,169.82) 155.17,169.44 C7715.2 ; C7708.2 150.77,173.9 v6(150.77,173.8) ; C7833.2 149.1,121.12 v6(149.12,121.1) ; v2(122.86,49.05) 123.01,48.9 C3009.2 ; R7918.2 138.51,107.69 138.56,107.64 v6(139,107.64) ; C6200.2 187.1,30.8 187.4,31.11 v2(187.4,31.46) ; v6(152.84,163.43) 152.91,163.37 C7730.2 ; R7611.1 v6(116.28,178.25) ; C7727.2 153.33,158.64 v6(153.24,158.74) ; v2(16.01,176.83) 16.27,176.57 R8089.2 ; v6(112.15,129.31) 112.37,129.09 112.86,129.09 C7105.2 ; v6(149.24,146.66) 149.35,146.77 C7818.2 ; v6(109.82,128.74) 110.42,128.74 C7212.2 ; v2(118.42,49.05) R3062.1 ; v6(123.62,99.02) 123.9,98.74 C7935.2 ; R0724.2 20.13,140.48 v6(20.24,140.59) ; C7731.2 155.17,167.88 v2(154.81,167.53) ; v6(116.79,104.49) 117.27,104.97 C7930.2 ; C7591.2 96.44,136.54 v6(96.32,136.67) ; C7634.2 117.74,180.99 118.29,180.44 v6(118.29,180.43) ; v2(128.78,37.71) 129.14,38.07 C3001.2 ; v6(122.15,99.02) 122.43,98.74 C7922.2 ; C7810.2 140.21,152.87 v6(140.46,153.13) ; v2(130.89,98.82) 130.18,98.82 C7904.2 ; v6(120.68,104.49) 121.13,104.94 R7919.2 ; v6(149.23,149.87) 149.48,149.62 C7811.2 ; R7716.2 145.69,156.07 v6(146.02,156.4) ; R4803.2 v2(251.36,79.36) ; C7926.2 117.85,101.06 v6(117.65,101.26) ; v2(148.79,44.87) 148.82,44.87 149.16,45.22 Q9101.1 ; R0726.2 20.27,143.4 20.27,143.4 v6(20.32,143.4) ; R7711.1 149.52,168.36 v2(150.14,168.36) ; C8743.2 v2(128.04,97.2) ; C7912.2 127.97,98.9 127.56,99.3 v6(127.56,99.46) ; C7617.2 115.22,172.2 v6(115.21,172.2) ; C7835.2 153.76,127.65 v6(153.26,128.15) ; v6(144.2,128.28) 144.17,128.31 C7914.2 ; C7605.1 116.41,175.94 v6(116,175.53) ; v6(153.21,146.77) 153.39,146.95 C7816.2 ; R7818.2 149.02,154.8 v2(149.1,154.88) 149.38,154.6 C7813.2 ; v6(122.43,110.91) 122.38,110.86 C7925.2 ; v6(122.68,179.19) 122.83,179.03 C7612.2 ; v2(216.81,48.18) 217.11,48.48 Q1302.1 ; v2(107.52,36.33) 107.51,36.33 107.51,36.35 108.34,36.35 C3003.2 ; v6(134.57,108.57) 134.49,108.5 133.76,108.5 C7913.2 ; v6(135.36,99.2) 135.71,98.85 C7908.2 ; C7909.2 139.16,101.95 v2(138.66,101.95) ; C7927.2 v6(113.39,106) ; C7712.2 151.5,169.76 v6(151.48,169.78) 151.48,169.82 150.78,170.53 R7713.1 ; C3022.2 120.98,49.02 v2(120.96,49.05) ; R2427.2 R2426.2 v2(189.92,49.16) 189.92,48.78 189.54,48.4 R2424.1 ; C7725.2 151.5,167.82 v6(151.71,167.6) ; C7923.2 113.87,105.19 113.51,105.19 v6(113.48,105.22) ; C7610.2 v2(117.02,182.91) ; R7712.1 146.27,167.01 v6(146,166.74) ; C7825.2 v6(153.98,121.93) ; v6(146.57,169.7) 146.57,169.52 146.85,169.25 C7705.2 ; v2(120.07,49.04) 120.07,48.68 119.96,48.58 C3011.2 ; C3015.1 122,49.02 v2(121.97,49.05) ; C7806.2 142.07,153.51 142.01,153.46 v6(142.01,153.12) ; v6(148.11,123.98) 148.11,123.6 R7819.2 ; R4604.2 v2(246.3,99.41) ; v6(116.21,179.87) 115.47,179.87 C7623.2 ; v6(122.66,178.37) 122.3,178.73 R7619.2 ; R7618.2 103.07,178.91 v2(103.05,178.93) ; C2617.2 183.19,56.23 182.91,56.5 v2(182.52,56.5) 182.42,56.5 182.32,56.4 C2616.2 ; v6(124.03,102.09) 124.51,101.61 C7917.2 ; v6(152.84,160.47) 152.84,160.56 153.01,160.72 C7734.2 ; R7814.2 146.81,147.13 v6(147.09,146.85) ; C3023.2 126.16,49.33 v2(126.09,49.41) ; C7929.2 142.02,142.56 v6(142.07,142.61) ; C7832.2 v6(149.1,124.09) ; v6(115.24,175.48) R7613.1 ; C7911.2 134.24,98.9 v6(133.93,99.2) ; v6(145.75,169.71) 145.98,169.49 C7711.2 ; v6(118.26,176.07) 118.13,175.94 C7603.2 ; v6(123.96,107.67) 123.88,107.58 R7912.1 ; Q9102.1 146.39,40.62 v2(146.15,40.86) ; v6(147.68,127.4) 147.22,127.85 C7831.2 ; v6(120.65,101.23) 120.55,101.13 C7931.2 ; v6(127.05,105.77) 127.42,106.14 C7918.2 ; v6(153.39,149.9) C7812.2 ; R7913.1 124.66,103.04 v6(124,103.7) ; C7934.2 v2(120.65,98.77) ; v2(185.84,74.34) 185.29,74.89 C5006.2 ; U5500.3 v2(258.71,46.32) ; C7907.2 132.69,98.9 v6(133.02,99.23) ; R0712.2 19.89,142.25 20.22,141.92 v6(20.22,141.62) 20.22,141.59 19.99,141.37 R0714.2 ; v2(189.55,55.87) 188.89,56.53 C2202.2 ; C8744.2 v2(130.3,97.2) ; R1202.1 v2(252.15,50.26) ; R7719.2 C7724.2 149.38,163.36 v6(149.23,163.51) ; v2(131.29,37.38) 131.14,37.23 R3066.1 ; C7726.2 150.85,156.4 v6(150.84,156.41) ; R1307.2 v2(207.92,56.2) ; R2349.1 v2(187.25,50.05) ; C8916.2 144.38,121.14 v6(144.5,121.02) ; v2(136.86,64.18) 137.13,64.45 137.13,64.97 137.39,65.22 C8310.2 ; C7830.2 147.43,144.17 v6(147.65,144.39) ; C7713.2 v6(155.42,174) ; C7616.2 v2(117.02,181.89) ; Q9103.1 v2(142.36,34.33)
  TOP w0.432: C1205.2 244.12,45.64 243.75,45.27 C1203.2 ; R3030.2 R3029.2 ; C8322.2 C8319.2 ; R1401.2 210.03,34.97 210.52,35.46 v2(210.52,35.8) ; v6(93.1,150.3) 93.07,150.34 93.07,150.99 ; R8911.1 174.75,84.42 v2(174.88,84.29) ; v2(17.6,128.24) 17.58,128.24 16.94,128.87 R0509.2 ; R8740.1 118.03,74.08 118.12,74.17 118.13,74.17 118.88,74.92 119.05,74.92 119.33,75.2 v2(119.33,75.59) ; v2(233.22,96.85) 233.1,96.97 C3317.2 ; R2142.2 169.47,40.53 169.72,40.28 v2(170.41,40.28) ; C7221.2 92.51,131.95 ; v6(120.93,135.96) 121.26,136.29 C7503.2 ; C8321.2 140.31,59.27 139.88,59.7 139.88,60.56 v2(139.71,60.72) ; C3002.2 v2(131.32,41.04) ; C5000.1 169.6,78.83 v3(169.37,79.06) ; C9132.2 v2(235.69,59.83) ; R3148.2 R3146.2 R3144.2 R3140.1 R3142.2 ; 92.18,150.99 92.18,150.44 ; R5206.2 v2(246.05,58.18) ; v2(208.05,32.63) 207.57,33.11 C1414.1 208.47,33.62 C1411.2 ; C0703.1 C0702.2 113.93,50.28 v2(114.83,49.38) ; v2(150.38,35.24) 150.38,37.1 150.47,37.2 R9107.2 ; C2630.2 192.58,44.85 v2(192.58,43.96) ; v2(180.4,89.14) 180.63,88.92 C8915.2 ; C8116.1 215.95,81.17 216.46,81.68 217.09,81.68 v2(217.27,81.5) 217.27,81.17 217.07,80.96 R8107.1 ; C8131.2 v2(236.98,64.86) ; v2(235.41,64.56) 235.56,64.41 C9130.2 ; v2(0.77,179.18) 0.93,179.34 C8008.2 ; C0505.1 13.59,127.62 v2(13.59,128.03) 12.79,128.03 12.34,127.59 C0504.1 ; R1411.2 v2(213.67,32.88) ; C1224.2 251.77,50.89 v2(252.15,50.89) ; R8308.2 v2(139.1,60.72) ; v2(252.15,51.53) 251.74,51.93 R1204.1 ; C4400.2 70.2,28.27 70.07,28.4 v2(70.07,28.89) ; v2(136.15,49.17) 136.02,49.3 C9200.2 ; v2(220.14,69.61) 219.33,69.61 C8100.2 ; R1222.2 229.28,55.16 v2(229.18,55.06) ; v2(171.5,68.59) 171.25,68.34 R2700.2 ; R8000.2 C8002.2 5.67,178.2 v2(5.45,178.41) ; C1842.2 v2(109.37,59.7) ; C3400.2 v2(239.35,147.28) ; R7312.1 v2(87.55,128.67) ; R2163.2 R1301.2 ; v2(212.73,45.61) 212.77,45.66 R1416.2 ; v2(155.48,46.78) 155.43,46.83 C9104.2 ; v2(66.83,67.19) 66.74,67.19 66.73,67.2 C1823.2 ; v2(206.88,42.36) 206.5,41.98 R1404.2 ; v2(248.36,45.06) 248.08,45.34 C1207.2 ; v2(229.26,56.98) 229.26,56.99 R1239.1 ; C4806.2 257.33,80.55 v2(257.48,80.39) ; v2(212.27,32.56) 212.27,32.53 212.27,32.52 C1413.2 212.01,34.01 211.8,34.01 211.32,34.5 R1406.2 ; C8130.2 v2(236.09,64.84) ; R1211.1 v2(236.02,45.69) ; v2(196.53,70.78) 196.26,71.06 C9114.2 ; R1417.2 v2(214.68,32.91) ; R0511.2 v2(11.3,130.08) ; C2623.2 v2(191.36,51.66) ; R2701.2 v2(169.52,68.59) ; C9126.2 v2(236.5,63.9)
  TOP w0.457: v2(222.58,89.3) 222.58,89.7 C3308.1 ; C2400.2 v2(181.92,63.4) ; v2(257.2,79.78) 256.55,79.78 C4809.2 ; R0709.2 17.17,142.48 17.17,142.37 v2(17.63,141.92) 17.21,141.92 16.97,141.67 R0710.2 ; R2148.2 v2(157.79,35.32) ; C7619.2 128.5,170 128.5,170.3 v6(128.12,170.68) ; v2(212.78,47.03) 212.95,47.21 R2163.2 ; R3048.1 116.07,24.85 115.96,24.74 115.96,24.73 115.71,24.48 v2(115.71,24.21) ; R7212.1 94.11,133.88 v6(94.13,133.9) ; v2(4.47,177.43) 4.47,176.77 R8033.1 ; C5803.2 v2(252.56,132.57) ; R7008.2 96.24,141.44 v6(96.3,141.5) ; C9503.2 121.02,58.39 v2(121.08,58.32) ; R2112.2 v2(168.71,35.32) ; C7827.2 150.5,116.6 v6(150.44,116.65) ; C2610.2 v2(182.8,63.4) R2476.2 ; v6(142.84,117.77) 142.88,117.73 C7826.2 ; C7920.2 135.08,107.88 134.57,108.38 v6(134.57,108.57) ; SR8707.1 157.15,81.12 157.8,81.77 v2(157.8,81.84) ; v6(20.96,150.71) C80124.2 C80125.2 ; R8302.2 133.24,65.79 v2(133.24,66.02) ; C80025.1 24.82,171.08 24.44,171.46 v2(23.39,171.46) ; R2110.2 R2111.2 169.37,33.01 v2(169.37,32.65) ; R2477.2 v2(184.07,71.26) ; C7208.2 80.57,150.82 80.18,150.42 v2(79.67,150.42) ; v2(182.02,58.99) 181.58,58.99 C2629.2 ; v2(116.61,164.75) 116.26,164.39 R7102.1 ; v6(126.5,174.65) 126.64,174.5 C7615.2 ; v2(23.28,75.52) 23.17,75.4 C3626.2 ; v2(83.11,126.66) 84.03,126.66 U7401.4 84.91,126.38 85.42,126.89 C7400.2 ; C9127.2 240.36,61.08 v2(240.38,61.1) ; C2622.2 182.29,47.36 v2(182.18,47.25) ; v2(185.24,63.85) 185.22,63.85 184.96,63.59 R2475.2 ; v2(240.31,86.67) 240.31,87.06 C5301.2 ; R8103.2 214.83,78.81 214.38,78.35 v2(214.25,78.35) ; C3618.2 R3607.2 ; C7613.2 104.61,173.11 v6(104.67,173.17) ; v2(214.4,46.98) 214.39,46.98 214.68,47.27 R1321.2 ; R6118.2 v2(163.12,32.65) ; R2262.2 181.99,54.21 v2(182.04,54.26) ; C4810.2 v2(255.35,75.53) ; C5005.2 30.33,112.66 ; R1309.2 v2(208.33,47.21) ; C7823.2 v6(152.15,116.65) ; R0725.2 16.89,144.69 v2(17.07,144.87) ; C7824.2 v2(148.84,116.65) ; C5802.2 v2(252.78,123.26) ; v2(207.65,59.67) 207.65,59.47 C1302.2 ; v2(7.14,183.48) 7.14,182.78 7.53,182.39 C80107.2 ; v2(139.12,62.63) 138.66,62.63 C8322.2 ; v2(214.21,58.38) 214.4,58.57 R1315.2 ; C9129.2 v2(240.34,61.99) ; v2(148.77,48.51) 148.77,48.48 149.07,48.18 C9102.2 ; R2257.2 v2(159.56,35.32) ; R2000.2 v2(170.38,68.62) ; v2(219.76,34.38) 219.81,34.33 R8817.1 ; v2(178.24,37.43) 178.32,37.36 C2308.2 ; SR8910.1 175.82,91.11 v2(175.82,91.16) ; C3319.2 224.11,95.47 v2(223.62,95.47) ; C3700.2 195.96,30.84 C3701.2 ; v6(97.84,136.67) 97.54,136.97 C7229.2 ; v2(181.65,40.95) 181.31,40.95 181.03,41.24 C2603.2 ; v2(222.22,79.77) 222.56,79.77 223.44,78.88 R8108.2 ; v6(150.83,124.97) 150.83,124.43 C7834.2 ; R2459.2 184.71,59.2 184.46,59.45 v2(184.46,60.33) 185.01,60.33 185.17,60.17 C2200.2 ; R8109.2 C8118.2 213.92,77.36 214.25,77.03 v2(214.25,76.52) ; v6(130.52,108.59) 130.8,108.31 131.07,108.31 R7914.2 ; C5801.2 v2(253.04,130.57) ; CON1201.6 v2(264.49,24.8) ; R8802.1 v2(246.48,14.44) ; R1012.1 22.46,148.57 v6(22.56,148.46) ; v2(87.68,125.11) R7313.2 ; C8117.2 v2(217.81,78.76) ; v6(89.59,122.7) 89.84,122.44 R7214.2 ; R2478.2 C2402.2 189.15,61.94 189.77,62.56 v2(189.77,64.21) ; U8000.53 12.24,178.96 C8000.2 ; C80082.1 12.8,165.55 13.01,165.75 v2(13.01,166.26) ; R8102.2 222.43,78.98 v2(222.25,79.16) ; C8115.2 v2(220.78,81.8) ; v2(175.53,66.06) 175.31,66.06 174.8,66.57 R2458.2 ; CON1201.5 v2(264.72,27.3) ; R2481.2 188.7,44.49 188.95,44.24 v2(189.42,44.24) ; R0510.2 10.93,123.71 10.6,124.05 v2(10.6,124.07) ; v2(179.38,37.35) R2347.1 ; R8106.1 v2(219.76,81.8)
  TOP w0.508: v2(249.03,46.99) 249,46.96 R1235.2 ; C8905.2 159.18,96.61 159.56,96.99 ; v2(24.18,69.56) 24.18,69.17 24.62,68.74 C3629.2 ; CON4800.20 265.23,102.85 ; CON4800.20 263.8,103.69 ; CON4800.20 262.36,102.85 ; C9612.2 v2(83.74,176.29) ; v6(150.14,167.68) 149.72,167.26 C7703.2 ; Q5102.2 159.82,28.2 v2(159.82,28.67) ; v2(193.09,39.18) 189.03,39.18 ; R1226.1 v2(236.02,46.7) ; v2(229.93,39.92) 230.41,39.44 R1129.2 ; 265.76,53.05 CON5500.13 267.5,53.79 ; v2(223.57,53.29) 223.56,53.29 223.3,53.03 C1129.2 ; Q3108.2 143.1,37.72 143,37.62 v3(143,37.57) ; R7816.2 v2(148.06,116.65) ; C2611.2 188.52,69.94 187.63,70.83 v2(187.63,71.26) ; v2(265.2,80.97) 265.2,81.48 ; v2(236.37,59.71) 236.74,59.71 C9131.2 ; C8746.2 123.37,76.68 v2(123.37,76.88) ; C7919.2 124.13,100.34 v6(123.98,100.5) ; v2(234.77,95.77) 234.76,95.77 234.39,95.39 C3324.2 ; C1131.2 247.54,25.75 v2(247.53,25.76) ; v2(267.01,83.79) 267.01,83.23 ; v2(239.95,97.88) 239.4,97.33 Y3300.2 ; v2(236.4,63.14) U9103.15 ; v2(261.32,83.81) 261.32,83.23 ; v2(7.93,126.2) 8.07,126.35 R0503.2 ; C5002.2 123.85,53.15 124.46,53.76 v2(124.46,54.21) ; C3701.2 196.36,30.08 v2(195.92,29.63) ; v2(24.13,34.97) 24.67,34.97 C5171.2 ; C7227.2 v6(91.62,131.84) ; v2(80.19,119.47) 80.95,120.23 R7314.2 ; v6(130.53,111.8) 130.69,111.64 C7921.2 ; R3029.2 v2(120.73,24.22) ; v2(259.31,80.97) 259.31,81.6 ; C1301.1 217.87,50.94 218.24,50.58 v2(218.24,50.51) ; 260.9,50.94 CON5500.11 ; CON5500.11 260.9,52.26 ; CON5500.11 259.54,51.6 ; v2(146.08,32.87) 146.08,33.34 R9108.2 ; C1303.2 v2(209.79,60.19) ; C2612.2 187.25,70.15 187.02,70.38 187.02,70.98 v2(186.74,71.26) ; C7837.2 156.55,119.33 v2(156.85,119.04) ; v2(168.22,47.97) 168.5,48.25 C2609.2 ; C8070.1 71.1,169.68 v2(71.1,171.48) ; v2(243.38,83.41) 242.8,83.99 C5302.2 ; C1412.2 208.01,45.49 v2(208.18,45.32) ; Q3110.2 139.4,37.72 139.29,37.62 v3(139.29,37.57) ; Q3602.2 0.84,67.05 0.81,67.02 ; C1130.2 251.69,25.44 v2(252.02,25.11) ; U5501.2 247.94,61.36 v2(247.87,61.43) ; JP5601.2 v2(31.07,182.53) ; R1147.2 240.02,43.53 240.01,43.52 v2(239.9,43.52) ; v6(94.02,129.1) 93.58,129.54 C7223.2 92.51,129.54 v6(92.06,129.1) ; 260.9,65.54 CON5501.10 ; R1011.1 21.89,133.53 v6(20.88,134.53) ; C8821.2 226.36,25.75 v2(226.11,26) ; C8727.2 150,79.61 U8700.26 ; CON4500.44 52.61,177.15 ; CON4500.44 54.8,178.62 ; CON4500.44 57.23,177.15 ; CON4500.44 54.8,175.83 ; R9604.1 91.11,178.78 v2(91.49,178.4) ; CON4500.43 66.2,178.47 ; CON4500.43 64.46,177.15 ; CON4500.43 66.2,175.83 ; CON4500.43 68.33,177.15 ; C9602.2 v2(89.71,167.87) ; C0503.1 10.62,126 v2(10.83,125.78) ; R4630.2 257.09,89.33 256.34,89.33 v2(256.29,89.28) ; v2(6.65,75.86) 6.65,75.85 6.27,75.47 Q6701.2 ; CON4601.21 259.18,125.15 ; CON4601.21 260.44,125.91 ; CON4601.21 260.44,124.39 ; v2(267.92,83.79) 267.92,83.3 ; CON4500.42 47.23,179.2 ; CON4500.42 48.25,181.21 ; CON4500.42 48.25,176.87 ; CON4601.23 269.28,127.3 ; C3318.2 231.7,97.12 232.53,97.96 v2(232.53,98) ; R1125.2 v2(240.08,42.64) ; C3325.2 v2(234.11,97.88) ; C1016.2 58.25,126.98 v6(57.87,127.36) ; v2(200.58,33.62) 200.58,32.84 200.76,32.66 C3101.2 ; v2(242.62,44.67) 242.62,44.79 242.37,45.04 C1206.2 ; v2(20.12,80.1) 20.12,80.36 21.02,81.26 R3607.2 ; v2(132.26,174.59) 132.63,174.97 Q7600.2 ; R7901.1 117.65,100.16 v6(117.73,100.24) ; v2(260.4,83.81) 260.4,83.23 ; CON4500.41 72.75,181.3 ; CON4500.41 73.8,179.2 ; CON4500.41 72.75,177.08 ; 31.19,85.2 CON1600.263 ; CON1600.263 35.21,85.2 ; CON1600.263 33.2,82.65 ; CON1600.263 33.2,87.75 ; v2(243.49,62.84) 243.85,62.84 244.08,62.61 R5501.1 ; 32.78,129.82 C1014.2 32.25,129.13 ; C7600.2 125.45,181.22 v6(125.63,181.04) ; C3100.2 197.35,25.62 v2(197.42,25.69) ; CON4301.21 v2(88.32,181.45) ; v2(220.2,35.11) 220.64,35.11 221.09,35.56 Q8805.2 ; 189,38.47 v2(193.09,38.47) ; C3647.1 10.01,73.34 10.21,73.13 10.91,73.13 v2(11.1,73.32) ; v6(111.91,174.57) 111.78,174.7 R7614.2 ; 267.63,102.85 CON4800.22 269,103.69 ; v2(238.29,48.17) 238.73,48.17 238.94,48.38 ; v2(233.2,92.66) 233.2,92.65 C3316.2 ; v2(86.17,169.35) 84.47,169.35 C9608.2 ; 265.76,64.75 CON5501.12 267.5,64.01 ; v2(236.84,79.98) 236.5,79.64 Q5302.2 ; v2(242.57,55.69) 242.85,55.69 243.18,56.02 R1229.2 ; v2(89.71,29.19) 89.2,28.68 89.2,28.29 ; v2(244.02,44.54) 243.64,44.92 C1203.2 ; v6(24.51,144.53) 24.59,144.45 R1002.1 ; v2(231.95,42) 231.62,42 R1119.2 ; v2(210,47.13) 210.11,47.24 R1305.2 ; v2(265.96,83.79) 265.96,83.36 ; R1233.2 R1234.2 250.27,46.32 v2(250.63,45.97) ; v3(137.41,37.72) Q3111.2 ; v2(234.84,92.87) 234.36,93.35 C3315.2 ; C7219.2 90.48,131.66 v6(90.65,131.84) ; Q5301.2 236.5,82.75 v2(237.16,83.41) ; v2(264.01,83.79) 264.01,83.25 ; v2(264.16,80.97) 264.16,81.5 ; C9611.2 87.99,169.51 v2(87.6,169.13) ; C8827.2 217.98,38.38 v2(217.74,38.62) ; C8402.2 174.37,22.09 v2(174.37,21.7) ; Y3300.4 235.93,95.13 v2(235.89,95.09) ; R5210.2 233.6,57.62 v2(233.59,57.61) ; v2(233.99,43.02) 234.11,43.15 234.91,43.15 R1139.2 ; Q4805.2 v2(254.11,93.88) ; C1223.2 252.25,49.37 v2(252.71,49.83) ; 260.44,109.51 CON4601.22 260.44,107.99 ; v2(241.22,113.76) C4613.1 ; R4608.1 v2(251.71,113.93) ; R3142.2 146.53,31.75 v2(146.74,31.96) ; R5200.2 258.16,58.77 258.23,58.84 v2(258.23,58.87) ; 259.11,127.86 v2(258.39,127.86) ; C7900.2 118.42,99.73 v6(118.42,100.29) ; Q7201.2 245.22,96.81 245.9,96.13 v2(245.9,96) ; C3616.2 v2(25.84,70.03) ; C3711.2 199.95,28.22 v2(199.86,28.14) ; C5600.2 v2(40.13,184.93) ; C1221.2 235.67,45.81 235.79,45.69 v2(236.02,45.69) ; C2403.2 175.36,19.31 ; v2(173.44,71.26) 173.48,71.23 C2620.2 ; v6(93.9,123.08) 93.27,122.44 R7213.2 ; C1208.2 235.89,47.46 v2(236.02,47.59) C1204.2 ; v2(261.26,80.97) 261.26,81.5 ; v2(138.3,33.16) 138.3,33.04 137.85,32.59 137.85,31.79 136.57,30.51 Q3109.2 ; v6(27.36,134.23) 27.36,133.96 27.04,133.64 C1001.2 ; C9134.2 198.17,83.12 ; 261.68,121.95 CON4601.2 261.04,122.58 ; v2(205.18,48.15) 205.31,48.27 C1304.2 ; C1219.2 v2(244.07,56.02) ; CON4601.8 261.68,118.95 ; v2(251.13,47.21) R1236.2 ; 124.1,26.43 124.1,26.43 124.03,26.51 C3004.2 ; R7601.1 v6(125.17,182.11) ; v2(185.05,31.91) 185.05,31.91 185.22,31.74 C6201.2 ; v2(171.39,71.26) 171.32,71.2 C2621.2 ; R1218.1 238.43,45.69 v2(238.38,45.64) ; C1708.2 C1707.1 108.16,51.84 v2(107.5,51.17) ; C8033.1 13.59,178.55 13,179.15 U8000.53 ; C6206.2 v2(181.78,31.73) ; C9133.2 196.52,83.15 ; Q7900.2 v2(137.57,116.61) ; v2(174.65,87.37) 174.69,87.33 174.71,87.33 C8910.2 ; C2619.2 172.91,63.42 172.71,63.22 v2(172.68,63.22) ; v2(102.67,184.09) 102.67,183.25 101.32,181.91 101.32,181.45 CON4301.22 ; v2(264.92,83.79) 264.92,83.33 ; v2(195.66,39.26) 195.38,39.54 U3101.4 ; CON4601.24 269.28,106.6 ; C5172.2 154.99,19.14 ; R5201.2 v2(258.23,59.66) ; C4637.2 v2(239.98,100.13) ; v2(268.96,83.79) 268.96,83.28 ; 260.9,79.66 CON5501.11 260.9,78.34 ; U1103.4 228.14,47.07 v2(228.12,47.1) ; CON4601.16 261.68,114.95 ; v2(260.22,80.97) 260.22,81.5 ; R2490.2 45.01,25.49 ; C4638.2 v2(256.92,111.17) ; v6(109.72,183.07) C7604.2 ; R1126.2 v2(252.65,36.29) ; X1101.2 v2(248.89,25.11) ; v2(262.36,83.81) 262.36,83.2 ; v2(252.78,22.45) 252.69,22.53 X1101.4
  IN1 w0.457: CON1201.B1 267.82,29.35
  IN1 w0.508: 264.69,29.9 CON1201.3 ; CON1201.3 265.91,29.9 ; CON1201.3 265.3,30.68 ; CON1201.3 265.3,29.11 ; CON5501.13 267.5,81.19 ; CON5501.13 269.24,80.45 ; CON5501.13 265.76,80.45 ; 267.5,63.71 CON5501.12 265.46,64.75 ; 266.76,106.6 CON4601.24 ; CON4601.24 269.28,106.6 ; CON4601.24 268.02,105.84 ; CON4601.24 268.02,107.36 ; 267.5,53.79 CON5500.13 265.76,53.05 ; 270.61,31.24 CON1201.9 270.61,29.86 ; CON5101.P5 22.38,21.74 ; CON5101.P5 21.62,22.5 ; CON5101.P5 22.38,23.26 ; CON5101.P5 23.14,22.5 ; 260,45.92 CON5500.7 ; CON5500.7 260.72,45.2 ; CON5500.7 260,44.48 ; 260.9,78.31 CON5501.11 ; CON5501.11 259.52,79 ; CON5501.11 260.9,79.69 ; CON1201.4 265.3,22.99 ; CON1201.4 264.69,22.2 ; CON1201.4 265.3,21.42 ; CON1201.4 265.91,22.2 ; 259.59,38.8 CON5500.10 ; CON5500.10 260.9,39.82 ; CON5500.10 260.9,38 ; 267.56,84.85 CON4800.23 269,84.01 ; 265.23,102.85 CON4800.20 ; CON4800.20 263.8,103.69 ; CON4800.20 262.36,102.85 ; 22.14,32.71 CON5101.S7 ; CON5101.S7 20.62,32.71 ; CON5101.S7 21.38,31.95 ; 267.84,22.7 CON1201.B12 267.16,23.94 ; CON5501.10 259.52,66.2 ; CON5501.10 260.9,66.89 ; CON5501.10 260.9,65.51 ; CON4800.21 263.8,84.01 CON4800.21 ; CON4800.21 262.43,84.85 ; CON4800.21 265.17,84.85 ; 22.14,36.52 CON5101.S4 20.62,36.52 ; 267.56,102.85 CON4800.22 269,103.69 ; 265.46,37.35 CON5500.12 267.5,36.31 ; CON1201.10 270.61,22.24 ; CON1201.10 269.43,21.55 ; CON1201.10 270.61,20.86 ; 259.18,125.15 CON4601.21 ; CON4601.21 260.44,125.91 ; CON4601.21 260.44,124.39 ; 268.02,126.54 CON4601.23 ; CON4601.23 266.76,127.3 ; CON4601.23 268.02,128.06 ; CON4601.23 269.28,127.3 ; 268.1,21.22 CON1201.8 268.1,22.44 ; CON5501.7 260,73.4 ; CON5501.7 260.8,72.6 ; CON5501.7 259.2,72.6 ; CON5501.7 260,71.8 ; 260.44,107.99 CON4601.22 ; CON4601.22 259.18,108.75 ; CON4601.22 260.44,109.51 ; 22.14,21.5 CON5101.P6 ; CON5101.P6 21.38,22.26 ; CON5101.P6 20.62,21.5 ; CON4601.16 261.71,114.95 ; 261.71,121.95 CON4601.2 261.04,122.62 ; 260.9,52.4 CON5500.11 260.9,50.33 ; 20.62,40.33 CON5101.S1 ; 268.1,30.88 CON1201.7 268.1,29.66 ; 267.11,28.36 CON1201.B1 ; CON4601.8 261.71,118.95
  IN2 w0.508: CON1201.B12 267.97,22.75 ; CON5501.13 267.5,81.49 ; CON5501.13 269.54,80.45 ; CON5501.13 265.46,80.45 ; 265.3,30.76 CON1201.3 264.61,29.9 ; CON1201.10 270.61,22.24 ; CON1201.10 269.43,21.55 ; CON1201.10 270.61,20.86 ; CON4800.23 269,84.01 CON4800.23 ; CON4800.23 267.63,84.85 ; 260.9,38.11 CON5500.10 259.52,38.8 ; CON1201.8 268.1,22.52 ; CON1201.8 269.08,21.83 ; CON1201.8 268.1,21.14 ; CON4800.22 269,103.69 CON4800.22 ; CON4800.22 267.63,102.85 ; 260.9,65.4 CON5501.10 ; CON4601.23 269.28,127.3 ; CON4601.23 268.02,126.54 ; CON4601.23 268.02,128.06 ; CON4601.23 266.76,127.3 ; CON4601.16 261.71,114.95 ; CON4800.2 262.63,98.79 ; CON5501.7 259.2,72.6 ; CON5501.7 260.8,72.6 ; CON5501.7 260,71.8 ; CON5501.7 260,73.4 ; 265.76,53.05 CON5500.13 267.5,53.79 ; 262.43,102.85 CON4800.20 ; CON4800.20 263.8,103.69 CON4800.20 ; CON4800.20 265.17,102.85 ; 20.62,36.52 CON5101.S4 ; CON4601.8 261.71,118.95 ; 268.02,107.34 CON4601.24 ; CON4601.24 268.02,105.86 ; CON4601.24 269.35,106.6 ; CON4601.24 266.69,106.6 ; 261.04,122.62 CON4601.2 261.71,121.95 ; 22.14,21.5 CON5101.P6 ; CON5101.P6 21.38,20.74 ; CON5101.P6 21.38,22.26 ; CON5101.P6 20.62,21.5 ; 260.44,124.39 CON4601.21 ; CON4601.21 260.44,125.91 ; CON4601.21 259.18,125.15 ; CON4601.22 259.18,108.75 ; CON4601.22 260.44,107.99 ; CON4601.22 260.44,109.51 ; CON1201.7 268.1,30.96 ; CON1201.7 269.08,30.27 ; CON1201.7 268.1,29.58 ; CON5101.P5 23.14,22.5 ; CON5101.P5 22.38,21.74 ; CON5101.P5 22.38,23.26 ; CON5101.P5 21.62,22.5 ; CON5500.11 260.9,52.29 ; CON5500.11 260.9,50.91 ; CON5500.11 259.52,51.6 ; 20.62,40.33 CON5101.S1 ; 265.17,84.85 CON4800.21 ; CON4800.21 263.8,84.01 ; CON4800.21 262.43,84.85 ; 265.46,64.75 CON5501.12 267.5,63.71 ; 265.76,37.35 CON5500.12 267.5,36.61 ; 267.97,29.33 CON1201.B1 ; 20.62,32.71 CON5101.S7 22.14,32.71 ; 260.9,78.31 CON5501.11 ; CON5501.11 259.52,79 ; CON5501.11 260.9,79.69 ; CON1201.9 270.61,31.24 ; CON1201.9 270.61,29.86 ; CON1201.9 269.43,30.55
  IN3 w0.102: 59.11,144.36 59.49,144.36 ; 152.98,179.01 153.39,179.01 ; 59.78,147.52 60.13,147.52 ; v6(145.16,180.15) 145.53,179.78 145.53,179.04 v6(145.94,178.63) ; 152.93,178.22 153.37,178.22 ; 58.82,149.63 58.82,149.21
  IN3 w0.254: 177.95,84.32 U8900.23
  IN3 w0.508: 267.87,22.75 CON1201.B12 267.03,23.77 ; CON4601.24 268.02,105.84 ; CON4601.24 268.02,107.36 ; CON4601.24 266.76,106.6 ; CON4601.24 269.28,106.6 ; CON5501.7 259.2,72.6 ; CON5501.7 260,73.4 ; CON5501.7 260,71.8 ; CON5501.7 260.8,72.6 ; CON1201.9 270.61,31.24 ; CON1201.9 270.61,29.86 ; CON1201.9 269.43,30.55 ; CON5101.P5 23.14,22.5 ; CON5101.P5 22.38,21.74 ; CON5101.P5 22.38,23.26 ; CON5101.P5 21.62,22.5 ; CON5101.S1 21.38,41.09 ; CON5101.S1 20.62,40.33 ; CON5101.S1 22.14,40.33 ; 260.44,124.39 CON4601.21 ; CON4601.21 260.44,125.91 ; CON4601.21 259.18,125.15 ; 268.1,29.58 CON1201.7 ; CON1201.7 269.08,30.27 ; CON1201.7 268.1,30.96 ; 260.37,121.95 CON4601.2 ; CON4601.2 261.04,122.62 ; CON4601.2 261.71,121.95 ; 265.17,84.85 CON4800.21 ; CON4800.21 262.43,84.85 ; CON4800.21 263.8,84.01 CON4800.21 ; CON1201.3 265.3,30.76 ; CON1201.3 264.61,29.9 ; CON1201.3 265.3,29.03 ; CON4601.23 269.28,127.3 ; CON4601.23 266.76,127.3 ; CON4601.23 268.02,128.06 ; CON4601.23 268.02,126.54 ; 262.36,102.85 CON4800.20 ; CON4800.20 265.23,102.85 ; CON4800.20 263.8,103.69 ; 265.46,53.05 CON5500.13 267.5,54.09 ; 269,103.69 CON4800.22 267.56,102.85 ; 260.9,52.4 CON5500.11 ; CON5500.11 260.9,50.8 ; CON5500.11 259.54,51.6 ; 265.76,64.75 CON5501.12 267.5,64.01 ; 268.1,21.14 CON1201.8 ; CON1201.8 269.08,21.83 ; CON1201.8 268.1,22.52 ; 20.62,21.5 CON5101.P6 ; CON5101.P6 22.14,21.5 ; CON5101.P6 21.38,22.26 ; CON5101.P6 21.38,20.74 ; 267.92,29.28 CON1201.B1 267.06,28.34 ; 258.87,120.45 CON4601.5 260.21,120.45 ; 20.62,36.52 CON5101.S4 22.14,36.52 ; 261.71,114.95 CON4601.16 260.37,114.95 ; 261.71,118.95 CON4601.8 260.37,118.95 ; 265.76,37.35 CON5500.12 267.5,36.61 ; 260.9,65.4 CON5501.10 ; CON5101.S7 22.14,32.71 ; CON5101.S7 20.62,32.71 ; CON5101.S7 21.38,31.95 ; CON1201.10 270.61,22.24 ; CON1201.10 269.43,21.55 ; CON1201.10 270.61,20.86 ; 260.44,107.99 CON4601.22 ; CON4601.22 260.44,109.51 ; CON4601.22 259.18,108.75 ; 265.3,21.34 CON1201.4 ; CON1201.4 264.61,22.2 ; CON1201.4 265.3,23.07 ; CON4800.2 262.63,98.54 ; 260.9,38.11 CON5500.10 ; 265.46,80.45 CON5501.13 ; CON5501.13 267.5,81.49 ; CON5501.13 269.54,80.45 ; 267.63,84.85 CON4800.23 269,84.01 ; CON5501.11 259.52,79 ; CON5501.11 260.9,79.69 ; CON5501.11 260.9,78.31 ; 260.21,117.45 CON4601.11 258.87,117.45
  IN4 w0.102: v6(145.94,178.63) 145.52,179.05 144.82,179.05 v6(144.38,178.62) ; v6(152.34,178.64) 152.75,178.22 153.62,178.22 v6(153.98,178.58) ; 126.15,137.89 125.89,138.16 v6(125.89,138.27) 126.33,138.71 128.35,138.71 v6(128.42,138.64) 128.42,138.44 127.75,137.77 127.19,137.77 127.07,137.89 126.15,137.89
  IN4 w0.381: CON5501.4 261.5,76.87 ; CON5501.4 260.73,76.1 ; CON5501.4 261.5,75.33 ; 260.73,48.7 CON5500.4 ; CON5500.4 261.5,47.93 ; CON5500.4 261.5,49.47
  IN4 w0.508: 22.38,21.74 CON5101.P5 ; CON5101.P5 21.62,22.5 ; CON5101.P5 22.38,23.26 ; CON5101.P5 23.14,22.5 ; 258.87,117.45 CON4601.11 260.21,117.45 ; CON5101.S7 21.38,31.95 ; CON5101.S7 22.14,32.71 ; CON5101.S7 20.62,32.71 ; 259.52,51.6 CON5500.11 ; CON5500.11 260.9,52.29 ; CON5500.11 260.9,50.91 ; CON4601.23 268.02,128.06 ; CON4601.23 268.02,126.54 ; CON4601.23 269.28,127.3 ; CON4601.23 266.76,127.3 ; CON5101.P6 22.14,21.5 ; CON5101.P6 20.62,21.5 ; CON5101.P6 21.38,20.74 ; CON5101.P6 21.38,22.26 ; CON5501.13 265.76,80.45 ; CON5501.13 269.24,80.45 ; CON5501.13 267.5,81.19 ; 266.76,106.6 CON4601.24 ; CON4601.24 268.02,107.36 ; CON4601.24 269.28,106.6 ; CON4601.24 268.02,105.84 ; CON1201.4 265.3,22.99 ; CON1201.4 264.69,22.2 ; CON1201.4 265.3,21.42 ; CON1201.4 265.91,22.2 ; 267.84,22.7 CON1201.B12 267.16,23.92 ; CON4601.19 258.87,113.45 ; CON4601.19 260.21,113.45 ; CON4601.19 259.54,112.78 ; 261.71,114.95 CON4601.16 260.37,114.95 ; 22.14,40.33 CON5101.S1 ; CON5101.S1 21.38,41.09 ; CON5101.S1 20.62,40.33 ; 268.1,21.22 CON1201.8 ; CON1201.8 269,21.83 ; CON1201.8 268.1,22.44 ; 260.44,124.39 CON4601.21 ; CON4601.21 260.44,125.91 ; CON4601.21 259.18,125.15 ; 269,84.01 CON4800.23 267.63,84.85 ; CON5501.7 259.2,72.6 ; CON5501.7 260,73.4 ; CON5501.7 260.8,72.6 ; CON5501.7 260,71.8 ; CON5501.11 260.9,79.8 ; CON5501.11 260.9,78.2 ; CON5501.11 259.54,79 ; 263.8,84.01 CON4800.21 ; CON4800.21 262.43,84.85 ; CON4800.21 265.17,84.85 ; 260.9,38.11 CON5500.10 ; CON5500.10 259.52,38.8 ; CON5500.10 260.9,39.49 ; 259.18,108.75 CON4601.22 ; CON4601.22 260.44,107.99 ; CON4601.22 260.44,109.51 ; 259.2,45.2 CON5500.7 ; CON5500.7 260,46 ; CON5500.7 260.8,45.2 ; CON5500.7 260,44.4 ; 265.76,53.05 CON5500.13 267.5,53.79 ; 268,29.33 CON1201.B1 267.06,28.39 ; 267.63,102.85 CON4800.22 ; CON4800.22 269,103.69 CON4800.22 ; 265.76,37.35 CON5500.12 267.5,36.61 ; 269.51,30.86 CON1201.9 ; CON1201.9 270.61,29.86 ; CON1201.9 270.61,31.24 ; CON4800.20 262.43,102.85 ; CON4800.20 263.8,103.69 CON4800.20 ; CON4800.20 265.17,102.85 ; 261.71,121.95 CON4601.2 ; CON4601.2 260.37,121.95 ; CON4601.2 261.04,122.62 ; 260.21,120.45 CON4601.5 258.87,120.45 ; 268.1,29.66 CON1201.7 268.1,30.88 ; 265.46,64.75 CON5501.12 267.5,63.71 ; 22.14,36.52 CON5101.S4 20.62,36.52 ; 265.3,29.11 CON1201.3 ; CON1201.3 265.91,29.9 ; CON1201.3 265.3,30.68 ; CON1201.3 264.69,29.9 ; 269.51,21.55 CON1201.10 ; CON1201.10 270.61,20.86 ; CON1201.10 270.61,22.24 ; CON5501.10 259.54,66.2 ; CON5501.10 260.9,65.4 ; CON5501.10 260.9,67 ; CON4800.2 262.63,98.54 ; 260.37,118.95 CON4601.8 261.71,118.95
  BOTTOM w0.102: U7000.B22 U7000.D22
  BOTTOM w0.127: v2(158.45,61.51) 158.85,61.1 158.85,60.77 159.5,60.12 160.03,60.12
  BOTTOM w0.152: v6(60.5,152.24) 61,152.24 61.26,151.97 61.26,151.44 U0300.C37 ; 61.64,128.22 U0300.A6 ; U2000.A37 159.87,45.04 U2000.B37 U2000.C37 ; v2(157.79,54.24) 158.21,53.81 159.14,53.81 159.56,54.24 U2000.A18 ; U7000.G48 U7000.G46
  BOTTOM w0.178: U2000.A32 159.45,47.42 v2(159.32,47.55) ; U2000.BB21 179.45,53.18 178.9,53.73 U2000.AW19 ; v2(181.96,52.03) 181.87,51.95 U2000.BE23 ; U2000.BB30 179.48,48.64 179.09,48.24 178.28,48.24 U2000.AV31 ; U0300.BM35 23.81,150.03 22.61,150.03
  BOTTOM w0.203: v2(179.72,40.54) 179.49,40.54 179.07,40.96 U2000.AY45 ; v2(177.58,63.49) 177.46,63.38 U2000.AU1 ; U0300.L34 55.74,149.11 v6(56.07,148.78) 55.75,148.46 U0300.L33 ; U2000.BE9 181.43,58.8 181.83,58.8 v2(182.02,58.99) ; U7901.R11 129.71,102.15 v6(129.67,102.15) 129.67,102.15 129.29,101.77 U7901.R12 ; U2000.BE40 181.99,43.5 182.17,43.32 v2(182.17,43.07) ; U0300.J36 57.5,150.16 57.64,150.16 U0300.H35 58.05,149.76 58.37,150.09 v6(58.43,150.09) 58.5,150.09 U0300.F36 58.9,150.41 v6(59.22,150.74) 59.22,151.61 U0300.E38 ; v6(61.24,145.55) 60.92,145.87 U0300.C29 60.92,146.08 U0300.D30 ; U2000.AU45 177.45,40.79 177.92,40.32 v2(177.92,40.09) ; U7801.E12 143.63,144.33 143.09,144.33 143.07,144.31 142.9,144.31 v6(142.85,144.36) ; U7901.N3 136.3,103.17 136.3,102.91 136.11,102.73 136.11,102.15 U7901.R3 ; U2000.P45 166.06,40.72 165.79,40.46 v2(165.79,40.45) ; v6(25.36,148.13) 25.68,147.81 U0300.BJ32 ; U0300.J33 57.31,148.46 v6(57.64,148.13) ; v6(61.24,139.25) 60.92,139.57 U0300.C21 60.52,140.04 60.52,140.18 U0300.D22 ; v6(62.85,132.57) 62.84,132.55 U0300.A12 ; U0300.F31 58.89,147.51 58.6,147.81 U0300.H32 57.72,148.13 v6(57.64,148.13) ; v6(55.48,145.27) 55.67,145.47 U0300.L29 U0300.L30 ; v6(63.13,130.93) 63.08,130.98 U0300.A10 ; v2(182.16,44.94) 181.99,45.11 U2000.BE37 ; v6(63.02,140.58) 62.87,140.43 U0300.A22 ; v6(97.08,121.43) 97.51,121.86 97.51,122.69 U7000.AY2 ; U0300.A28 v6(63.3,145.15) ; U0300.BT32 20.78,148.01 20.78,148.01 20.71,148.01 20.5,148.22 v6(20.5,148.23) ; U2000.BE18 182,54.22 v2(182.04,54.26) ; v6(57.64,148.13) 57.46,147.95 57.45,147.95 57.32,147.81 U0300.J32 ; v2(97.05,182.47) 97.21,182.31 97.21,181.96 97.45,181.71 U4301.21 ; U7700.U12 141.26,165.95 v6(142.8,165.95) 143.63,165.95 U7700.N12 ; U7000.E46 125.1,157.49 v6(124.28,157.49) ; U0300.BN19 23.54,137.9 v6(23.21,138.23) 23.21,138.3 U0300.BN20 ; v6(127.36,181.04) 127.32,181.01 127.32,180.28 127.73,179.87 U7600.E3 ; v6(61.24,147.12) 60.92,147.45 U0300.C31 60.52,147.91 60.52,148.05 U0300.D33 59.93,148.63 59.93,148.77 U0300.E34 59.77,149.24 59.77,149.61 U0300.E35 ; U2000.AW19 178.62,53.73 178.1,53.21 v2(178.1,53.19) ; U2000.AM45 174.6,40.6 v2(174.6,40.23) ; U7000.AB45 112.3,157.49 113.05,157.49 v6(113.06,157.48) ; U7800.K13 146.86,126.55 v6(146.86,125.74) ; v2(168.17,40.32) 168.33,40.49 U2000.V45 ; v6(24.51,142.95) 24.19,143.28 U0300.BM26 ; v6(61.24,143.97) 60.92,144.3 U0300.C27 60.52,144.76 60.52,144.9 U0300.D28 ; v6(62.85,138.91) 62.79,138.85 U0300.A20 ; v6(20.75,137.05) 20.75,137.02 20.78,137.05 U0300.BT18 U0300.BR18 ; U2000.AH1 172.89,63.01 v2(172.68,63.22) ; v2(171.76,43.22) 171.84,43.14 U2000.AE42 ; U7800.U12 140.46,126.55 140.46,127.39 U7800.U14 ; U2000.AC45 170.61,40.69 170.41,40.49 v2(170.41,40.28) ; 59.23,138.3 59.41,138.47 59.88,138.47 U0300.D20 ; U0300.A24 v6(62.85,142) ; U7000.C49 126.7,159.89 v6(125.9,159.89) ; U7600.C1 129.33,181.5 128.93,181.9 v6(128.93,182.67) ; U0300.BT35 21.13,149.58 21.01,149.71 v6(21.01,150.09) ; U2000.BE28 181.9,49.68 v2(182.09,49.48) ; U7000.AL45 U7000.AL46 ; U7000.BJ3 v6(89.59,123.5) ; U7000.AE46 109.5,158.05 109.18,158.37 109.18,158.73 109.5,159.05 U7000.AE48 ; v2(258.63,27.89) 257.86,27.89 257.72,28.03 U1207.3 ; v2(182.18,47.25) 182.03,47.4 U2000.BE32 ; U0300.A18 v6(62.85,137.28) ; U7900.R14 124.27,111.32 123.99,111.59 123.99,112.53 U7900.U14 ; U7801.H2 U7801.H1 ; U0300.A30 v6(62.88,146.93) ; U0300.A26 v6(62.85,143.58) ; v2(172.88,40.24) U2000.AH45
  BOTTOM w0.229: v2(182.52,56.5) U2000.BE14
  BOTTOM w0.254: U7801.A3 140.74,151.85 140.55,151.85 140.51,151.81 v6(140.3,151.81) ; 144.38,178.6 143.97,179 U7701.C3 ; 144.38,178.6 144.36,178.6 U7701.C4 ; 144.38,178.6 v6(144.38,178.62) ; U2402.3 193.61,65.8 193.48,65.68 192.79,65.68 v2(192.46,66.01) ; v2(39.55,181.32) 39.55,181.03 40.51,180.07 40.51,179.21 39.75,178.45 CON5602.21 ; v6(142.77,177.06) 142.77,177.08 142.77,177.07 142.84,177.07 U7701.B5 ; v6(104.67,170.27) U7601.A1 ; U7900.N14 124.38,109.67 v6(124.71,109.33) ; C2306.2 183.36,33.03 v2(183.36,32.61) ; U7900.C4 116.02,101.36 v6(115.98,101.36) 115.93,101.36 U7900.C3 ; U7701.G10 147.55,173.02 v6(147.58,173.02) ; C2503.2 v2(152.15,64.41) ; C2503.2 152.15,63.21 ; C2503.2 151.68,63.72 ; C8016.1 16.31,185.94 ; CON4601.19 260.19,113.45 ; CON4601.19 258.89,113.45 ; CON4601.19 259.54,112.8 ; C2204.2 189.15,46.24 v2(189.28,46.37) ; v2(7.77,183.46) 7.77,182.46 C80108.2 ; CON6700.7 10.37,64.75 10.47,64.66 v2(10.72,64.66) ; U7701.E14 145.57,169.9 v6(145.75,169.71) ; U7000.AE39 109.5,152.06 v6(109.09,151.66) ; v6(153.22,180.2) 153.23,180.2 153.49,180.47 153.49,180.53 U7701.R1 ; C80104.1 v2(0.76,182.51) ; v2(55.73,58.54) 55.88,58.39 CON1701.98 ; v6(154.79,169.82) U7701.U14 ; U2000.AC1 170.49,62.91 v2(170.49,63.26) ; v2(35.23,174.89) 34.85,174.51 C8069.1 ; 260.19,117.45 CON4601.11 258.89,117.45 ; v6(144.35,172.2) 143.97,172.58 U7701.C11 ; v6(141.81,171.8) U7701.A12 ; U7000.BA13 96.3,131.9 v6(96.3,131.93) 95.9,131.53 U7000.BB13 ; v2(187.25,50.05) 187.25,49.62 187.45,49.42 R2413.2 R2460.1 ; U0300.D20 60.92,138.2 U0300.C19 ; U0300.BL35 24.73,149.76 24.61,149.65 U0300.BM35 ; U2000.AV17 177.8,54.91 177.42,55.29 177.39,55.29 v2(177.19,55.49) 177.24,55.53 U2000.AT15 ; 4.24,185.82 R8087.2 ; v4(240.61,39.3) 240.59,39.28 C1185.2 ; C8013.2 20.88,177.83 v2(20.98,177.93) ; v6(145.16,180.15) 145.48,180.47 145.48,180.52 U7701.E1 ; D1204.2 262.18,24.93 v2(262.69,24.93) ; 38.93,66.45 39.13,66.26 CON1701.31 ; U2000.BB11 179.69,57.48 v2(179.03,57.48) 179.03,57.46 U2000.AW13 ; CON1701.244 94.38,55.88 ; U2000.AK42 174.11,43.16 v2(174.15,43.2) ; U7701.R3 153.57,178.98 v6(153.98,178.58) 153.6,178.2 U7701.R4 ; v6(62.94,149.47) 62.86,149.55 U0300.A34 ; v2(9.07,61.1) 9.03,61.1 8.85,61.28 8.85,61.53 9.07,61.75 CON6700.1 ; 40.05,31.65 CON5100.14 ; v2(0.79,176.95) 1.62,176.95 C8005.2 ; R2001.1 169.56,68.56 v2(169.52,68.59) 168.98,68.59 168.73,68.34 R2526.1 ; v6(152.37,172.2) 151.98,171.8 U7701.N12 ; 260.39,121.95 CON4601.2 ; CON4601.2 261.04,122.6 ; CON4601.2 261.69,121.95 ; v6(26.67,140.2) U0300.BJ22 26.02,140.32 25.61,140.32 U0300.BK22 ; C8014.1 15.42,185.94 ; v2(63.45,179.97) R4524.1 ; v2(243.91,86.1) 243.75,85.94 CON5300.33 ; U0300.BM25 v6(24.51,142.95) ; v2(193.19,57.65) 193.07,57.65 192.2,56.78 C2203.2 ; U8200.16 137.23,70.34 v2(136.91,70.02) ; U7000.L37 120.51,150.7 120.96,150.25 v6(121.03,150.25) ; 40.14,33.15 CON5100.11 ; 261.69,114.95 CON4601.16 260.39,114.95 ; U7701.N14 151.55,169.78 v6(151.48,169.78) ; D1203.2 262.11,23.08 v2(262.69,23.08) ; v6(23.22,142.17) 23.54,141.84 U0300.BN24 v6(23.86,141.38) ; U0300.BP26 U0300.BR26 U0300.BT26 20.93,143.35 v6(20.88,143.4) ; 10.59,76.99 10.59,76.1 10.58,76.08 10.58,75.96 10.36,75.75 CON6700.29 ; U7000.T39 116.89,152.29 v6(116.89,152.65) ; v4(239.52,35.37) 239.55,35.35 C1171.2 ; U7701.N3 152.32,178.65 152.32,178.65 v6(152.34,178.64) ; U0300.F29 58.96,145.87 v6(58.64,145.55) 58.31,145.22 U0300.G28 ; R8041.2 v2(6.53,185.94) ; 42.7,28.64 42.69,28.65 CON5100.20 39.75,28.65 ; U8005.4 70.91,171.28 v2(71.1,171.48) ; U7701.R14 153.17,170.6 v6(153.16,170.6) ; D1205.2 v2(263.54,27.2) ; 40,30.15 CON5100.17 ; 39.93,33.27 40.31,33.65 CON5100.10 ; U8200.4 v2(137.73,74.64) ; U2000.D45 161.15,40.92 v2(161.55,40.53) ; D1206.2 v2(263.64,28.87) ; v2(192.58,43.96) 192.71,43.83 R2484.1 ; U9400.4 v2(78.65,155.29) ; v4(240.17,36.02) 240.31,35.88 C1180.2 ; 39.99,32.65 CON5100.12 ; v6(142.09,169.76) 142.37,170.04 U7701.A14 ; U7701.U3 155.29,178.88 155.35,178.88 v6(155.58,178.65) ; v6(145.97,172.2) 145.57,171.8 U7701.E12 ; U7000.N4 119.1,124.32 v6(118.72,124.7) 119.1,125.09 U7000.N5 ; CON3104.1 181.95,30.46 181.81,30.6 181.47,30.6 D3102.2 181.32,31.41 181.46,31.41 v2(181.78,31.73) ; 0.82,175.15 1.78,175.15 C8012.2 ; U4301.10 97.45,178 U4301.31 ; U2000.BB16 179.23,55.46 v2(179.16,55.53) ; U7701.N1 v6(151.57,180.21) ; U7701.K14 U7701.K13 ; v2(179.41,50.73) 179.41,50.73 179.6,50.91 U2000.BB25 ; U0300.BK25 U0300.BJ25 ; C1182.2 240.82,30.5 v4(240.82,29.53) ; U0300.BT14 U0300.BR14 U0300.BP14 22.89,133.96 v6(23.22,134.29) 23.42,134.09 23.42,134.02 U0300.BN14 ; 260.19,120.45 CON4601.5 258.89,120.45 ; v6(60.5,152.24) 60.5,152.23 60.12,151.85 U0300.D38 ; C8010.1 v2(12.75,185.94) ; C2309.2 182.55,35.4 v2(182.47,35.32) ; v4(241.47,36.67) 241.47,36.04 C1167.2 ; v4(240.17,32.77) 240.46,33.06 C1178.2 ; v2(92.09,185.05) 92.09,184.71 91.75,184.37 U4302.3 91.75,182.21 90.98,181.45 v2(90.98,180.18) ; R8028.2 v2(7.42,185.94) ; v6(24.51,139.02) 24.19,139.34 U0300.BM21 ; R6102.2 v2(162.23,35.32) ; R8021.1 v2(13.64,185.94) ; U7701.R12 153.58,171.8 v6(153.98,172.2) ; U2000.T42 167.13,42.79 v2(167.13,43.23) ; v6(138.63,111.37) U7901.C1 ; v6(143.58,170.59) U7701.C14 ; v6(152.43,143.58) 152.43,143.53 U7801.R14 ; 260.39,118.95 CON4601.8 261.69,118.95 ; v2(169.38,43.21) 169.56,43.03 U2000.AA42 ; U0300.AY14 33.04,133.78 v6(32.56,134.25) ; U7600.K13 U7600.K14 ; R8029.1 v2(14.53,185.94) ; U2000.AV33 177.49,47.36 v2(177.49,47.42) 177.49,47.45 U2000.AV31 ; R2425.2 v2(187.25,51.2) ; U0300.AH34 U0300.AH33 42.31,148.46 42.63,148.14 v6(42.68,148.14) ; v6(117.08,129.56) 116.7,129.93 U7000.T11 ; R8046.2 v2(5.13,185.94)
  BOTTOM w0.279: U0300.BP18 23,137.16 23.43,137.16 U0300.BN18 ; XDP4400.2 1.69,141.35 v2(1.43,141.61) ; XDP4400.14 0.82,138.35 v2(0.78,138.32) ; v2(0.76,139.84) 0.77,139.85 XDP4400.8 ; CON6700.26 10.57,74.25 10.58,74.24 v2(11.11,74.24) ; CON4402.11 200.86,26.59 200.99,26.46 201.73,26.46 201.86,26.59 CON4402.9 ; v2(8.56,65.6) 8.56,65.02 8.83,64.75 CON6700.7 ; XDP4400.26 0.85,135.35 v2(0.76,135.27) ; v2(0.78,136.79) 0.85,136.85 XDP4400.20 ; v2(0.76,129.3) 0.82,129.35 XDP4400.50 ; XDP4400.38 0.77,132.35 v2(0.76,132.35) ; CON6700.10 v2(8.65,66.25)
  BOTTOM w0.28: v6(126.7,145.5) U7000.D31
  BOTTOM w0.3: U7000.BB29 v6(96.3,143.9)
  BOTTOM w0.305: v6(33.58,145.18) 33.63,145.22 U0300.AW29 U0300.AW30 ; U7600.A14 118.93,183.21 v6(119.28,183.56) ; v6(111.51,127.9) 111.9,127.51 U7000.AB8 ; U7000.P14 118.13,132.48 v6(118.13,132.62) 117.98,132.62 U7000.R15 ; U7600.A3 v6(128.14,183.48) ; U7000.P16 118.08,134.52 v6(118.08,134.63) 117.97,134.63 U7000.R17 ; v6(99.9,123.71) U7000.AU4 ; U7801.R4 152.43,150.77 v6(152.43,150.76) ; v2(50.98,55.64) 50.88,55.74 CON1701.78 ; U7000.BH19 91.12,136.3 v6(91.49,136.67) ; U7000.W25 113.87,142.73 v6(113.87,142.64) 113.97,142.64 U7000.V24 ; CON1701.61 46.63,66.95 ; CON1701.247 95.13,66.47 ; CON1701.94 54.88,56.13 v2(54.46,55.72) 54.15,55.72 53.88,56 CON1701.90 ; U7000.BB31 95.9,145.9 v6(96.3,146.3) ; v2(56.71,67.84) 56.88,68.01 CON1601.102 ; v2(56.71,67.84) 57.04,67.84 58.13,66.76 CON1701.107 ; v2(56.71,67.84) 56.21,67.84 55.88,68.18 CON1601.98 ; U7700.M5 145.21,159.58 v6(145.21,159.58) ; U7801.H1 v6(146.44,154.07) ; U0300.F25 58.64,142.46 v6(58.64,142.4) 58.64,142.32 U0300.G24 ; U7901.T10 130.93,100.97 v6(131.34,101.39) ; CON1601.52 44.38,68.16 44.04,67.82 ; U7000.BF10 v6(92.06,129.1) ; CON1701.231 91.13,66.61 ; U7900.R4 116.33,111.27 116.33,111.2 v6(116.04,110.91) 115.68,111.27 115.63,111.27 U7900.R3 ; U7000.AD16 108.88,134.48 v6(108.88,134.59) 109,134.59 U7000.AC17 ; U7000.N42 119.23,154.57 119.23,154.03 U7000.N41 v6(118.71,153.51) ; U7701.M5 150.83,177.07 v6(150.75,177.07) 150.71,177.07 150.37,177.4 U7701.L5 ; v6(56.41,152.32) 56.46,152.28 U0300.K38 ; v6(28.51,148.79) 28.18,149.11 U0300.BF34 ; U7800.B10 152.84,123.12 v6(153.26,122.7) ; U7000.B1 127.9,121.25 127.98,121.17 v6(127.99,121.17) ; U7600.H2 U7600.H1 129.76,177.47 v6(129.9,177.61) ; CON1701.214 86.88,55.88 v2(86.67,55.67) ; U7900.E1 v6(113.47,103.32) ; R8085.2 2.15,185.07 v2(2.15,185.94) ; v6(90.48,126.69) 91.09,126.69 U7000.BH7 ; v6(52.13,148.78) 52.07,148.78 U0300.T34 ; U7901.R4 135.69,101.77 v6(135.28,101.36) 134.89,100.97 U7901.T5 ; U7000.AE2 v6(109.5,122.12) ; U0300.BN30 23.22,146.82 v6(23.22,146.89) 23.22,146.96 U0300.BN31 ; U7600.A1 129.33,183.07 v6(128.93,182.67) ; U7000.AL21 100.97,138.57 v6(100.89,138.57) 100.89,138.49 U7000.AM20 ; CON1601.184 79.38,67.65 v2(79.27,67.55) ; U0300.BP34 23.21,148.53 ; 23.21,148.53 v6(23.21,148.47) ; 23.21,148.53 U0300.BN34 ; U0300.AC37 U0300.AC38 v6(46.23,152.41) ; CON1601.99 56.13,78.51 ; v6(102.16,136.54) 102.16,136.44 U7000.AK18 U7000.AJ19 ; v2(76.43,53.97) R1717.2 ; v2(56.45,47.35) CON5102.21 ; U7600.R1 129.43,171.97 129.56,171.97 v6(129.79,172.2) ; CON1601.43 42.13,78.71 42.07,78.77 ; v6(112.01,171.53) 112.01,171.47 U7601.B10 ; 40.29,66.58 40.13,66.41 CON1701.35 ; v6(106.91,150.51) U7000.AF32 ; U7701.C11 U7701.B10 143.17,173.52 143.48,173.83 144.34,173.83 U7701.D10 ; U7800.K2 146.85,117.77 146.85,117.74 146.85,117.74 v6(146.84,117.74) 146.47,117.37 U7800.K1 ; v2(46.28,55.64) 46.38,55.74 CON1701.60 ; CON5103.71 46.7,34.85 ; CON1701.44 42.38,55.9 ; v6(130.03,179.68) 130.03,179.69 129.85,179.87 U7600.E1 ; v6(107.18,169.92) 106.96,170.15 106.94,170.15 U7601.A3 ; v6(113.48,105.22) U7900.H1 U7900.H2 ; U7000.AF20 107.01,138.61 v6(107.12,138.61) 107.12,138.72 U7000.AE21 ; v6(114.63,129.41) 114.63,129.46 114.3,129.78 U7000.W11 ; U0300.AE33 44.98,148.13 v6(45.04,148.13) ; v6(90.65,131.84) 90.6,131.84 90.94,131.5 U7000.BH13 ; U0300.T33 52.07,148.13 v6(52.13,148.13) ; U7900.C1 113.57,101.72 113.46,101.61 v6(113.46,101.61) ; U7000.AL17 101,134.6 v6(100.9,134.6) 100.9,134.5 U7000.AM16 ; CON1601.107 58.13,78.59 ; U7000.E31 125.63,146.03 126.17,146.03 U7000.D31 ; U7000.AF18 107.02,136.62 v6(107.12,136.62) 107.12,136.72 U7000.AE19 ; v2(97.28,67.81) 96.57,67.81 96.38,68 CON1601.252 ; U7901.A14 127.47,112.75 127.47,112.73 v6(127.13,112.39) ; v6(96.3,146.3) U7000.BB32 ; v6(96.3,146.3) U7000.BA31 ; U7000.AH46 106.73,158.27 v6(106.73,158.35) 107.21,158.83 107.21,159.39 U7000.AH48 ; U7000.N46 119.1,157.88 v6(118.72,157.49) 119.1,157.11 U7000.N45 ; U7701.H13 148.35,170.62 v6(148.35,170.61) 147.97,170.23 U7701.H14 ; U7800.C11 152.04,125.38 v6(151.65,125.78) 152.04,126.17 U7800.C12 ; U7700.E12 v6(150.06,165.17) ; U7000.K5 121.44,125.1 v6(121.09,124.75) ; CON1601.73 49.63,78.81 49.63,78.82 ; v6(142.07,149.96) 141.85,150.18 141.82,150.18 141.64,150.35 U7801.B5 ; U7000.AB5 v6(111.5,124.7) 111.9,124.3 U7000.AB4 ; U7000.P30 118.08,148.52 v6(118.08,148.6) ; v6(106.35,182.69) 106.64,182.98 106.72,182.98 U7601.U3 ; v6(49.77,148.13) 49.7,148.13 U0300.W33 ; U7901.A3 136.42,112.97 v6(136.09,113.3) ; v2(7.49,133.7) 7.65,133.85 XDP4400.31 ; U7900.R14 124.71,110.98 v6(124.71,110.91) ; v2(46.72,44.2) 46.87,44.35 CON5103.33 ; v6(119.33,179.47) 119.33,179.47 U7600.E14 ; U7600.M10 122.14,174.27 v6(122.58,174.72) 122.22,175.07 U7600.L10 ; U0300.G18 U0300.H18 U0300.J18 v6(56.42,137.28) ; v6(153.26,128.15) U7800.A14 154.1,127.31 154.1,126.63 153.96,126.49 153.96,126.48 U7800.A12 ; U7000.AH41 107.07,153.9 v6(106.71,154.27) 107.1,154.67 U7000.AH42 ; U7000.Y24 112.07,142.54 v6(112.07,142.64) 111.97,142.64 U7000.AA25 U7000.AB24 ; U0300.N33 54.43,148.13 v6(54.49,148.13) ; CON1701.48 v2(43.38,55.64) ; U7000.BB28 95.9,143.5 v6(96.3,143.9) U7000.BA28 ; v6(154.8,180.2) 154.8,180.24 155.16,180.6 U7701.U1 ; v6(23.86,139.8) 23.86,139.74 U0300.BN21 ; U7000.AB18 U7000.AA19 112.06,136.54 v6(112.07,136.54) 112.07,136.54 U7000.Y18 ; CON1701.85 52.63,66.23 v2(52.97,66.57) ; U0300.AN30 U0300.AN29 38.35,145.25 v6(38.28,145.18) ; U7000.AB39 112.19,152.39 v6(112.19,152.8) ; U7000.T32 U7000.R31 118.03,149.63 v6(118.08,149.63) 118.08,149.68 U7000.P32 ; CON6700.4 8.85,63.25 8.56,62.96 v2(8.56,62.78) ; U7000.T28 U7000.U29 115.11,146.71 v6(115.11,146.55) 114.95,146.55 U7000.V28 ; U7000.BF16 U7000.BE16 v6(94.13,133.9) ; U7000.AL48 104.3,159.1 104.3,159.1 v6(104.27,159.08) ; v6(138.5,109.46) 138.19,109.77 U7901.E1 ; CON1701.15 35.13,67.05 ; U7901.G10 130.89,108.22 v6(130.52,108.59) 130.52,108.6 U7901.F10 ; U7000.AE4 109.53,124.3 v6(109.92,124.69) 109.5,125.1 U7000.AE5 ; v6(58.64,135.31) 58.64,135.38 U0300.G16 ; CON4402.11 200.86,27.96 200.73,28.08 199.91,28.08 v2(199.86,28.14) ; v6(20.88,134.53) 21.51,133.9 U0300.BT14 ; v2(7.23,77.55) 7.47,77.31 8.51,77.31 8.57,77.25 CON6700.32 ; CON1601.22 36.88,68.09 37.14,67.83 v2(37.52,67.83) 37.75,67.83 37.88,67.96 CON1601.26 ; U7000.AK32 102.51,150.1 v6(102.92,150.51) ; v6(119.51,127.09) 119.51,127.09 119.11,127.5 U7000.N8 119.25,127.65 119.25,128.15 U7000.N9 ; U7901.N3 v6(136.09,103.77) ; U7600.R4 v6(127.31,171.5) 127.68,171.87 U7600.R3 ; U7000.AF28 106.51,146.1 v6(106.99,146.57) 107.5,147.09 U7000.AE29 ; v2(50.34,78.63) 50.63,78.35 CON1601.77 ; U7000.AL27 100.94,144.54 v6(100.89,144.54) 100.89,144.49 U7000.AM26 ; CON5300.45 246.75,85.53 246.75,85.7 246.43,86.02 v2(246.08,86.02) ; CON1701.27 38.13,66.41 ; U7600.H13 119.51,177.69 119.15,177.69 U7600.H14 118.91,177.45 118.41,177.45 v6(118.39,177.43) ; U7000.AJ25 U7000.AK24 102.16,142.44 v6(102.16,142.64) ; U7901.H14 127.69,107.28 v6(128.01,106.97) 128.25,107.21 128.34,107.21 U7901.H13 ; CON1701.52 44.38,55.77 v2(44.25,55.64) ; v6(144.42,126.55) 144.04,126.17 U7800.N12 ; CON1601.222 88.88,68.08 v2(88.63,67.83) ; v6(118.36,173.85) 118.55,173.85 U7600.N14 ; U7601.H13 115.21,175.48 v6(115.24,175.48) 115.61,175.85 U7601.H14 ; U7701.E3 145.57,179 v6(145.94,178.63) ; v6(102.28,122.06) 102.3,122.09 U7000.AP2 ; v6(124.89,148) 125.2,148 U7000.E34 125.63,148.43 126.18,148.43 U7000.D34 ; U7000.W27 113.87,144.73 v6(113.87,144.67) 113.93,144.67 U7000.V26 ; U7700.C3 151.99,158.34 v6(151.64,158.69) 151.64,158.73 U7700.C4 ; CON1601.31 39.13,78.67 ; U7000.AP5 U7000.AP4 102.3,123.81 v6(102.22,123.73) ; v2(37.26,78.67) 37.13,78.53 CON1601.23 ; U7000.T46 116.72,157.9 v6(117.11,157.51) 117.09,157.49 117.09,157.49 U7000.T45 ; U7801.A14 140.84,143.14 140.58,142.88 v6(140.58,142.61) ; U7000.G46 123.9,157.88 v6(124.28,157.49) ; v2(95.05,67.83) 95.38,68.16 CON1601.248 ; CON1701.192 81.38,55.93 v2(81.64,55.67) ; v6(142.01,153.12) 142.04,153.14 142.04,153.14 U7801.C1 ; U7000.J19 122.46,136.46 122.95,136.46 U7000.H19 123.31,136.5 125.3,136.5 U7000.E19 v6(125.9,135.9) U7000.D19 v6(126.69,135.91) ; v2(117.02,182.91) 116.86,183.07 U7601.U14 ; U7000.AK14 102.5,132.06 102.16,131.72 v6(102.16,131.59) ; U7000.AK14 U7000.AJ15 ; U7000.AK14 102.16,132.44 v6(102.16,132.6) ; v6(122.38,103.69) 122.75,103.32 U7900.E12 ; U7601.R4 107.61,181.53 v6(107.24,181.9) 107.24,181.9 U7601.R3 ; U7601.L5 108.41,178.35 v6(108.74,178.68) 108.41,179 U7601.M5 ; U7000.L22 120.85,139.05 v6(121.89,139.05) ; U7000.BE21 93.49,137.9 v6(93.12,138.27) ; v2(7.51,136.85) 7.51,136.85 XDP4400.19 ; U7000.G5 123.52,124.72 v6(123.5,124.72) 123.5,124.71 U7000.G4 124.01,124.19 124.01,123.32 123.9,123.21 U7000.G2 ; v6(115.11,132.6) 115.11,132.71 U7000.U15 U7000.T14 ; v6(128.43,155.4) 128.01,155.4 U7000.B43 127.61,155.8 126.67,155.8 126.37,155.5 U7000.D43 126.21,155.59 125.59,155.59 U7000.E43 ; U7000.AG23 105.01,140.6 v6(104.95,140.6) 104.95,140.55 U7000.AH22 ; U0300.AA30 U0300.AA29 48.21,145.4 v6(48.21,145.25) ; U7600.B5 126.13,182.28 v6(126.54,182.69) ; v2(30.46,175.61) 29.75,176.31 CON5602.1 ; v6(122.42,100.48) 122.78,100.12 U7900.A12 ; v6(141.64,121.1) U7800.T5 ; v2(48.69,55.64) 48.38,55.96 CON1701.68 ; U7800.H2 147.68,117.8 v6(147.68,117.77) 148.04,117.4 U7800.H1 ; U7000.AC21 108.97,138.57 v6(108.88,138.57) 108.88,138.48 U7000.AD20 ; v6(141.33,167.68) 141.33,167.65 140.84,167.17 U7700.U14 ; v6(102.16,140.6) 102.16,140.44 U7000.AK22 U7000.AJ23 ; U0300.AB34 47.34,148.78 v6(47.41,148.78) ; U7601.D10 v6(112.78,172.31) 112.78,172.31 113.21,171.87 U7601.C11 ; U7000.AH24 104.95,142.55 v6(104.95,142.64) 105.04,142.64 U7000.AG25 ; U7000.AK30 103.01,148.6 v6(103.05,148.6) 103.05,148.65 U7000.AJ31 ; CON1601.48 43.38,68.05 43.15,67.83 v2(42.52,67.83) 42.38,67.98 CON1601.44 ; U7000.D28 U7000.B28 ; CON1701.69 48.62,66.22 48.29,66.55 v2(48.13,66.55) 47.77,66.55 47.62,66.41 CON1701.65 ; v2(56.46,50.3) 56.46,49.2 56.8,48.86 57.62,48.86 CON5102.15 ; U7900.U12 v6(122.38,112.51) ; v6(115.11,144.67) 115.11,144.71 U7000.U27 U7000.T26 ; CON1601.51 44.13,78.65 44.11,78.66 ; v6(108.84,182.64) 108.64,182.44 108.58,182.44 U7601.T5 ; v6(150.08,119.33) 150.44,118.97 U7800.E3 ; v2(46.58,43.12) 46.84,42.85 CON5103.39 ; U7900.L5 117.2,108.12 v6(117.6,108.52) 117.21,108.92 U7900.M5 ; U7000.AP45 102.58,156.82 v6(102.58,156.66) ; U0300.AG30 U0300.AG29 v6(43.08,145.28) ; U7000.AD32 108.98,149.62 v6(109.02,149.62) ; U7601.K13 114.82,177.47 v6(115.21,177.87) 115.61,177.47 U7601.K14 ; v2(94.92,78.63) 95.13,78.42 CON1601.247 ; U7000.D10 126.3,129.1 v6(125.89,129.51) 125.5,129.12 U7000.E10 ; v2(82.6,67.83) 82.38,68.06 CON1601.196 ; U7000.AP46 102.31,157.9 v6(102.7,158.28) ; 51.59,78.74 51.63,78.7 CON1601.81 ; U7800.F10 149.57,124.57 v6(149.1,124.09) 148.84,124.35 U7800.G10 ; U7000.P18 118.08,136.52 v6(118.08,136.54) 118.06,136.54 U7000.R19 ; U7000.E22 125.5,138.65 v6(125.89,138.27) 126.3,138.68 U7000.D22 ; U7000.A48 129.03,159.5 129.34,159.2 v6(129.34,159.15) 129.34,159.03 129.01,158.7 U7000.A47 ; U7000.AW34 98.31,148.49 97.69,148.49 v6(97.1,147.9) U7000.BA34 ; v6(124,103.7) U7900.E14 ; v6(27.33,152.34) U0300.BG38 U0300.BG37 ; U7800.R11 U7800.R12 142.83,126.56 v6(142.85,126.56) ; CON1701.226 89.88,55.93 89.64,55.69 v2(89.46,55.69) 89.18,55.69 88.88,56 CON1701.222 ; CON5300.51 248.25,85.58 248.62,85.95 v2(249.1,85.95) ; U0300.AD30 U0300.AD29 v6(45.44,145.18) ; U7000.AH32 104.5,150.1 v6(104.91,150.51) ; v6(113.67,173.05) 114.01,173.4 U7601.E12 ; v6(108.84,171.59) 108.84,171.5 U7601.B5 ; v2(132,148.35) 132.41,148.76 R7106.1 ; v2(176.12,29) 175.67,29 175.45,29.22 CON3104.14 ; U7000.V14 114,132.6 v6(113.87,132.6) 113.87,132.73 U7000.W15 ; U7000.T16 U7000.U17 115.11,134.71 v6(115.11,134.63) ; v6(115.21,172.2) 115.4,172.02 115.47,172.02 U7601.C14 ; CON1701.57 45.63,67.01 ; U7000.C3 v6(126.7,123.1) ; U7000.C3 v6(127.51,123.1) U7000.B2 ; U7000.C3 v6(126.7,123.91) U7000.D4 U7000.E5 ; CON1701.18 35.88,55.8 ; v6(114.17,122.19) 114.17,122.39 114.3,122.52 U7000.W2 ; U7000.D37 126.3,150.7 v6(125.9,151.1) ; U7800.E1 v6(150.44,116.65) ; U7000.B13 v6(127.5,131.9) ; U7801.U14 153.9,142.9 v6(154.09,142.9) ; U7601.K2 105.98,177.43 105.25,177.43 U7601.K1 v6(104.7,177.47) ; U7000.AD28 108.54,146.1 v6(109.02,146.57) 109.5,147.06 U7000.AC29 ; CON1701.218 87.88,55.98 87.63,55.73 87.46,55.73 86.79,55.06 v2(86.67,55.06) 86.26,55.06 85.79,55.53 v2(85.79,55.59) 85.88,55.67 CON1701.210 ; CON5102.51 56.62,39.85 56.46,40.01 v2(56.46,41.4) ; v2(76.67,67.85) 76.38,68.14 CON1601.172 ; v2(7.93,126.2) 7.82,126.31 7.82,126.61 8.07,126.85 XDP4400.59 ; U7801.A1 140.67,153.37 140.67,153.33 v6(140.46,153.13) ; 61.24,136.17 v6(61.24,136.1) ; U7000.N39 119.1,151.68 118.87,151.45 v6(118.87,150.87) ; v2(78.49,78.75) 78.63,78.62 CON1601.181 ; CON5103.51 47.25,39.85 v2(46.66,39.85) ; v6(114.99,149.62) 114.98,149.62 U7000.V32 ; v6(129.87,173.7) 129.55,173.7 U7600.N1 ; U7801.E1 143.69,153.2 143.69,153.11 v6(143.67,153.09) ; v6(118.37,170.4) 118.63,170.4 118.76,170.27 U7600.U14 ; U7000.AE27 107.5,145.06 v6(107.11,144.67) 106.54,144.1 U7000.AF26 ; v6(112.95,146.57) 112.97,146.57 ; 112.97,146.57 U7000.Y28 ; 112.97,146.57 U7000.W29 ; U7000.AJ17 U7000.AK16 102.16,134.44 v6(102.16,134.63) ; U7700.H1 148.04,156.82 v6(148.38,157.16) 148.04,157.5 U7700.H2 ; CON1701.2 31.88,56.18 32.33,55.72 ; U7000.AD24 108.5,142.12 v6(108.89,142.51) 109.48,143.1 U7000.AC25 ; CON1601.231 91.13,78.26 91.49,78.63 v2(91.87,78.63) 92.13,78.38 CON1601.235 ; U0300.BB30 U0300.BB29 v6(31.27,145.28) ; U0300.BM38 v6(24.33,152.34) ; U0300.B37 61.66,151.14 U0300.A37 62.74,151.14 v6(62.86,151.02) 62.86,150.71 62.51,150.36 U0300.A36 ; U7000.H40 123.1,153.1 v6(122.7,152.7) ; v6(136.09,109.36) 136.49,109.76 U7901.E3 ; U7700.N3 144.05,158.34 v6(144.45,158.75) ; U7800.E12 v6(150.01,125.74) ; v2(235.18,83.43) 235.75,84 CON5300.1 ; U7000.AG29 104.97,146.57 v6(104.95,146.57) 104.95,146.55 U7000.AH28 ; v6(115.16,100.55) 115.58,100.12 U7900.A3 ; CON1601.171 76.13,78.35 v2(76.66,78.88) 77.13,78.41 CON1601.175 ; U7701.C12 143.95,171.8 v6(143.58,171.43) ; U0300.AB33 47.34,148.13 v6(47.41,148.13) ; U7000.AU45 99.49,156.69 v6(99.49,156.68) ; v2(46.66,41.35) 46.79,41.35 CON5103.45 ; U7900.N12 122.78,109.69 122.38,109.29 v6(122.39,109.29) ; v6(154.11,145.22) 153.65,144.75 U7801.U12 ; v6(146.84,157.95) 146.44,157.56 U7700.K2 U7700.K1 ; U7000.AL25 101,142.6 v6(100.87,142.6) 100.87,142.47 U7000.AM24 ; v6(49.28,145.25) 49.61,145.25 U0300.V29 U0300.V30 ; U7900.L10 121.18,108.12 v6(120.82,108.48) 121.18,108.84 U7900.M10 ; v6(142.85,146.68) 143.18,146.35 U7801.D10 ; v6(144.39,116.96) 144.39,116.96 144.04,117.31 U7800.N1 ; U7900.P10 120.82,110.16 v6(120.82,110.12) ; U7901.L5 134.54,104.97 v6(134.16,104.59) 134.58,104.17 U7901.M5 ; U7600.R11 121.33,171.87 v6(120.94,172.25) 120.56,171.87 U7600.R12 ; 140.07,165.53 140.07,165.54 U7700.U12 ; v6(105.1,158.37) 104.7,157.97 U7000.AL46 ; v6(52.52,145.2) U0300.R29 U0300.R30 ; v6(153.24,153.15) 153.64,153.55 U7801.U1 ; U7000.AM28 v6(101.02,146.61) U7000.AL29 ; U7000.AB41 111.87,153.9 v6(111.51,154.27) 111.9,154.66 U7000.AB42 ; v6(118.34,171.87) U7600.R14 ; U7000.AE25 107.13,142.73 v6(107.13,142.55) 106.95,142.55 U7000.AF24 ; v2(7.49,140.03) 7.67,139.85 XDP4400.7 ; 92.88,55.65 92.88,55.65 CON1701.238 ; v6(113.98,99.48) 113.98,100.12 U7900.A1 ; U7000.AF16 107.04,134.64 v6(107.12,134.64) 107.12,134.72 U7000.AE17 ; v2(56.46,41.4) 56.46,42.64 56.68,42.85 CON5102.39 ; v2(56.46,41.4) 56.62,41.4 56.67,41.35 CON5102.45 ; U7000.L31 v6(120.91,145.49) ; U7000.AC15 109,132.6 v6(108.89,132.6) 108.89,132.49 U7000.AD14 ; CON1701.22 36.88,55.64 ; v2(175.18,68.61) 175.18,68.21 175.46,67.93 R2350.2 ; U7800.A3 v6(153.24,119.37) ; CON1701.230 90.88,55.91 v2(91.13,55.66) ; v6(41.76,131.92) 41.85,131.92 U0300.AH12 ; U7000.T30 U7000.U31 115.5,148.99 v6(115.11,148.6) 115.01,148.6 U7000.V30 ; CON1601.202 83.88,67.81 ; CON1601.10 33.88,67.56 ; CON1601.94 54.88,67.72 ; v2(7.3,131.67) 7.3,131.87 7.78,132.35 XDP4400.37 ; U7000.AE31 107.48,149.1 v6(106.99,148.6) 106.5,148.12 U7000.AF30 ; U7800.B5 v6(152.84,121.08) ; v6(56.44,140.05) 56.58,140.05 U0300.J22 U0300.H22 ; U0300.BT9 21.09,130.75 v6(20.98,130.86) ; 52.61,55.96 52.65,55.96 52.88,56.18 CON1701.86 ; CON5300.57 249.75,85.64 249.75,85.79 v2(249.94,85.97) ; U7000.AE23 107.12,140.72 v6(107.12,140.65) 107.06,140.65 U7000.AF22 ; v6(120.93,135.96) 120.85,135.96 U7000.L19 ; CON1701.202 83.88,55.79 v2(84.1,55.56) 84.45,55.56 84.88,55.99 CON1701.206 ; v6(149.21,171.37) 149.21,171.36 U7701.K13 ; U7901.G5 134.89,108.25 v6(134.57,108.57) 134.89,108.9 U7901.F5 ; CON1701.89 53.63,66.33 53.38,66.57 v2(52.97,66.57) ; U0300.AJ37 U0300.AJ38 41.5,151.86 v6(40.95,152.41) ; v6(142.85,144.36) 142.85,144.36 142.84,144.35 U7801.C12 ; U7000.BE19 93.14,136.67 v6(93.09,136.67) 92.72,136.3 U7000.BF19 ; v6(104.67,173.17) 104.98,173.47 U7601.E1 ; U7901.U3 137,99.66 v6(137.52,99.66) ; CON1701.197 82.63,66.61 ; U7000.AL42 104.7,154.7 v6(105.09,154.3) 104.7,153.91 U7000.AL41 ; U7801.E14 144.04,143.14 143.66,142.76 v6(143.66,142.61) ; U7000.K45 121.5,157.12 v6(121.86,157.48) 121.86,157.54 121.5,157.9 U7000.K46 ; U7901.N12 129.65,103.73 129.65,103.73 v6(129.65,103.73) ; U7900.B5 117.31,100.92 v6(117.65,101.26) ; U7000.W5 114.34,125.1 v6(114.73,125.49) ; v6(129.74,170.64) 129.54,170.44 129.5,170.44 U7600.U1 ; CON1701.223 89.13,66.41 ; U7000.AH45 106.89,156.89 106.89,156.04 v6(106.74,155.89) ; U7601.R1 105.06,181.32 105.03,181.32 v6(104.78,181.07) ; v6(115.11,138.57) 115.11,138.71 U7000.U21 U7000.T20 ; v6(95.3,133.9) U7000.BB16 U7000.BA16 ; U7000.AB11 112.15,129.85 v6(112.15,129.31) 112.15,128.55 U7000.AB9 ; U7000.W23 113.87,140.73 v6(113.87,140.6) 114,140.6 U7000.V22 ; U7800.G5 148.84,120.83 v6(149.12,121.1) 149.64,120.58 U7800.F5 ; CON1601.214 86.88,67.78 ; CON1701.30 38.88,55.73 ; v6(143.69,118.61) 144.04,118.96 U7800.N3 ; U7000.W17 113.87,134.73 v6(113.87,134.63) 113.97,134.63 U7000.V16 ; U7800.R4 v6(142.85,119.36) 142.46,118.97 U7800.R3 ; CON1701.77 50.63,66.7 ; v6(142.07,142.61) 142.07,142.77 142.44,143.14 U7801.C14 ; U7700.K13 146.4,166.34 v6(146,166.74) 146.4,167.14 U7700.K14 ; U0300.BD37 U0300.BD38 v6(29.69,152.34) ; v6(123.52,151.12) 123.5,151.09 U7000.H37 ; U0300.BT3 21.26,126.38 21.09,126.22 v6(20.95,126.22) ; U0300.F21 58.64,139.97 v6(58.64,140.04) 58.31,140.36 U0300.G22 ; U7000.R23 118,140.6 v6(118.08,140.6) 118.08,140.52 U7000.P22 ; U0300.BT4 20.99,127.1 v6(20.9,127.02) ; C8724.2 156.83,79.9 157.19,79.54 v2(157.58,79.54) ; U7000.AB20 U7000.AA21 112.03,138.57 v6(112.07,138.57) 112.07,138.54 U7000.Y20 ; v2(253.95,83.4) 254.25,83.7 254.25,84.63 CON5300.75 ; v6(40.32,148.14) 40.25,148.14 U0300.AL33 ; v6(113.39,111.04) 113.7,111.04 U7900.R1 ; U7700.U3 140.52,158.02 140.14,158.02 v6(139.95,157.82) ; CON1701.201 83.63,66.28 83.88,66.54 ; CON6700.45 10.37,83.75 v2(10.69,83.43) 10.51,83.25 CON6700.44 ; v6(89.59,122.7) 89.59,122.7 U7000.BJ2 U7000.BH2 ; v6(143.59,180.2) 143.61,180.2 143.61,180.21 143.59,180.23 U7701.C1 ; CON1601.56 45.38,67.85 ; CON1701.93 54.63,66.63 ; v6(102.16,144.54) 102.16,144.44 U7000.AK26 U7000.AJ27 ; CON1601.82 51.88,67.69 ; v2(237.59,86.58) 237.25,86.24 CON5300.7 ; CON1701.227 90.13,66.42 ; U7700.R3 142.44,158.37 v6(142.05,158.76) 142.43,159.14 U7700.R4 ; v6(127.56,99.46) 127.56,100.03 U7901.U14 ; v2(74.56,28.53) 74.63,28.6 CON4400.2 ; CON1601.9 33.63,78.66 ; U7000.L13 120.57,131.5 v6(121.1,130.97) ; CON1701.176 77.38,55.94 77.68,55.64 v2(78.13,55.64) 78.38,55.89 CON1701.180 ; v6(124.03,102.09) 124.38,101.75 U7900.C14 ; v2(252.75,86.28) CON5300.69 ; U7000.AM22 100.88,140.48 v6(100.88,140.6) 101.01,140.6 U7000.AL23 ; U7900.E3 v6(115.2,103.7) ; v6(40.32,148.79) 39.99,149.11 U0300.AL34 ; v6(36.78,152.34) U0300.AR38 U0300.AR37 ; U0300.N34 54.43,148.78 v6(54.49,148.78) ; U7000.BB34 U7000.BB35 95.9,149.1 v6(96.3,149.5) ; U7700.P10 143.24,163.94 v6(142.88,164.3) 142.85,164.33 142.85,164.33 U7700.R11 142.61,164.9 142.61,165.38 U7700.R12 ; U7700.P10 143.75,163.44 144.35,163.44 144.84,163.93 U7700.M10 144.84,163.95 v6(145.22,164.33) 145.61,163.94 U7700.L10 ; U7700.P10 143.24,163.9 142.79,163.45 142.14,163.45 U7700.T10 ; CON1701.188 80.37,56.07 80.74,55.7 v2(80.74,55.62) ; U7000.AA31 111.05,148.65 v6(111.05,148.6) 111.01,148.6 U7000.AB30 ; U7700.N1 144.05,156.74 144.42,157.11 v6(144.45,157.11) ; U0300.C23 60.27,141.87 U0300.D24 60.59,142.32 v6(60.59,142.4) 60.92,142.73 U0300.C25 60.92,142.93 U0300.D26 ; U7000.H28 123.04,143.5 v6(122.67,143.87) 122.31,143.5 U7000.J28 ; v6(30.87,148.14) 30.8,148.14 U0300.BC33 ; CON1701.168 75.38,58.7 v2(75.21,58.86) ; CON1601.192 81.38,67.72 ; U7700.A12 153.27,165.17 v6(153.26,165.17) ; U7000.P24 118.08,142.52 v6(118.08,142.64) 117.97,142.64 U7000.R25 ; U7601.E3 106.81,173.46 v6(107.21,173.07) ; U7901.K2 137.29,105.72 v6(137.64,105.37) 138.04,105.77 U7901.K1 ; 32.63,79.43 CON1601.5 32.63,76.04 31.87,75.29 v2(30.79,75.29) ; CON1701.235 92.13,66.44 v2(92,66.56) ; U7000.W31 113.01,148.6 v6(112.95,148.6) 112.95,148.55 U7000.Y30 ; U7801.M5 149.64,150.29 v6(149.23,149.87) 148.84,150.26 U7801.L5 ; U7700.E1 150.6,156.58 150.67,156.58 v6(150.84,156.41) ; U7901.B5 134.89,112.16 v6(135.28,111.77) U7901.C4 ; v2(10.69,80.91) 10.69,81.52 10.47,81.74 10.07,81.74 10.06,81.75 CON6700.41 ; v6(26.7,137.3) 26.39,137.3 U0300.BJ18 U0300.BK18 ; U7601.R12 114.01,181.4 v6(113.63,181.02) 113.21,181.43 U7601.R11 ; CON1701.19 36.13,66.91 35.94,67.1 ; U7800.C1 152.04,116.76 v6(152.15,116.65) ; v6(37.96,148.14) 37.89,148.14 U0300.AP33 ; CON1701.106 57.88,56.09 57.43,55.64 v2(57.23,55.64) 56.88,55.99 CON1701.102 ; U7000.BH5 91.1,125.1 90.73,124.73 v6(90.68,124.73) ; v6(23.22,142.17) 22.89,141.84 U0300.BP24 22.79,141.87 22.34,141.87 U0300.BR24 U0300.BT24 ; U7000.AE45 109.24,157.36 109.24,157.64 U7000.AE46 ; 47.69,78.71 47.62,78.64 CON1601.65 ; v2(80.19,80.79) 80.82,80.79 81.11,81.08 81.12,81.08 81.13,81.09 R1619.2 ; v2(76.66,79.52) 76.12,79.52 75.13,78.52 CON1601.167 ; U7700.A14 v6(153.26,167.52) ; U7000.V20 114.03,138.57 v6(113.87,138.57) 113.87,138.73 U7000.W21 ; U0300.AK30 U0300.AK29 v6(40.71,145.28) ; U7600.B10 U7600.C11 ; U7600.C11 U7600.D10 122.34,180.67 v6(122.68,180.33) ; U7600.C11 121.33,181.43 v6(120.93,181.03) 120.72,181.24 120.72,181.29 U7600.C12 ; v6(20.87,139.41) 20.87,139.41 U0300.BT21 U0300.BR21 ; v6(113.94,159.12) 114.3,159.48 U7000.W48 ; CON5300.63 v2(251.25,85.99) ; U7601.C1 104.96,171.87 v6(104.67,171.58) ; U7000.J16 v6(122.7,133.5) U7000.H16 ; v6(144.2,128.28) 144.2,127.92 U7800.N14 ; v6(114.42,182.67) 114.02,183.07 U7601.U12 ; U7000.R29 118.03,146.57 v6(118.08,146.57) 118.08,146.52 U7000.P28 ; U7000.Y14 112.07,132.54 v6(112.07,132.6) 112,132.6 U7000.AA15 U7000.AB14 ; U7600.F10 122.33,179.07 122.44,179.19 v6(122.68,179.19) ; v6(121.59,155.21) 121.5,155.13 U7000.K42 ; U7600.L5 126.13,175.07 126.52,174.68 126.52,174.66 v6(126.5,174.65) 126.5,174.64 126.14,174.27 U7600.M5 ; U7000.AB16 U7000.AA17 111.97,134.63 v6(112.07,134.63) 112.07,134.54 U7000.Y16 ; U0300.BR38 v6(22.18,152.36) ; U7000.J37 v6(122.7,151.1) ; v6(115.21,170.69) 115.21,170.68 U7601.A14 115.09,169.75 114.54,169.75 U7601.A12 ; U7700.F5 149.57,159.94 v6(149.25,160.26) 148.93,159.94 U7700.G5 ; v6(150.04,158.74) U7700.E3 ; U7801.R1 152.04,153.55 v6(151.66,153.18) ; U7901.A12 129.29,112.92 v6(128.91,112.54) ; U7000.AG31 105.01,148.6 v6(104.95,148.6) 104.95,148.55 U7000.AH30 ; v2(60.02,43.2) 60.02,43.71 59.38,44.35 CON5102.33 ; CON5102.73 58.93,34.35 ; U7901.C12 v6(129.72,111.77) 129.74,111.75 U7901.C11 ; CON1601.85 52.63,78.5 ; U7801.N3 v6(150.87,151.53) ; U0300.F27 58.64,144.04 v6(58.64,143.97) 58.31,143.65 U0300.G26 ; 46.67,78.7 46.63,78.66 CON1601.61 ; U7000.BF7 92.13,126.7 92.06,126.63 v6(92,126.63) ; CON5102.57 v2(56.31,38.35) ; CON5103.3 49.33,51.85 v2(49.33,51.85) ; v6(109.5,160.03) U7000.AE48 ; CON1601.57 45.63,78.82 45.57,78.88 ; v6(48.59,152.41) U0300.Y38 U0300.Y37 ; U7700.R4 142.49,159.14 v6(142.88,158.75) ; U7700.R4 U7700.T5 ; U7000.T42 v6(117.1,154.3) U7000.T41 ; v6(29.26,145.18) 28.9,145.53 U0300.BE29 U0300.BE30 ; v6(126.52,179.47) 126.52,179.46 U7600.F5 126.05,178.99 126.05,178.35 U7600.G5 ; U7000.BC2 v6(95.1,121.99) ; CON1701.64 47.38,55.67 ; v2(46.41,67.81) 46.38,67.84 CON1601.60 ; U7000.W4 114.52,124.08 114.55,124.08 v6(114.72,123.92) ; U7000.AW29 98.66,144.46 98.7,144.46 v6(98.91,144.67) 98.97,144.73 98.97,145.45 98.5,145.91 U7000.AW31 ; U7000.L28 120.52,143.5 v6(120.96,143.93) ; U7600.C3 127.73,181.41 v6(127.36,181.04) U7600.C4 ; CON1601.201 83.63,78.37 83.24,78.75 v2(82.98,78.75) 82.63,78.4 CON1601.197 ; U7800.U1 140.53,117.37 v6(140.16,117.74) ; v6(111.61,180.61) 111.69,180.61 111.76,180.67 U7601.P10 ; v6(115.11,140.6) 115.11,140.71 U7000.U23 U7000.T22 ; v6(120.93,179.5) 120.56,179.87 U7600.E12 ; CON1601.27 38.13,78.68 ; CON1601.180 78.38,67.77 ; U7801.R11 v6(152.45,145.96) U7801.T10 ; v6(93.9,124.73) 93.9,124.7 U7000.BE4 ; v6(146.04,145.98) 145.67,146.35 U7801.G10 145.52,146.47 144.96,146.47 U7801.F10 ; U7600.T5 126.13,171.07 v6(126.5,170.7) ; U7000.AB32 110.92,149.68 v6(110.92,149.62) ; CON1701.172 76.38,58.28 77.62,59.53 v2(77.86,59.53) ; U7000.AG21 104.97,138.57 v6(104.95,138.57) 104.95,138.55 U7000.AH20 ; U7701.L10 150.47,173.5 150.48,173.5 v6(150.77,173.8) U7701.M10 ; v6(153.16,173.78) 152.79,173.4 U7701.P10 ; U7000.AH14 U7000.AG15 ; CON1601.86 52.88,67.94 v2(52.97,67.84) 53.54,67.84 53.88,68.18 CON1601.90 ; U7701.F5 146.71,177.06 v6(146.76,177.06) 146.82,177.06 U7701.G5 ; CON1701.184 79.38,55.9 v2(79.12,55.64) ; 41.11,66.65 41.13,66.63 CON1701.39 ; 48.63,78.78 48.62,78.77 CON1601.69 ; v6(33.23,148.14) 33.17,148.14 U0300.AY33 ; U7000.AB28 110.97,146.57 v6(111.05,146.57) 111.05,146.65 U7000.AA29 ; U7901.L10 131.05,104.81 131.05,104.32 U7901.M10 130.9,104.17 v6(131.32,103.75) ; CON1601.205 84.63,78.49 ; U7601.H2 U7601.H1 v6(104.67,175.87) ; U7901.D10 130.89,110.61 v6(130.51,110.23) ; U7701.A1 141.53,179.76 v6(141.53,179.59) ; v6(140.17,144.42) 140.5,144.75 U7801.A12 ; v6(22.57,139.81) 22.57,139.73 U0300.BP21 ; CON1601.218 87.88,67.64 ; U7000.G45 v6(123.5,156.69) ; CON1601.6 32.88,67.68 ; U7000.V18 114.06,136.54 v6(113.87,136.54) 113.87,136.73 U7000.W19 ; v6(153.39,149.9) 153.29,149.9 U7801.T5 ; v6(150.95,167.76) 150.95,167.6 150.49,167.14 U7700.E14 ; CON1601.217 87.63,78.85 ; CON1601.185 79.63,78.83 ; U7800.C4 152.04,119.77 v6(151.64,119.37) 152.04,118.97 U7800.C3 ; U7000.E25 125.5,141.05 v6(125.85,140.7) 126.25,141.1 U7000.D25 ; v6(152.45,145.15) 152.05,144.75 U7801.R12 ; U7000.BG1 U7000.BH1 89.62,121.9 v6(89.59,121.93) ; U7000.B16 127.9,133.86 v6(127.5,133.46) ; v6(150.83,164.36) 151.24,163.94 U7700.D10 ; v6(119.51,159.86) 119.15,159.5 U7000.N48 ; CON1701.1 31.63,66.34 31.88,66.59 ; v2(10.66,80.28) 10.62,80.25 CON6700.38 ; U7701.T5 154.3,177.4 v6(153.9,177) ; v6(128.42,138.64) 128.3,138.64 128.24,138.7 U7000.B22 ; v6(122.49,173.03) 122.49,173.03 U7600.P10 ; U7700.B5 v6(152.84,160.47) ; U7000.E13 125.51,131.5 v6(125.9,131.89) 125.9,131.89 126.29,131.5 U7000.D13 ; CON1701.72 49.38,55.84 ; v6(120.81,111.76) 120.82,111.76 U7900.T10 ; U7700.N14 v6(144.46,167.55) ; CON1701.189 80.63,66.53 ; v6(99.9,122.06) U7000.AU2 ; CON1701.205 84.63,66.48 ; CON1601.230 90.88,67.61 ; U7900.C11 122.02,101.72 v6(122.38,102.08) 122.74,101.72 U7900.C12 ; U0300.BC34 30.54,149.11 v6(30.87,148.79) ; v6(89.71,132.6) 89.71,133.24 90.37,133.9 U7000.BH16 ; CON1601.35 40.13,78.65 ; CON1601.103 57.13,78.45 ; U0300.AE34 44.98,148.78 v6(45.04,148.78) ; v6(101.14,154.32) 100.76,154.7 U7000.AT42 ; v6(146.77,173) U7701.F10 ; U7801.B10 141.64,146.35 v6(142.05,145.95) U7801.C11 ; v6(111.53,159.1) 112.07,158.56 112.07,158.07 U7000.AB46 ; U7801.K2 148.06,152.75 v6(148.46,153.15) 148.06,153.55 U7801.K1 ; U7600.A12 v6(120.15,182.69) ; v2(31.62,70.93) 31.88,70.68 CON1601.2 ; U7900.N3 115.58,109.65 v6(115.21,109.29) ; v6(113.9,127.9) U7000.W8 ; U7900.F5 117.16,104.12 v6(116.79,104.49) 117.18,104.87 U7900.G5 ; U7000.BF5 v6(92.3,124.7) ; CON1601.93 54.63,78.49 ; CON1601.19 36.13,78.78 36.08,78.82 ; U7900.N1 113.98,109.71 113.74,109.47 113.54,109.47 v6(113.39,109.31) ; U7000.AD26 108.87,144.47 v6(108.87,144.62) 109.03,144.62 U7000.AC27 ; v6(37.96,148.79) 37.63,149.11 U0300.AP34 ; U0300.BF33 28.44,148.14 v6(28.51,148.14) ; CON1701.167 75.13,66.48 ; U7900.B10 120.97,100.92 v6(120.65,101.23) ; v6(142.84,117.77) U7800.R1 ; CON1601.30 38.88,68.12 39.16,67.84 v2(40.01,67.84) 40.18,67.84 40.38,68.04 CON1601.36 ; v6(114.7,154.3) 114.3,153.9 U7000.W41 ; U7901.N14 127.17,102.85 v6(127.17,101.77) U7901.R14 ; v6(145.21,160.37) 145.64,159.94 U7700.L5 ; U7900.K2 U7900.K1 113.63,107.32 v6(113.41,107.53) ; U0300.F23 58.64,140.89 v6(58.64,140.82) 58.31,141.14 U0300.G23 ; U0300.BR36 21.7,150.28 U0300.BT36 21.27,150.71 v6(20.96,150.71) ; v6(122.66,178.37) 122.37,178.37 122.27,178.27 U7600.G10 ; 75.38,67.82 CON1601.168 ; U7801.C3 142.44,151.95 v6(142.04,151.55) 142.44,151.15 U7801.C4 ; U7800.K14 U7800.K13 ; v6(115.21,173.86) 115.23,173.86 U7601.E14 ; U7800.L5 145.09,121.12 144.6,121.12 v6(144.5,121.02) 144.5,120.91 U7800.M5 ; CON1601.244 94.38,67.82 ; v2(56.17,55.67) 55.88,55.96 CON1701.98 ; U7700.U1 140.48,157.1 v6(140.48,157.1) ; U7901.N1 138.07,103.37 v6(137.67,103.77) ; CON1701.43 42.13,66.44 42.25,66.56 v2(42.52,66.56) 42.9,66.56 43.13,66.34 CON1701.47 ; v6(139,107.64) 138.37,107.64 U7901.H1 U7901.H2 ; CON1701.251 96.13,66.3 96.29,66.46 ; v2(10.57,129.34) 10.55,129.35 XDP4400.49 ; v2(0.78,133.75) 0.81,133.75 0.92,133.85 XDP4400.32 ; U7900.G10 121.11,104.92 v6(120.68,104.49) 121.04,104.12 U7900.F10 ; v6(131.32,102.99) 130.9,102.57 U7901.P10 ; CON1701.209 85.63,66.44 ; CON1601.15 35.13,78.68 ; U7701.R11 153.57,172.61 v6(153.98,173.01) 154.36,173.4 U7701.T10 ; v6(151.71,167.6) 151.97,167.35 151.97,167.33 152.04,167.26 U7700.C14 ; CON1701.252 96.38,58.22 96.38,58.22 v2(96.38,58.75) ; U7000.AE11 109.82,129.78 v6(109.82,129.33) ; 23.86,136.72 v6(23.86,136.66) ; 23.86,136.72 U0300.BM18 ; 23.86,136.72 U0300.BN18 ; U7000.AC23 109.01,140.61 v6(108.88,140.61) 108.88,140.48 U7000.AD22 ; U7701.A3 142.12,178.75 v6(141.5,178.75) C7716.2 ; v6(120.65,102.78) 120.71,102.72 120.92,102.52 U7900.D10 ; U7600.U12 120.68,170.42 120.68,170.46 v6(120.88,170.65) ; U7901.K13 U7901.K14 v6(127.05,105.77) ; CON1601.234 91.88,67.96 v2(92,67.83) ; U7000.Y32 112.95,149.65 v6(112.95,149.62) ; CON1701.239 93.13,66.53 ; U0300.AY34 32.91,149.11 v6(33.23,148.79) ; U7000.AC19 108.97,136.57 v6(108.88,136.57) 108.88,136.48 U7000.AD18 ; U7701.H2 147.95,179.8 v6(147.55,180.2) 147.95,180.6 U7701.H1 ; U7601.T10 v6(111.91,182.27) ; CON1701.234 v2(91.88,55.57) ; v6(128.1,161.05) 128.1,160.5 U7000.B49 U7000.B48 ; v6(146.44,142.64) U7801.H14 146.51,143.21 146.51,143.89 U7801.H13 ; U7000.AE41 109.5,153.9 v6(109.11,154.29) 109.5,154.68 U7000.AE42 ; U7901.E14 127.3,110.16 v6(127.11,110.16) ; U7601.G5 108.82,174.67 v6(108.84,174.67) 108.44,174.27 U7601.F5 ; v6(99.02,133.9) U7000.AW16 ; U7900.H14 124.37,105.72 v6(124,105.35) 123.95,105.35 U7900.H13 ; CON1601.47 43.13,78.69 43.1,78.71 ; U7000.AG19 104.95,136.55 v6(104.95,136.54) 104.94,136.54 U7000.AH18 ; 58.75,33.82 v2(58.76,33.82) 58.73,33.85 CON5102.75 ; U7000.A2 U7000.B2 ; U7000.B2 U7000.A3 ; U7601.R14 v6(116.16,181.47) ; CON1601.188 80.37,67.85 ; U0300.AU34 35.27,149.11 v6(35.59,148.79) ; CON1701.36 40.38,55.83 ; U7700.C11 152.04,164.79 v6(151.66,165.17) 152.04,165.54 U7700.C12 ; CON1701.81 51.63,66.37 51.83,66.57 v2(52.97,66.57) ; XDP4400.13 7.66,138.35 v2(7.51,138.21) ; U0300.P37 U0300.P38 v6(53.31,152.41) ; v6(118.26,176.07) 118.46,175.87 U7600.K14 ; U7601.G10 111.93,174.59 111.93,174.59 v6(111.91,174.57) 112.2,174.27 U7601.F10 ; v6(150.11,142.73) 150.1,142.74 150.1,142.81 150.44,143.15 U7801.N14 ; U0300.BL38 v6(25.04,152.34) ; CON5103.27 46.86,45.85 46.74,45.98 v2(46.74,46.18) ; U7000.AE15 107.11,132.71 v6(107.11,132.6) 107,132.6 U7000.AF14 ; v6(115.94,112.53) 115.94,112.55 115.58,112.91 U7900.U3 ; U7000.AU5 v6(99.9,125.74) ; U7800.C14 151.64,128.18 v6(151.64,128.49) ; U7800.R14 v6(142.44,128.31) ; CON1601.89 53.63,78.56 ; U7700.B10 v6(152.84,163.43) ; U7900.K13 123.93,107.67 v6(123.96,107.67) 124.03,107.67 U7900.K14 ; U7601.N12 v6(113.59,179.44) ; U7900.R12 v6(122.43,110.91) U7900.R11 ; U7601.C12 114.01,171.87 v6(113.62,171.48) ; U7700.R14 142.83,167.53 142.83,167.53 v6(142.95,167.65) ; CON1701.99 56.13,66.22 56.48,66.57 v2(56.71,66.57) 56.94,66.57 57.13,66.39 CON1701.103 ; v2(239.19,90.69) 239.52,90.69 240,91.17 CON5300.18 ; U7901.E12 129.29,109.79 v6(128.94,110.15) ; U7900.T5 117.25,112.12 117.61,111.75 v6(117.61,111.74) ; U7600.K2 U7600.K1 v6(129.84,175.87) ; v6(128.12,170.68) 127.73,170.29 U7600.U3 ; U7000.H25 122.74,141.47 122.74,141.47 v6(122.71,141.49) 122.33,141.1 U7000.J25 ; CON1701.26 37.88,55.8 ; v2(41.5,55.59) 41.4,55.69 41.38,55.69 CON1701.40 ; v6(59.29,136.1) 59.29,136.17 U0300.F17 ; U7000.E40 U7000.D40 126.46,152.94 127.12,152.94 127.4,153.22 v6(127.4,153.43) 127.73,153.1 U7000.B40 ; U7000.R21 117.9,138.7 v6(118.08,138.7) 118.08,138.52 U7000.P20 ; U7600.N12 v6(120.93,173.88) ; U7000.AL19 101,136.6 v6(100.87,136.6) 100.87,136.47 U7000.AM18 ; v6(109.82,128.74) 109.82,128.62 U7000.AE9 ; U7800.H14 148.04,127.76 v6(147.68,127.4) 148.04,127.03 U7800.H13 ; v4(240.17,32.12) 240.4,32.35 C1181.2 ; U7601.C4 107.61,171.87 v6(107.21,171.46) U7601.C3 ; U7801.U3 153.99,151.6 154,151.6 v6(154.05,151.55) ; U7000.T24 U7000.U25 115.11,142.71 v6(115.11,142.64) ; 60.12,53.13 v2(60.13,53.13) 60.13,52.16 59.81,51.85 CON5102.3 ; CON1701.243 94.13,66.41 ; U7901.U12 v6(129.69,100.57) ; CON1701.23 37.13,66.55 37.14,66.57 ; CON1701.171 76.13,66.41 ; U7800.A1 v6(153.64,116.86) ; U7000.J34 v6(122.68,148.68) ; U0300.U37 U0300.U38 v6(50.95,152.41) ; U7801.R3 v6(152.46,151.54) ; CON5103.21 v2(49.59,47.35) ; v6(150.83,124.97) 151.23,124.57 U7800.D10 ; CON1601.78 50.88,67.74 ; U7801.N12 v6(150.04,145.15) ; v6(123.98,100.5) 124.36,100.12 U7900.A14 ; U7000.AL31 U7000.AM30 v6(99.99,147.59) ; v2(7.7,78.83) 8,78.53 8.66,78.53 8.88,78.75 CON6700.35 ; CON1601.226 89.88,67.75 ; CON1701.56 45.38,55.65 ; U0300.AV37 U0300.AV38 v6(34.41,152.34) ; U7700.H13 148.04,166.35 v6(147.63,166.76) 148.01,167.14 U7700.H14 ; U7700.G10 148.84,163.9 v6(149.23,163.51) 149.64,163.93 U7700.F10 ; CON1601.209 85.63,78.65 v2(85.52,78.75) ; XDP4400.25 v2(7.51,135.35) ; v6(90.55,129.1) U7000.BH10 ; U7000.AL39 v6(104.7,152.8) ; v6(56.44,142.79) U0300.J25 U0300.H25 ; v6(151.64,146.75) U7801.P10 ; v2(95.39,58.57) 95.39,58.03 95.39,58.03 95.39,57.11 CON1701.248 ; U0300.W34 49.7,148.78 v6(49.77,148.78) ; U7000.T4 116.7,124.31 v6(116.31,124.7) 116.7,125.1 U7000.T5 ; U7000.Y26 112.06,144.54 v6(112.06,144.67) 111.93,144.67 U7000.AA27 U7000.AB26 ; v6(144.42,151.55) 144.42,151.62 144.09,151.95 U7801.E3 ; U7000.AJ29 U7000.AK28 102.16,146.44 v6(102.16,146.57) ; U7000.E48 125.51,159.5 v6(125.9,159.89) ; U7600.C14 119.35,181.05 v6(119.35,181.04) ; U7601.U1 104.87,182.73 104.86,182.73 v6(104.81,182.68) ; v6(104.72,179.72) 104.88,179.87 U7601.N1 ; v2(85.8,67.81) 85.88,67.88 CON1601.210 ; v6(128.07,111.75) 128.07,111.75 127.69,111.38 U7901.C14 ; v6(93.9,123.08) 93.53,122.7 U7000.BE2 ; CON4400.4 73.63,28.6 v2(73.56,28.53) ; CON1701.217 87.63,66.33 ; v6(107.21,179.47) U7601.N3 ; CON1601.251 96.14,77.29 96.14,78.21 95.08,79.26 v2(94.92,79.26) ; CON5103.73 46.77,34.35 ; v6(102.16,138.57) 102.16,138.44 U7000.AK20 U7000.AJ21 ; U7000.B19 v6(128.8,136.3) ; v6(150.06,153.17) 150.44,153.55 U7801.N1 ; v6(155.55,172.18) 155.55,172.18 U7701.U12 ; v6(127.1,121.25) U7000.C1 ; CON1601.1 31.63,78.58 ; v6(121.9,159.1) U7000.K48 ; v6(142.85,124.96) 143.24,124.57 U7800.P10 ; v6(32.05,152.34) U0300.BA38 U0300.BA37 ; CON1701.82 51.88,55.71 ; U7000.AL15 101,132.6 v6(100.87,132.6) 100.87,132.47 U7000.AM14 ; CON1601.106 57.88,67.84 ; v6(113.97,151.4) 113.97,151.77 U7000.W39 ; v6(122.54,171.48) U7600.T10 ; U7000.AY46 v6(97.13,158.28) ; U0300.AU33 35.53,148.14 v6(35.59,148.14) ; U7801.M10 149.56,146.35 v6(149.24,146.66) 148.93,146.35 U7801.L10 ; CON1601.68 48.38,68.06 v2(48.13,67.82) 47.73,67.82 47.38,68.18 CON1601.64 ; CON5103.75 46.72,33.85 ; v6(116.21,179.87) U7601.N14 ; v2(82.51,55.62) 82.38,55.75 CON1701.196 ; CON1701.9 33.63,66.38 ; v2(245.25,86.12) CON5300.39 ; U7000.BC48 v6(95.1,160.03) ; v2(59.07,46.14) 58.78,45.85 CON5102.27 ; v6(127.36,173.1) U7600.N3 ; U7000.B45 127.91,157.1 v6(128.3,157.48) ; CON1601.213 86.63,78.79 ; U7000.D16 v6(125.9,134.3) 125.9,134.3 125.51,133.9 U7000.E16 ; U7000.H31 123.08,145.9 v6(122.71,145.53) 122.33,145.9 U7000.J31 ; CON5102.71 58.93,34.85 ; CON1601.40 41.38,68.09 41.08,67.79 40.83,67.79 40.24,67.21 v2(40.01,67.21) ; CON1701.181 78.63,66.48 ; U7800.L10 145.59,124.57 v6(145.2,124.96) 144.84,124.6 U7800.M10 ; U7000.BE7 v6(94.03,126.7) ; U7601.M10 112.41,179.03 v6(112.04,178.65) 112.01,178.65 U7601.L10 ; CON1601.239 93.13,78.61 ; v2(49.07,50.35) CON5103.9 ; v6(120.96,148.76) U7000.L34 ; v6(130.53,111.8) 130.89,112.16 U7901.B10 ; v6(142.2,155.69) 142.2,156.5 U7700.R1 ; 33.17,55.59 32.88,55.89 CON1701.6 ; CON5103.57 v2(46.66,38.35) ; U7000.AG17 104.95,134.55 v6(104.95,134.51) 104.91,134.51 U7000.AH16 ; v2(138.66,101.95) 138.48,101.77 U7901.R1 ; CON5102.9 v2(58.79,50.35) ; CON1701.213 86.63,66.4 ; U7901.A1 v6(138.61,112.97) ; U7000.AB2 v6(112.32,123.12) ; CON1701.193 81.63,66.61 ; U7701.K1 149.95,180.22 v6(149.98,180.18) 149.6,179.8 U7701.K2 ; v6(136.09,111.77) U7901.C3 ; CON1701.175 77.13,66.55 ; U7000.AC31 109.5,149.09 v6(109.02,148.6) 108.51,148.1 U7000.AD30 ; U7000.AP41 v6(101.9,154.3) ; v6(152.6,156.19) 152.6,156.19 U7700.C1 ; v6(115.11,136.54) 115.11,136.71 U7000.U19 U7000.T18 ; v6(150.06,128.15) 150.06,128.15 U7800.E14 ; CON1701.73 49.63,66.49 ; U7000.AG27 105.5,145.09 v6(104.95,144.54) 104.94,144.54 U7000.AH26 ; CON1601.223 89.13,75.74 89.54,75.33 v2(89.78,75.33) 89.87,75.33 90.34,75.79 90.34,76.16 90.13,76.38 CON1601.227 ; U7700.A3 153.64,158.34 v6(153.24,158.74) ; U7901.U1 v6(138.09,99.64) ; 41.08,78.67 41.13,78.63 CON1601.39 ; CON1601.189 80.63,78.45 ; CON1701.51 44.13,66.57 ; U0300.BM23 24.19,141.05 v6(23.86,141.38) ; v6(120.07,140.73) 120.13,140.73 U7000.L25 ; 77.38,67.46 CON1601.176 ; CON1601.238 92.88,67.75 ; U7000.Y22 112.07,140.54 v6(112.07,140.6) 112,140.6 U7000.AA23 U7000.AB22 ; U7801.G5 145.64,150.35 v6(145.26,149.97) 145.22,149.97 144.84,150.35 U7801.F5 ; v6(35.99,145.28) U0300.AT29 U0300.AT30 ; v6(39.14,152.34) U0300.AM38 U0300.AM37 ; CON1601.206 84.88,67.77 ; v6(141.23,118.58) U7800.U3 ; v6(95.1,123.77) U7000.BC4 U7000.BC5 ; U7801.K13 147.97,143.95 v6(147.57,143.55) 147.97,143.15 U7801.K14 ; U7000.BB36 v6(95.5,150.3) ; CON1701.10 33.88,55.73 ; v2(75.54,53.97) C1713.2 ; U7800.T10 v6(141.22,124.98) ; CON1601.72 49.38,67.91 ; U7000.K2 v6(121.5,122.16) ; CON1701.185 79.63,66.46 ; U7800.U14 v6(140.84,128.34) ; U7000.E28 v6(125.1,143.1) ; 94.13,78.37 CON1601.243 ; U7700.A1 v6(154.07,157.16) ; CON1601.18 35.88,67.95 ; CON1601.193 81.63,78.54 ; U7000.R27 117.93,144.67 v6(118.08,144.67) 118.08,144.52 U7000.P26 ; 34.88,55.92 CON1701.14 ; U7000.T2 v6(116.7,122.14)
  BOTTOM w0.33: U0300.BJ25 v6(26.67,142.56)
  BOTTOM w0.35: v6(117.07,128.67) 117.07,128.67 U7000.T9 ; v6(129.54,143.19) 129.36,143.37 128.03,143.37 U7000.B28 ; U7000.AP48 v6(102.3,160.02) ; U7000.E37 125.5,150.7 v6(125.9,151.1) ; v6(121.09,124.75) 121.09,124.75 121.5,124.33 U7000.K4 ; v6(106.7,151.7) 107.1,152.1 U7000.AH39 ; U7000.W42 v6(114.7,154.3) ; v6(121.08,133.49) 120.91,133.49 U7000.L16 ; v6(116.65,158.72) 116.64,158.72 116.64,159.44 U7000.T48 ; U7000.H34 123.06,148.3 v6(122.68,148.68) ; v6(128.3,151.1) 127.9,150.7 U7000.B37 ; U7000.AE8 v6(109.1,127.1) ; U7000.AU48 100,159.41 100,158.8 v6(99.5,158.3) U7000.AU46 ; v6(111.53,159.1) 111.53,159.13 U7000.AB48 ; U7000.AP42 v6(101.9,155.1) ; U7000.BE10 v6(94.02,129.1) ; U7000.B10 127.9,129.1 127.57,129.43 126.75,129.43 v6(126.75,129.44) ; v6(113.9,127.9) 114.3,128.3 U7000.W9 ; v6(119.56,129.64) U7000.N11 ; v6(95.38,129.1) U7000.BB10 ; v6(95.45,127.1) 95.5,127.1 U7000.BB8 ; U7000.AY4 97.08,124.72 v6(97.08,124.73) 97.45,125.1 U7000.AY5 ; v6(117.1,127.1) U7000.T8 ; v6(97.5,158.85) U7000.AY48 ; U7000.B34 v6(127.5,148.7) ; v6(97.13,127.1) 97.13,127.13 U7000.AY8 ; U7000.B25 128,141 128.56,141 v6(128.96,141.4) ; U7000.N2 119.1,122.43 119.07,122.4 v6(119.07,122.13)
  BOTTOM w0.356: 17.57,127.55 C0701.2 15.93,127.55 15.56,127.92 U0701.3 ; U7000.W46 114.3,157.88 v6(113.92,157.49) 114.3,157.11 U7000.W45 ; U2403.3 v2(190.54,66.97)
  BOTTOM w0.381: R0715.2 12.5,140.52 12.95,140.97 v2(13.26,140.97) 13.27,140.98 R0719.2 R0705.2 ; R1614.2 94.51,87.7 94.87,87.34 v2(95.15,87.34) 95.33,87.52 R1613.2 ; R7448.1 106.72,114.8 v2(107.45,114.07) ; v6(18.25,148.94) 18.12,148.81 C80134.2 ; R8038.2 5.55,174.34 5.34,174.13 v2(4.17,174.13) 4.45,174.42 4.45,174.44 C8004.2 ; C4517.2 50.82,185.86 ; v2(99.26,54.11) 98.76,54.11 98.6,54.27 R1716.2 ; v2(94.89,176.42) 94.79,176.52 C4308.2 ; v2(72.82,55.47) 73.03,55.26 C80135.2 ; v2(67.34,173.1) 67.34,173.04 C8067.1 ; R1123.1 244.83,28.1 v4(244.75,28.19) ; R1108.2 236.06,30.94 v4(236.82,30.94) ; C9603.2 75.48,177.59 v2(74.79,176.9) ; v2(150.99,87.13) 150.99,87.23 150.55,87.67 R8707.2 ; D3101.2 177.88,32 C3102.2 178.07,32.19 v2(178.07,32.66) ; v2(102.49,113.93) 102.54,113.98 R7435.1 ; v4(245.67,28.19) 245.75,28.11 R1124.1 ; C1819.2 97.85,54.23 v2(97.74,54.12) ; v2(168.71,32.65) 168.71,32.86 R2121.2 ; v2(95.59,164.64) 94.99,165.24 R7502.2 ; R1101.2 241.71,28.8 241.99,28.52 v4(241.99,28.19) ; R1719.2 106.59,60.21 106.37,59.99 v2(106.37,59.65) ; v2(95.63,54.1) 95.63,54.27 95.38,54.52 C1700.2
  BOTTOM w0.394: C1826.2 84.35,54.7 v2(84.1,54.96)
  BOTTOM w0.406: C7719.2 v2(152.88,183.45) ; C7706.2 157.4,177.36 v2(157.4,177.89) ; v2(84.1,54.96) 83.87,54.73 C1607.2 ; v6(119.28,183.56) 118.85,183.99 C7611.2 ; C7803.2 147.5,130.82 147.24,131.08 146.23,131.08 145.85,130.7 v2(145.85,130.37) R7812.1 ; v2(189.55,55.87) 189.55,55.86 189.33,55.64 R2263.2 ; C7817.2 v2(148.77,139.84) ; R0742.2 16.68,144.48 v2(17.07,144.87) 17.51,144.43 R1016.2 ; R7105.1 97.54,164.68 97.73,164.88 v2(97.73,165.25) ; C7829.2 v2(139.24,128.8) ; C7625.2 114.61,167.78 v2(114.86,168.04) ; v2(145.16,60.11) 144.65,59.61 C9108.2 ; C3103.2 180.98,32.59 v2(180.91,32.66) ; v6(139.62,167.4) C7729.2 ; R1015.2 15.84,144.33 16.15,144.64 v2(16.15,144.87) 16.21,144.87 R0741.2 ; v2(141.58,23.92) 141.75,24.09 CON3110.15 ; C7814.2 v2(156.03,148.5) ; C7626.2 114.15,169.2 v6(113.94,169.41) ; R7701.1 v2(156.79,162.7) ; C7628.2 103.35,179.14 103.15,178.93 v2(103.05,178.93) ; R7916.2 112.55,106.44 112.99,106 v6(113.39,106) ; v6(141.53,171.03) 141.12,170.63 C7714.2 ; C7704.2 157.58,174.03 v2(157.4,174.21) ; R7718.2 v2(147.63,183.84) ; 140.07,165.53 139.37,164.84 C7735.2 ; C7717.2 v2(149.86,183.38) ; v2(6.05,122.81) 5.89,122.66 R4423.2 ; v2(145.62,66.82) 145.55,66.82 145.03,66.31 C9103.2 C9105.2 ; CON3110.16 133.25,24.35 132.99,24.1 v2(132.46,24.1) ; C4402.2 R4426.2 3.73,122.8 v2(3.63,122.9) ; C1719.2 106.81,61.69 v2(106.34,61.69) ; C7819.2 v2(150.83,140.55) ; R7107.1 v2(131.72,165.19) ; C7807.2 141.51,142.05 v6(142.07,142.61) ; R7114.1 v2(134.25,144.77) ; v2(195.92,29.63) 195.25,29.63 194.69,30.19 C3708.2 ; Q9104.1 212.34,85.18 212.68,85.52 v2(212.68,85.68) ; C7614.2 117.88,168.93 118.08,169.13 118.14,169.13 v6(118.35,169.35) ; R7506.2 v2(125.32,163.49) ; v2(12.62,144.66) 12.62,144.65 12.03,144.65 11.81,144.44 R4424.1 ; C7629.2 104.83,167.48 v2(105.05,167.25) 105.34,167.25 105.72,167.63 C7630.2 ; R1715.2 94.94,54.1 v2(95,54.1) ; C7700.2 v2(156.79,163.59) ; U2404.3 v2(199.51,48.04) ; R7118.1 v6(109.14,119.06)
  BOTTOM w0.432: R9406.2 78.97,161.67 79.18,161.88 v2(79.67,161.88) ; R1617.2 v2(91.57,80.41) ; C1718.2 72.29,55.13 v2(72.06,55.36) ; C1710.1 C1717.2 v2(35.66,91.33) ; v2(93.47,80.33) C1705.1 C1706.2 ; v2(143.08,64.86) 142.93,64.86 142.19,65.6 C9100.2 ; C1610.1 C1618.2 76.81,87.76 76.82,87.77 v2(76.84,87.77) ; R1618.2 90.98,82.36 v2(90.98,82.31) ; v2(212.92,86.3) 213.44,86.3 C9124.2 ; C9111.2 196.13,71.19 v2(196.53,70.78) ; C9120.2 v2(221.08,85.49) C9118.2 ; R1615.2 82.91,80.94 82.75,80.79 v2(82.12,80.79) ; R2256.2 152.45,35.38 v2(152.39,35.32) ; C1619.2 65.28,81.17 65.02,80.92 v2(65.02,80) ; R8204.2 137.72,67.01 v2(138.06,66.67) ; R5017.2 230.58,98.9 230.2,98.52 v2(230.18,98.52) ; C1604.2 88.98,82.92 88.7,82.64 v2(88.7,82.06) C1605.1 ; C1606.2 89.15,81.42 v2(88.7,81.42) ; v2(193.4,70.05) 193.22,69.86 C2404.1 ; v2(76.25,80.53) 75.95,80.84 C1613.1 ; v2(185.52,61.56) 185.53,61.56 185.56,61.58 C2501.2 ; R8206.2 139.37,69.3 v2(139.37,69.82) ; R9402.2 v2(80.62,160.44) ; v2(139.71,60.72) 140.15,60.29 C9101.2 141.4,59.83 141.74,59.5 C9109.2 ; v2(231.95,61.23) 231.98,61.25 C9128.2 ; v2(144.49,139.78) 144.55,139.85 R7813.1 ; C5001.2 172.89,74.14 v2(173.09,73.95) ; R9110.2 v2(212.4,81.04) ; C2828.2 C2827.2 221.49,55.93 221.79,56.23 v2(221.79,56.86) ; R0740.2 16.64,152.29 16.41,152.52 v2(15.75,152.52) ; C9123.2 213.39,84.98 v2(212.68,85.68) ; C1804.2 51.57,82.06 51.83,81.8 v2(51.83,81.42) 51.57,81.17 C1801.2 ; C2405.1 v2(197.69,67.91) ; R1612.2 v2(75.24,84.34) ; R1714.2 34.3,88.03 v2(34.15,88.18) ; v2(181.09,68.67) 180.77,68.35 R2479.2 ; C1602.1 56.33,83.96 56.06,83.69 v2(56.06,82.18) C1703.1 C1702.1 ; C8829.2 221.03,38.24 v2(220.87,38.08) ; C1603.1 v2(56.06,81.29)
  BOTTOM w0.457: C8065.1 45.26,174.64 v2(45.39,174.77) ; R7436.2 v2(104.17,116.6) ; C8031.1 v2(17.07,171.97) C8032.1 ; v2(222.56,94.84) 222.56,94.71 222.65,94.62 C3311.2 ; C2300.2 v2(186.74,71.26) ; v2(246.95,76.82) 246.86,76.91 CON6002.3 ; CON5300.76 234.65,86.19 234.65,87.63 v2(234.89,87.86) ; R2201.2 155.12,35.81 v2(155.12,35.32) 154.48,35.32 154.36,35.45 R6116.2 ; R7318.2 v2(87.55,127.78) ; R0506.1 R0507.2 68.53,120 v2(68.71,120.19) ; C8028.2 v2(19.53,175.58) ; v2(184.46,60.33) C2401.2 ; v2(67.48,82.8) 67.48,82.89 68.1,83.51 C1620.2 ; R2255.2 153.26,35.76 152.87,35.37 152.87,35.37 152.83,35.32 v2(152.39,35.32) ; C2310.2 v2(184.96,71.26) ; v2(157.79,35.32) R2148.2 R2258.2 ; R6114.2 v2(161.34,35.32) ; v2(94.54,116.09) 95.01,116.56 X7200.2 ; v2(246.18,74.01) 246.56,74.01 246.86,74.31 CON6002.4 ; R2261.2 v2(160.45,37.35) ; v2(99.49,176.47) 100.18,176.47 100.69,175.96 R4312.2 ; v2(94.44,114.42) 94.36,114.34 R7211.2 ; C7216.2 97.64,118.58 v6(97.51,118.71) ; C3309.2 224.6,96.46 C3322.2 ; v2(11.12,166.26) 10.52,166.26 C80019.1 ; v2(87.68,125.11) R7315.2 ; v2(98.98,113.93) 97.72,113.93 X7200.4 ; R2146.2 v2(164.01,35.32) ; v2(93.83,83.71) 93.47,83.36 C1704.2 C1706.2 ; R7316.2 v2(87.55,128.67) ; R3306.1 231.87,96.59 232.53,97.24 v2(232.53,98) ; v2(10.6,124.07) 9.83,123.31 C4403.2 ; C2500.2 185.91,63.85 v2(185.24,63.85) ; v2(104.5,113.89) 104.8,113.58 C7401.2 ; v6(88.19,126) R7404.1 ; v2(15.55,174.64) 15.55,174.39 15.16,174 C8035.1 ; v2(171.39,71.26) 171.5,71.15 R2235.2 ; C3706.2 192.91,36.85 v2(193.04,36.72) ; R7408.1 R7210.1 94.02,117.01 94.27,117.26 v2(94.27,117.64) ; C2303.2 v2(184.07,71.26) ; C4401.2 v2(8.03,122.87) ; v2(193.09,33.87) 193.09,33.88 192.96,33.88 192.51,34.33 C3705.2 ; v2(165.79,32.65) 165.84,32.65 165.85,32.66 166.35,32.66 166.68,32.99 R2145.2 ; C3619.2 v2(13.39,87.62) ; R7500.2 v2(125.97,165.24) ; R2474.2 171.42,68.52 v2(171.5,68.59) ; CON6002.5 v2(242.49,77.78) ; R3630.1 21.15,71.35 U3600.53 ; R7425.1 v2(85.65,133.7) ; R2257.2 v2(159.56,35.32) ; R0504.1 v2(69.44,122.67) ; C2302.2 v2(187.63,71.26) ; v2(87.68,123.4) 87.62,123.33 R7407.1 ; Q4501.2 v2(49.29,174.85) ; 62.28,185.82 R4586.1 ; R7317.2 v2(87.55,126.89) ; C2301.2 v2(185.85,71.26) ; C3620.2 v2(15.9,87.47) ; C3604.2 17.5,67.7 U3600.50 ; C80066.1 69.37,167.76 v2(69.37,168.17) ; v2(248.21,77) 247.9,76.7 CON6002.6 ; v2(16.94,88.18) 16.76,88 C3621.2 ; C4515.2 62.97,182.23 v2(62.9,182.3) ; R8092.1 16.15,173.9 v2(16.15,174.67) ; R6124.2 v2(158.67,35.32) ; v6(95.12,118.76) C7215.2 ; v2(23.39,171.46) C80064.1 ; v6(98.73,118.63) R7441.2 ; C4518.2 51.7,185.88 ; C2201.2 172.29,66.31 v2(172.57,66.04) ; R7319.2 v2(87.68,124.22) ; C8066.1 33.76,174.89 v2(34.47,174.89) ; C8020.1 0.89,171.52 ; v6(140.84,128.34) C7828.2 ; C4526.1 61.27,185.94 ; C6001.1 v2(249.89,71.39) ; R2112.2 v2(168.71,35.32) ; C8022.2 16.3,176.54 v2(16.01,176.83) ; R7429.1 v2(103.18,116.6)
  BOTTOM w0.508: v2(203.15,28.14) 203.51,28.14 203.85,28.48 C4404.1 ; v2(228.14,98.01) 228.15,98 C3320.2 ; v2(193.65,32.78) 193.9,33.04 C3707.2 ; CON4800.20 263.8,103.69 ; CON4800.20 265.17,102.85 ; CON4800.20 262.43,102.85 ; C4538.2 50.04,181.94 v2(50.02,181.96) ; U3600.51 17.75,71.06 D3600.1 ; v2(20.12,80.1) 20.12,79.93 19.61,79.42 C3645.1 ; 267.5,53.79 CON5500.13 265.76,53.05 ; v2(26.44,66.89) 26.62,67.07 26.62,68.57 CON1701.264 26.42,70.03 v2(25.84,70.03) ; v2(228.12,47.1) 228.35,46.87 R1120.2 ; Q8806.2 218.43,45.87 v2(218.21,45.65) ; v2(136.47,68.09) 136.47,67.65 C8205.2 ; 133.6,56.41 v2(133.6,57.04) ; v2(82.7,35.34) 82.7,37.69 ; v2(222.43,56.86) 222.43,57.19 C2826.2 ; CON5501.11 260.9,79.66 ; CON5501.11 260.9,78.34 ; CON5501.11 259.54,79 ; v2(77.23,28.82) CON4400.13 76.51,27.45 76,27.96 76,28.51 v2(76,28.52) ; D6006.1 226.55,25.56 v2(226.11,26) ; C8015.1 17.1,181.05 v2(17.13,181.02) 17.13,180.19 C8009.1 ; v2(8.1,85.62) 7.22,85.62 CON6700.47 ; 263.8,84.01 CON4800.21 ; CON4800.21 262.43,84.85 ; CON4800.21 265.17,84.85 ; C4309.2 102.84,185.01 102.98,184.87 ; CON5001.2 180.63,72.31 v2(179.86,71.54) ; C7805.2 v2(146.18,140.69) ; v2(196.55,62.3) 196.14,62.3 196.01,62.43 Y2500.3 ; Q5705.2 v2(148.45,135.45) ; U7000.AG15 105.64,133.1 v2(106.11,132.63) ; U5003.2 230.23,100.27 v2(230.23,101.31) ; v2(196.54,62.99) 196.37,62.99 196.03,63.33 Y2500.2 ; Q5700.2 v2(153.66,135.3) ; 141.02,56.41 141.02,56.91 v2(141.17,57.07) ; CON5501.7 260.83,72.6 ; CON5501.7 260,73.43 ; CON5501.7 260,71.77 ; CON5501.7 259.17,72.6 ; R5601.2 48.51,182.21 v2(48.8,181.92) ; v2(100.92,74.37) 101.31,74.76 102.28,74.76 102.75,74.29 CON1701.263 ; v2(236.4,28.27) 235.8,28.27 D6003.2 ; U3103.2 v2(223.7,47.92) ; v2(11.3,130.08) 12.14,130.08 R1007.1 ; D5502.2 256.64,41.55 257.12,41.06 v2(257.12,40.84) ; v2(146.19,67.15) 146.45,66.9 C8212.2 ; v2(223.71,96.07) 224.08,96.44 C3309.2 ; 269,103.69 CON4800.22 267.63,102.85 ; C1848.2 38.35,85.84 v2(38.63,86.12) C1714.2 ; 260.44,124.39 CON4601.21 ; CON4601.21 259.18,125.15 ; CON4601.21 260.44,125.91 ; v2(254.79,83.5) 255.35,84.06 CON5300.77 255.35,85.78 255.82,86.25 v2(256.46,86.25) ; CON6700.46 7,58.55 7.04,58.51 ; 228.65,104.74 229.25,104.14 U5003.4 ; v2(147.57,80.83) 147.56,80.83 146.81,81.58 R8717.1 ; CON3700.6 188,25.82 v2(188.98,25.82) ; v2(208.01,26.17) 208.01,25.56 207.96,25.5 CON4402.13 ; D5501.2 255.32,40.1 v2(255.32,40.1) ; C1000.2 69.58,125.95 69.71,125.82 v2(69.71,125.4) ; C1712.2 34.54,85.54 35.03,85.05 v2(35.43,85.05) ; v2(45.67,175.53) 46.03,175.18 C8068.1 ; C1614.2 77.57,82.62 v2(77.52,82.56) C1612.2 ; v2(234.11,88.73) 233.96,88.88 C3312.2 ; D6002.2 235.79,25.02 v2(237.67,25.02) ; v2(11.53,102.91) 11.18,103.27 10.54,103.27 10.3,103.03 CON6701.6 ; v2(103.1,166.59) 102.79,166.29 C7102.2 ; 260.9,50.94 CON5500.11 ; CON5500.11 259.54,51.6 ; CON5500.11 260.9,52.26 ; R6005.2 v2(255.86,69.18) ; 268.02,126.54 CON4601.23 ; CON4601.23 268.02,128.06 ; CON4601.23 266.76,127.3 ; CON4601.23 269.28,127.3 ; R7009.2 85.65,153.94 v3(84.63,152.92) ; U4501.2 v2(53.01,179.8) ; Y2501.2 151.51,65.27 151.41,65.18 v2(151.41,64.41) ; v2(222.45,43.02) 222.45,42.79 222.24,42.57 Q8807.2 ; v2(134.24,57.02) 134.24,56.38 ; 267.5,64.01 CON5501.12 265.76,64.75 ; 49.85,53.45 CON5103.76 ; CON5103.76 46.34,53.45 ; CON5103.76 48.09,54.43 ; C8723.2 v2(158.67,82.14) ; D6005.1 227.11,22.26 226.47,22.91 v2(226.47,23.36) ; CON6001.9 10.11,87.52 v2(10.36,87.77) ; 82.07,37.53 v2(82.07,35.34) ; v2(219.1,51.45) 219.18,51.53 R3168.2 ; CON5501.13 269.24,80.45 ; CON5501.13 265.76,80.45 ; CON5501.13 267.5,81.19 ; 255.1,18.86 CON6000.12 254.2,17.57 ; C8828.2 v2(221.11,44.42) ; CON4601.24 269.28,106.6 ; CON4601.24 266.76,106.6 ; CON4601.24 268.02,105.84 ; CON4601.24 268.02,107.36 ; v2(236.91,38.7) 236.96,38.75 R1142.2 ; CON3100.27 118.6,29.88 117.78,30.7 v2(117.78,32.28) ; v2(185.84,74.34) 185.6,74.34 184.43,75.51 CON5001.6 ; U4502.4 v2(56.38,175.95) ; v2(67.48,82.8) 67.73,82.54 C1811.2 C1814.2 ; C5007.1 230.18,104.48 229.05,105.61 v2(229.01,105.64) ; C9403.2 78.74,154.4 v2(78.51,154.17) ; CON6003.3 21.76,61 21.76,65.31 v2(21.8,65.36) ; v2(156.63,123.66) R7801.1 ; CON5001.5 175.58,77.65 v2(175.79,77.86) ; Q3107.2 193.43,38.13 v2(193.09,38.47) ; v2(19.36,86.05) 19.36,87.39 C3622.2 ; Q7405.2 101.46,108.83 v2(98.68,108.83) ; C3321.2 226.01,98.11 v2(225.98,98.14) ; R3631.1 14.4,65.38 v2(14.4,64.86) ; Q5704.2 v2(153.66,137.63) 154.65,136.64 Q5703.2 ; R7811.1 v6(148.77,128.92) ; v2(232.8,29.99) 232.49,30.3 R1154.2 ; R4588.2 59.41,176.8 v2(58.98,176.37) ; C8707.2 v2(147.23,89.28) ; v2(22.38,64.87) 22.38,62.78 CON6003.4 ; C3104.2 v2(222.27,45.47) ; C1822.2 81.38,54.75 v2(81.64,55.01) ; R1102.2 230.14,44.29 v2(229.93,44.49) ; CON4800.2 262.63,98.46 ; Q5702.2 v2(148.45,133.24) ; Q7700.2 159.15,167.51 ; C1229.2 231.63,48.79 v2(231.37,48.52) R1133.2 ; C4539.2 56.19,185.89 ; CON5602.30 45.77,180.97 v2(46.15,180.97) ; v2(256.59,70.75) 256.33,71.01 D5503.2 ; v2(139.75,33.17) 139.74,33.16 139.74,31.29 ; v2(28.3,116.27) 26.9,116.27 26.39,115.76 CON5000.2 ; v2(22.89,108.34) 19.8,108.34 16.8,111.33 CON3600.5 ; 259.18,108.75 CON4601.22 ; CON4601.22 260.44,107.99 ; CON4601.22 260.44,109.51 ; R5602.2 48.57,183.1 v2(48.82,182.85) ; v2(243.31,69.7) 243.31,69.7 CON2800.2 ; v2(85.78,35.25) 85.78,37.84 ; Q5701.2 v2(157.21,135.46) ; Q0702.2 3.69,154.76 2.77,153.84 v2(1.63,153.84) ; C1615.1 v2(79.5,81.29) ; 267.63,84.85 CON4800.23 269,84.01 ; D5504.2 v2(255.11,74.02) ; 260.9,65.54 CON5501.10 ; C7800.2 v2(156.67,124.55)
  vias: v2(0.76,183.79) v2(0.77,181.72) v2(0.78,175.14) v2(0.77,173.8) v2(0.77,172.51) v2(0.77,170.97) v2(0.77,169.03) v2(0.77,166.49) v2(0.77,163.95) v2(0.77,161.41) v2(0.77,158.87) v2(0.77,156.33) v2(0.77,153.79) v2(0.77,151.25) v2(0.77,148.71) v2(0.77,146.17) v2(0.77,143.63) v2(0.78,141.91) v2(0.77,141.09) v2(0.78,137.53) v2(0.76,135.96) v2(0.76,131.43) v2(0.76,130.4) v2(0.76,127.88) v2(0.76,125.32) v2(0.78,122.75) v2(0.78,120.21) v2(0.78,117.71) v2(0.77,114.92) v2(0.77,112.71) v2(0.79,110.11) v2(0.79,107.57) v2(0.77,95.56) v2(0.77,93.02) v2(0.77,90.48) v2(0.77,87.94) v2(0.77,85.4) v2(0.77,82.86) v2(0.77,80.32) v2(0.77,77.78) v2(0.77,75.24) v2(0.77,72.7) v2(0.77,70.16) v2(0.77,67.62) v2(0.77,65.08) v2(0.77,62.54) v2(0.77,60) v2(0.88,185.89) v2(1.91,105.53) v2(2.01,98.44) v2(2.62,100.3) v2(2.72,102.86) v2(2.78,58.46) v2(3.41,185.93) v2(5.32,58.46) v2(5.81,185.92) v2(6.05,79.01) v2(6.07,77.02) v2(6.4,112.49) v2(6.4,111.85) v2(6.53,88.23) v2(7.49,79.52) v2(7.81,80.9) v2(7.86,58.46) v2(8.25,185.94) v2(9.62,185.93) v2(10.4,58.46) v2(10.75,185.93) v2(10.75,98.8) v2(10.85,77.43) v2(11.18,99.74) v2(11.3,113.4) v2(11.5,76.53) v2(11.85,185.93) v2(12.39,78.15) v2(12.88,67.15) v2(12.94,58.46) v2(13.33,65.02) v2(13.82,64.62) v2(14.53,164.33) v2(15.48,58.46) v2(15.67,185.94) v2(17.26,185.92) v2(17.96,128.74) v2(18.02,58.46) v2(18.62,164.03) v2(20.45,57.37) v2(20.57,54.97) v2(20.57,52.43) v2(20.57,49.08) v2(20.58,48.15) v2(20.56,39.75) v2(20.56,37.17) v2(20.57,34.65) v2(20.59,32.04) v2(20.58,29.6) v2(20.58,27.05) v2(20.59,24.46) v2(20.6,22.02) v2(20.58,18.35) v2(20.56,15.99) v2(20.57,14.7) v2(20.57,13.1) v2(20.58,6.69) v2(20.57,4.15) v2(20.75,0.86) v2(21.77,5.3) v2(22.86,116.6) v2(22.94,114.96) v2(22.94,114.32) v2(23.02,43.18) v2(24.85,22.26) v2(25.46,22.25) v2(25.76,64.31) v2(26.03,73.81) v2(26.03,73.18) v2(26.03,72.54) v2(25.96,16.73) v2(26.04,0.78) v2(26.07,22.24) v2(26.34,2.13) v2(26.44,94.09) v2(26.69,22.24) v2(26.95,161.69) v2(27.03,19.47) v2(27.04,17.24) v2(27.04,14.7) v2(27.02,13.06) v2(27.04,6.77) v2(27.04,4.54) v2(27.43,184.93) v2(27.61,22.25) v2(27.74,160.24) v2(27.97,44.29) v2(28.3,117.38) v2(28.45,160.24) v2(29.21,24.23) v2(29.97,184.93) v2(31.5,25.33) v2(31.57,160.16) v2(32.16,66.59) v2(32.51,184.93) v2(32.98,113.02) v2(32.98,112.38) v2(33.5,109.09) v2(33.5,108.44) v2(33.5,107.83) v2(33.5,107.2) v2(33.63,88.69) v2(33.71,161.81) v2(33.88,38.68) v2(33.94,37.09) v2(34.05,25.46) v2(34.34,161.81) v2(34.49,79.34) v2(34.49,78.71) v2(34.6,67.2) v2(35.05,184.93) v2(35.16,55.66) v2(35.32,47.6) v2(35.81,39.34) v2(35.84,38.68) v2(35.85,37.09) v2(35.94,47.58) v2(36.58,47.59) v2(36.59,25.46) v2(37.24,79.28) v2(37.19,47.59) v2(37.59,184.93) v2(37.59,29.98) v2(38.44,29.98) v2(39.08,118.7) v2(39.07,116.61) v2(39.11,29.98) v2(39.13,25.46) v2(39.8,38.45) v2(39.84,29.98) v2(40.59,48.62) v2(40.69,79.4) v2(40.79,109.09) v2(41.3,48.62) v2(41.67,25.46) v2(41.83,82.69) v2(41.83,81.42) v2(42.09,52.09) v2(42.67,184.93) v2(42.67,29.22) v2(43.25,175.89) v2(43.36,39.67) v2(43.54,26.26) v2(43.87,52.16) v2(43.89,29.21) v2(44.15,26.26) v2(44.21,25.46) v2(44.38,51.64) v2(45.01,51.65) v2(45.03,44.16) v2(45.21,184.93) v2(45.21,39.68) v2(45.29,48.62) v2(46.46,26.1) v2(46.6,30) v2(46.56,29.22) v2(46.75,25.46) v2(47.3,78.63) v2(47.66,185.93) v2(48.26,29.15) v2(48.32,26.1) v2(49.29,25.46) v2(49.45,175.73) v2(49.54,55.64) v2(49.53,44.51) v2(49.58,67.79) v2(49.59,66.65) v2(49.94,29.18) v2(49.96,35.53) v2(50.2,185.93) v2(50.95,54.96) v2(51.38,44.51) v2(51.44,25.47) v2(51.6,175.19) v2(51.74,55.73) v2(51.79,179.8) v2(51.89,26.19) v2(52.49,55.75) v2(52.5,26.2) v2(52.74,185.93) v2(53.19,26.18) v2(53.82,67.64) v2(53.8,26.18) v2(53.93,66.77) v2(54.42,179.89) v2(54.37,25.46) v2(54.7,53.74) v2(55.28,185.93) v2(56.09,171.52) v2(56.35,80.09) v2(56.62,33.04) v2(56.62,32.42) v2(56.73,171.52) v2(56.67,161.61) v2(56.67,53.74) v2(56.91,25.46) v2(57.15,26.1) v2(57.28,29.15) v2(57.43,161.61) v2(57.71,180.05) v2(57.71,179.42) v2(57.71,178.78) v2(57.82,185.93) v2(58.33,161.63) v2(58.77,182.45) v2(58.9,29.18) v2(59.38,182.45) v2(59.45,25.46) v2(60.15,55.58) v2(60.13,53.74) v2(60.21,185.92) v2(60.6,29.2) v2(60.68,26.1) v2(60.93,173.65) v2(61.99,25.46) v2(62.2,82.52) v2(62.2,81.88) v2(62.33,29.2) v2(62.59,173.7) v2(62.71,67.18) v2(62.78,175.83) v2(62.9,185.93) v2(63.07,173.07) v2(63.14,29.23) v2(64.53,25.46) v2(64.55,173.71) v2(64.64,67.86) v2(64.64,67.25) v2(64.96,179.97) v2(65.44,185.93) v2(65.61,148.6) v2(65.74,179.9) v2(65.68,173.72) v2(66.6,146.95) v2(67.07,25.46) v2(67.25,179.98) v2(67.39,173.71) v2(67.98,185.93) v2(68.03,179.62) v2(68.02,173.71) v2(68.39,28.24) v2(68.71,25.47) v2(69.19,28.24) v2(69.4,179.97) v2(69.86,173.72) v2(69.93,136.42) v2(70.03,67.18) v2(70.26,179.92) v2(70.32,173.31) v2(70.52,185.93) v2(71.53,82.85) v2(71.53,82.24) v2(71.73,181.83) v2(71.82,152.19) v2(72.13,151.65) v2(72.15,25.46) v2(72.49,152.19) v2(72.47,53.89) v2(72.65,151) v2(72.77,151.64) v2(73.06,185.93) v2(73.67,150.38) v2(73.99,133.95) v2(74.04,126.28) v2(73.97,123.06) v2(74.1,149.93) v2(74.69,25.46) v2(75.6,185.93) v2(77.23,25.46) v2(77.89,154.18) v2(78.14,185.93) v2(79.64,159.22) v2(84.85,25.46) v2(85.04,83.66) v2(85.04,82.34) v2(85.52,79.39) v2(86.77,23.8) v2(86.81,21.21) v2(87.12,29.3) v2(87.12,28.64) v2(88.63,67.2) v2(89.3,21.06) v2(90.12,28.23) v2(90.84,185.93) v2(91.84,21.06) v2(91.92,28.16) v2(92.38,174.59) v2(92.38,173.96) v2(92.9,55.63) v2(92.92,28.16) v2(93.38,185.93) v2(93.73,174.59) v2(93.73,173.96) v2(93.73,173.32) v2(94.16,185.16) v2(94.38,21.06) v2(94.51,161.87) v2(94.49,84.72) v2(94.58,85.62) v2(94.97,80.28) v2(95.15,163.09) v2(95.1,28.16) v2(95.59,164.02) v2(95.92,185.93) v2(96.1,28.16) v2(96.92,21.06) v2(97.43,47.6) v2(97.84,164.1) v2(97.84,163.08) v2(97.97,162.37) v2(98.04,47.6) v2(98.22,28.16) v2(98.46,185.93) v2(98.69,107.22) v2(98.69,47.6) v2(98.98,88.41) v2(99.22,28.16) v2(99.43,87.93) v2(99.46,21.06) v2(99.81,185.89) v2(101.02,28.16) v2(101.19,67.84) v2(102.02,28.16) v2(102,21.06) v2(103.54,185.93) v2(103.94,28.16) v2(104.54,21.06) v2(104.64,69.13) v2(104.95,28.16) v2(106.08,185.93) v2(107.11,28.16) v2(107.08,21.06) v2(107.37,117.36) v2(107.37,116.7) v2(107.37,116.07) v2(107.37,115.43) v2(107.43,113.45) v2(108.13,28.16) v2(108.62,185.93) v2(109.62,21.06) v2(109.77,102.19) v2(110.2,75.44) v2(110.4,102.17) v2(110.41,48.61) v2(111.16,185.93) v2(111.92,85.18) v2(112.16,21.06) v2(112.32,48.61) v2(113.7,185.93) v2(114.7,21.06) v2(114.89,79.3) v2(116.24,185.93) v2(116.18,81.1) v2(116.83,80.83) v2(117.24,21.06) v2(118.07,78.08) v2(118.78,185.93) v2(119.43,51.81) v2(119.78,21.06) v2(120.23,51.81) v2(121.32,185.93) v2(121.91,62.48) v2(122.32,21.06) v2(123.86,185.93) v2(124.86,21.06) v2(126.4,185.93) v2(126.57,115.43) v2(126.92,167.78) v2(127.4,21.06) v2(128.19,167.78) v2(128.94,185.93) v2(128.88,115.46) v2(129.73,59.7) v2(129.94,21.06) v2(130.3,183.14) v2(131.34,185.92) v2(132.48,21.06) v2(132.91,139.96) v2(133.63,57.65) v2(134.02,185.93) v2(134.25,57.65) v2(135.02,21.06) v2(135.94,90.14) v2(136.3,70) v2(136.56,185.93) v2(136.58,90.14) v2(137.21,90.14) v2(137.56,21.06) v2(137.85,90.14) v2(139.1,185.93) v2(139.45,65.67) v2(140.1,21.06) v2(140.42,140.38) v2(141.41,140.37) v2(141.64,185.93) v2(141.71,64.08) v2(142.01,62.12) v2(142.64,21.06) v2(143.51,183.74) v2(144.12,183.74) v2(144.18,185.93) v2(144.74,183.74) v2(145.18,21.06) v2(146.48,51.08) v2(146.72,185.93) v2(146.67,106.45) v2(146.67,105.82) v2(146.67,103.91) v2(146.69,52.43) v2(147.12,20.97) v2(147.19,107.71) v2(147.3,55.52) v2(147.37,108.29) v2(147.37,54.4) v2(147.63,94.84) v2(147.88,97.5) v2(148.26,94.84) v2(148.37,51.08) v2(148.51,52.44) v2(148.64,19.07) v2(149.17,55.77) v2(149.21,54.36) v2(149.26,185.93) v2(150.35,41.4) v2(150.42,39.01) v2(151.8,185.93) v2(152.41,154.92) v2(153.46,74.87) v2(153.59,19.07) v2(154.04,183.82) v2(154.03,69.14) v2(154.06,77.6) v2(154.23,64.41) v2(154.34,185.93) v2(154.66,183.82) v2(154.78,19.06) v2(155.53,57.92) v2(156.05,19.06) v2(156.13,77.61) v2(156.29,153) v2(156.47,42.25) v2(156.7,145.5) v2(156.7,144.89) v2(156.7,144.28) v2(156.68,19.06) v2(156.79,159.91) v2(156.79,159.3) v2(156.77,157.61) v2(156.79,156.93) v2(156.79,156.29) v2(156.77,155.68) v2(156.85,118.43) v2(156.85,117.79) v2(156.85,117.19) v2(156.77,108.58) v2(156.88,185.93) v2(156.95,153.68) v2(156.93,152.98) v2(157.32,19.06) v2(157.4,179.62) v2(157.4,172.05) v2(157.4,170.65) v2(157.4,59.2) v2(157.52,43.69) v2(157.94,106.8) v2(158.02,77.44) v2(158.85,100.98) v2(158.93,42.65) v2(159.09,98.45) v2(159.24,184.85) v2(159.24,182.31) v2(159.24,179.77) v2(159.24,177.23) v2(159.24,174.69) v2(159.24,172.15) v2(159.24,169.61) v2(159.24,167.05) v2(159.24,164.53) v2(159.24,161.99) v2(159.24,159.45) v2(159.24,156.91) v2(159.24,154.37) v2(159.24,151.83) v2(159.24,149.29) v2(159.24,146.75) v2(159.24,144.21) v2(159.24,141.67) v2(159.24,139.13) v2(159.24,136.59) v2(159.24,134.05) v2(159.24,131.51) v2(159.24,128.97) v2(159.24,126.43) v2(159.24,123.89) v2(159.24,121.35) v2(159.36,118.81) v2(159.39,109.54) v2(159.5,40.91) v2(159.74,103.36) v2(159.84,79.34) v2(159.86,116.32) v2(159.86,19.06) v2(160.14,86.59) v2(160.13,78.8) v2(160.37,96.26) v2(160.52,113.87) v2(160.5,79.32) v2(160.78,78.77) v2(160.82,60.6) v2(161.09,76.21) v2(161.21,21.72) v2(161.34,111.46) v2(161.39,78.77) v2(161.54,105.15) v2(161.47,56.53) v2(161.47,54.32) v2(161.77,55.53) v2(162.03,78.77) v2(162.31,109.12) v2(162.38,60.6) v2(162.38,55.51) v2(162.4,19.06) v2(162.48,94.84) v2(162.79,46.31) v2(162.87,45.35) v2(162.99,76.21) v2(163.02,60.6) v2(162.99,55.51) v2(163.32,59.38) v2(163.43,106.84) v2(163.53,53.13) v2(163.5,45.35) v2(163.8,60.6) v2(163.76,43.47) v2(164.01,59.37) v2(164.21,58.08) v2(164.26,53.11) v2(164.39,76.21) v2(164.9,46.88) v2(164.87,44.39) v2(164.94,19.06) v2(165.01,94.46) v2(165,79.06) v2(165.02,59.83) v2(165.02,59.07) v2(165.61,79.09) v2(166.01,61.1) v2(166.01,60.47) v2(165.96,58.16) v2(166.22,79.09) v2(166.29,76.21) v2(166.83,79.09) v2(166.8,48.07) v2(167.06,72.15) v2(167.06,63.26) v2(167.14,60.73) v2(167.14,60.11) v2(167.14,59.48) v2(167.14,58.87) v2(167.14,58.26) v2(167.11,56.76) v2(167.11,56.12) v2(167.06,46.99) v2(167.06,45.73) v2(167.07,45.11) v2(167.16,57.65) v2(167.45,95.22) v2(167.39,28.85) v2(167.48,19.06) v2(167.69,63.26) v2(168.22,72.13) v2(168.2,57.42) v2(168.2,56.66) v2(168.19,56.02) v2(168.28,61.1) v2(168.28,60.47) v2(168.28,59.83) v2(168.33,21.7) v2(169.34,57.42) v2(169.34,56.66) v2(169.42,58.27) v2(169.44,54.65) v2(169.42,53.1) v2(169.42,52.35) v2(169.37,47.89) v2(169.36,45.11) v2(169.5,96.72) v2(169.46,60.54) v2(169.46,59.8) v2(169.45,59.03) v2(169.47,28.88) v2(170.1,19.07) v2(170.23,53.1) v2(170.21,52.35) v2(170.47,60.97) v2(170.47,60.34) v2(170.61,57.42) v2(170.61,56.66) v2(170.61,55.89) v2(170.61,48.15) v2(170.6,47.08) v2(170.56,46.37) v2(170.63,45.6) v2(170.69,28.87) v2(171.12,21.7) v2(171.71,47.14) v2(171.71,45.62) v2(171.76,59.15) v2(171.76,58.16) v2(171.76,56.66) v2(171.76,48.48) v2(171.76,44.91) v2(171.76,21.7) v2(171.93,96.02) v2(172.17,94.95) v2(172.39,21.7) v2(172.56,19.06) v2(172.8,57.55) v2(172.77,56.73) v2(172.84,47.19) v2(172.86,59.55) v2(172.85,44.99) v2(172.96,47.88) v2(173.32,94) v2(173.89,94.39) v2(174.09,58.92) v2(174.09,58.31) v2(174.09,57.7) v2(174.15,45.44) v2(174.17,48.4) v2(174.19,47.38) v2(174.44,93.14) v2(174.63,56.45) v2(174.68,55.51) v2(174.68,53.23) v2(175.1,61.09) v2(175.13,58.99) v2(175.13,58.23) v2(175.13,57.5) v2(175.06,51.96) v2(175.1,19.06) v2(175.17,47.39) v2(175.17,44.91) v2(175.31,56.45) v2(175.31,55.51) v2(175.44,53.23) v2(175.44,49.67) v2(175.64,25.68) v2(175.69,51.96) v2(175.97,92.88) v2(176.03,46.48) v2(176.03,45.87) v2(176.07,53.23) v2(176.23,58.54) v2(176.17,57.47) v2(176.3,59.58) v2(176.33,51.96) v2(176.25,25.68) v2(176.84,58.54) v2(177.14,60.47) v2(177.19,59.58) v2(177.19,45.73) v2(177.51,50.75) v2(177.64,19.06) v2(177.72,58.56) v2(177.67,49.74) v2(177.75,44.49) v2(177.77,60.47) v2(178.03,59.6) v2(178.1,91.54) v2(178.36,44.49) v2(178.71,59.63) v2(178.99,58.56) v2(180.18,19.06) v2(180.37,90.34) v2(180.61,64.18) v2(180.6,63.55) v2(182.68,89.29) v2(182.72,19.06) v2(184.99,88.43) v2(185.26,19.06) v2(186.24,32.89) v2(187.33,87.73) v2(187.36,32.87) v2(187.8,19.06) v2(189.89,87.14) v2(190.34,19.06) v2(191.42,25.58) v2(191.97,66.99) v2(192.07,74.24) v2(192.68,74.27) v2(192.76,86.65) v2(192.88,19.06) v2(193.57,84.31) v2(195.42,19.06) v2(195.58,83.28) v2(197.21,49.09) v2(197.42,26.3) v2(197.86,67.2) v2(197.96,19.06) v2(198.27,83.23) v2(198.78,45.15) v2(198.98,65.45) v2(199.95,43.35) v2(200.5,19.06) v2(200.63,45.1) v2(200.79,83.35) v2(201.57,41.67) v2(203.04,19.06) v2(203.12,41.72) v2(203.25,83.63) v2(203.41,45.01) v2(203.74,52.24) v2(204.04,50.28) v2(204.22,41.72) v2(205.27,45.1) v2(205.57,84.95) v2(205.58,19.06) v2(205.77,87.49) v2(205.93,26.3) v2(206.76,26.27) v2(207.39,26.27) v2(208.12,19.06) v2(208.17,88.23) v2(209.88,79.27) v2(210.53,89.08) v2(210.66,19.06) v2(212.54,18.55) v2(212.87,90.09) v2(213.08,15.82) v2(213.08,12.89) v2(213.47,10.37) v2(214.6,41.38) v2(214.6,40.72) v2(214.59,39.76) v2(215.01,49.19) v2(215.13,91.25) v2(215.5,54.64) v2(215.49,52.45) v2(215.66,56.48) v2(216.01,10.37) v2(216.28,41.24) v2(216.31,38.06) v2(216.93,69.83) v2(217.19,39.64) v2(217.3,92.56) v2(217.33,41.11) v2(218.55,10.37) v2(219.38,94.02) v2(221.09,10.37) v2(221.34,89.93) v2(221.36,95.62) v2(223.22,97.34) v2(223.63,10.36) v2(224.46,89.37) v2(224.74,87.27) v2(224.76,99.05) v2(224.99,41.46) v2(225.35,87.26) v2(225.42,33.13) v2(225.41,32.48) v2(225.61,39.96) v2(225.98,87.26) v2(226.14,51.26) v2(226.17,10.36) v2(226.43,101.27) v2(226.59,87.26) v2(226.67,98.92) v2(227.23,87.9) v2(227.23,87.26) v2(227.31,40.05) v2(227.8,103.41) v2(228.4,37.05) v2(228.67,99.12) v2(228.71,10.36) v2(229.03,37.05) v2(230.07,107.95) v2(230.07,37.01) v2(230.38,33.17) v2(230.41,30.37) v2(230.44,13.22) v2(230.48,31.36) v2(230.68,102.2) v2(230.7,37.02) v2(230.68,28.08) v2(230.95,110.33) v2(231.05,13.25) v2(231.25,10.36) v2(231.33,28.1) v2(231.67,112.77) v2(231.75,94.07) v2(231.95,28.1) v2(232.21,115.25) v2(232.38,94.13) v2(232.57,117.77) v2(232.79,159.1) v2(232.77,156.59) v2(232.77,154.05) v2(232.77,151.51) v2(232.77,148.97) v2(232.77,146.43) v2(232.77,143.89) v2(232.77,141.35) v2(232.77,127.92) v2(232.77,125.38) v2(232.77,122.84) v2(232.75,120.3) v2(233.05,161.1) v2(233.34,53.19) v2(233.65,108.6) v2(233.79,10.36) v2(234.33,107.6) v2(234.62,127.22) v2(234.69,104.87) v2(234.79,102.3) v2(234.95,140.06) v2(235.22,128.53) v2(235.54,161.06) v2(236.27,158.64) v2(236.27,152.92) v2(236.32,109.41) v2(236.35,107.89) v2(236.33,10.36) v2(236.58,105.55) v2(237.29,52.93) v2(237.44,139.52) v2(237.62,128.16) v2(237.69,129.2) v2(237.8,90.74) v2(238.08,161.06) v2(238.53,90.72) v2(238.87,10.36) v2(239.45,137.97) v2(239.62,130.85) v2(239.65,24.97) v2(240,20.38) v2(240.34,158.64) v2(240.34,152.92) v2(240.3,96.69) v2(240.47,136.14) v2(240.62,161.06) v2(240.59,143.1) v2(240.66,133.16) v2(240.79,137.2) v2(241.08,139.98) v2(241.19,145.4) v2(241.23,142.21) v2(241.16,24.27) v2(241.29,143.88) v2(241.43,146.99) v2(241.41,10.36) v2(241.51,95.68) v2(241.5,67.2) v2(241.57,19.86) v2(241.72,141.23) v2(241.78,24.3) v2(242.11,67.2) v2(242.14,59.91) v2(243.16,161.06) v2(243.34,109.03) v2(243.31,104.1) v2(243.38,71.64) v2(243.39,24.3) v2(243.39,20.78) v2(243.94,104.1) v2(243.95,10.36) v2(243.98,109.03) v2(244.02,20.81) v2(244.38,73.04) v2(244.42,24.25) v2(244.86,20.97) v2(245.11,71.48) v2(245.23,113.12) v2(245.29,158.64) v2(245.29,152.92) v2(245.32,149.13) v2(245.34,65.98) v2(245.52,20.94) v2(245.7,161.06) v2(245.76,142) v2(246.02,137.73) v2(246.12,148.5) v2(246.18,146.91) v2(246.21,141.08) v2(246.2,24.12) v2(246.3,145.25) v2(246.3,143) v2(246.43,138.42) v2(246.43,136.99) v2(246.49,10.36) v2(246.91,23.97) v2(247.22,66.03) v2(247.35,109.06) v2(247.26,51.25) v2(247.45,135.22) v2(247.4,113.15) v2(247.37,104.15) v2(247.88,49.6) v2(247.98,109.06) v2(248,104.15) v2(248.08,34.49) v2(248.08,33.83) v2(248.24,161.06) v2(248.34,55.59) v2(248.39,39.43) v2(248.39,38.81) v2(248.49,48.86) v2(248.73,28.12) v2(248.87,98.72) v2(249.03,10.36) v2(249.12,88.53) v2(249.15,86.58) v2(249.23,158.64) v2(249.35,152.92) v2(249.35,99.43) v2(249.37,96.97) v2(249.36,28.12) v2(249.48,134.65) v2(249.53,82.54) v2(250,28.12) v2(250.37,38.7) v2(250.5,34.76) v2(250.78,161.06) v2(250.85,82.44) v2(251.13,34.76) v2(251.18,66.94) v2(251.41,45.4) v2(251.57,10.36) v2(251.89,134.65) v2(252.03,40.1) v2(252.03,38.7) v2(252.15,89.5) v2(252.52,25.83) v2(252.72,46.05) v2(253.09,57.27) v2(253.19,114.52) v2(253.32,161.06) v2(253.29,133.95) v2(253.42,151.02) v2(253.47,89.54) v2(253.77,27.19) v2(254.1,19.35) v2(254.11,10.36) v2(254.43,132.94) v2(254.43,60.04) v2(254.74,32.5) v2(254.74,30.65) v2(255.83,131.54) v2(256.65,10.36) v2(257.15,85.31) v2(257.2,161.04) v2(257.23,130.14) v2(257.23,120.45) v2(257.18,88.23) v2(257.2,87.11) v2(257.28,101.65) v2(257.29,99.24) v2(257.33,84.14) v2(257.3,56.71) v2(257.25,56.07) v2(257.42,48.92) v2(257.4,48.31) v2(257.48,151.02) v2(257.57,69.02) v2(257.86,71.14) v2(257.88,68.44) v2(258.17,98.61) v2(258.17,97.51) v2(258.19,72.97) v2(258.34,128.67) v2(258.25,120.52) v2(258.4,161.06) v2(258.98,149.62) v2(259.19,10.36) v2(259.84,149.62) v2(259.84,103.45) v2(259.92,126.99) v2(259.89,106.47) v2(260.73,127.04) v2(260.78,53.88) v2(260.82,26.54) v2(260.94,161.06) v2(260.88,106.42) v2(260.91,25.41) v2(261.47,77.74) v2(261.47,75.1) v2(261.47,74.49) v2(261.49,70.55) v2(261.47,50.54) v2(261.48,47.55) v2(261.49,37.86) v2(261.58,109.87) v2(261.56,103.45) v2(261.73,123.03) v2(261.75,117.48) v2(261.72,114.5) v2(261.72,107.29) v2(261.7,65.14) v2(261.73,10.36) v2(261.78,124.07) v2(261.77,120.5) v2(261.78,111.58) v2(262.18,106.39) v2(262.2,53.91) v2(262.44,101.03) v2(262.59,80.61) v2(262.74,85.77) v2(262.92,98.85) v2(262.94,88.38) v2(262.87,53.21) v2(263.07,151.02) v2(263.48,161.06) v2(263.63,106.44) v2(263.93,37.67) v2(264,65.07) v2(264.13,126.38) v2(264.26,10.37) v2(264.49,107.51) v2(264.59,36.67) v2(264.71,53.86) v2(264.77,106.55) v2(264.77,63.87) v2(264.87,80.11) v2(265.23,52.72) v2(265.28,65.07) v2(265.53,103.45) v2(265.5,102.44) v2(265.48,85.26) v2(266.02,161.06) v2(266.2,126.36) v2(266.3,10.37) v2(266.44,103.51) v2(266.96,107.51) v2(267.13,151.02) v2(267.12,102.42) v2(267.16,103.5) v2(267.26,85.26) v2(268.56,161.06) v2(268.74,158.6) v2(268.74,156.06) v2(268.74,153.52) v2(268.74,126.36) v2(268.99,150.82) v2(269.11,63.66) v2(269.14,35.15) v2(269.39,10.51) v2(269.64,107.5) v2(269.7,106.52) v2(269.71,105) v2(269.7,83.81) v2(269.67,80.97) v2(269.8,127.98) v2(270,32.25) v2(270.56,28.16) v2(270.56,24.99) v2(271.74,31.55) v2(271.74,29.01) v2(271.74,26.47) v2(271.74,23.93) v2(271.7,20.91) v2(271.73,18.61) v2(271.73,16.63) v2(271.72,12.61) v2(271.74,11.23) v3(1.58,162.19) v3(1.58,161.3) v3(1.58,160.42) v3(1.58,159.53) v3(1.7,152.67) v3(1.7,151.78) v3(1.7,150.89) v3(1.7,150) v3(1.7,149.11) v3(1.7,148.22) v3(1.7,147.33) v3(1.7,146.45) v3(1.7,145.56) v3(1.7,144.67) v3(1.7,143.78) v3(1.7,142.86) v3(2.46,162.19) v3(2.46,161.3) v3(2.46,160.42) v3(2.46,159.53) v3(2.59,152.67) v3(2.59,151.78) v3(2.59,150.89) v3(2.59,150) v3(2.59,149.11) v3(2.59,148.22) v3(2.59,147.33) v3(2.59,146.45) v3(2.59,145.56) v3(2.59,142.89) v3(3.35,162.19) v3(3.35,161.3) v3(3.35,160.42) v3(3.35,159.53) v3(3.48,150.89) v3(3.48,150) v3(3.48,149.11) v3(3.48,148.22) v3(3.48,147.33) v3(3.48,146.45) v3(3.48,145.56) v3(11.55,102.08) v3(11.53,101.21) v3(11.9,99.01) v3(11.9,98.12) v3(11.9,97.23) v3(11.9,96.37) v3(12.83,102.63) v3(12.78,99.01) v3(12.78,98.12) v3(12.78,97.23) v3(12.78,96.37) v3(13.51,162.73) v3(13.64,161.86) v3(13.64,160.97) v3(13.64,160.09) v3(14.4,163.59) v3(14.4,162.73) v3(14.53,161.86) v3(14.53,160.97) v3(14.53,160.11) v3(15.29,164.48) v3(15.29,163.59) v3(15.29,162.7) v3(16.18,164.48) v3(16.18,163.59) v3(16.18,162.7) v3(17.07,164.48) v3(17.07,163.59) v3(17.07,162.7) v3(17.96,164.48) v3(17.96,163.59) v3(17.96,162.7) v3(18.34,161.81) v3(18.34,160.95) v3(18.34,160.09) v3(25.94,26.95) v3(26.04,170.24) v3(26.24,169.16) v3(26.24,168.27) v3(26.24,167.4) v3(26.85,170.83) v3(26.85,169.94) v3(26.85,26.95) v3(27.1,169.05) v3(27.1,168.16) v3(27.09,167.27) v3(27.23,160.92) v3(27.74,170.83) v3(27.74,169.94) v3(27.69,161.69) v3(27.97,169.05) v3(27.97,168.16) v3(27.97,167.27) v3(28.12,160.92) v3(28.63,170.83) v3(28.63,169.94) v3(28.58,161.69) v3(29.01,160.92) v3(29.44,161.69) v3(29.9,160.92) v3(30.12,156.68) v3(30.3,161.69) v3(30.79,160.92) v3(31.01,156.68) v3(31.22,161.69) v3(31.67,160.92) v3(31.9,156.68) v3(32.08,161.69) v3(32.56,160.92) v3(32.97,161.69) v3(36.5,171.21) v3(36.5,170.32) v3(36.5,169.43) v3(37.39,171.21) v3(37.39,170.32) v3(37.39,169.43) v3(38.28,171.21) v3(38.28,170.32) v3(38.28,169.43) v3(39.17,171.21) v3(39.17,170.32) v3(39.17,169.43) v3(40.06,169.43) v3(47.3,161.3) v3(47.3,160.42) v3(48.18,161.3) v3(48.18,160.42) v3(49.07,161.3) v3(49.07,160.42) v3(49.96,161.3) v3(49.96,160.42) v3(50.85,161.3) v3(50.85,160.42) v3(51.87,161.3) v3(51.87,160.42) v3(51.87,159.53) v3(52.76,161.3) v3(52.76,160.42) v3(52.76,159.53) v3(53.65,161.3) v3(53.65,160.42) v3(53.65,159.53) v3(54.53,161.3) v3(54.53,160.42) v3(54.53,159.53) v3(55.42,161.3) v3(55.42,160.42) v3(58.85,166.46) v3(58.85,165.57) v3(58.85,164.69) v3(59.74,166.51) v3(59.74,165.62) v3(59.74,164.73) v3(60.63,166.51) v3(60.63,165.62) v3(60.63,164.73) v3(61.52,166.51) v3(61.52,165.62) v3(61.52,164.73) v3(62.41,166.51) v3(62.41,165.62) v3(62.41,164.69) v3(63.27,165.22) v3(69.36,163.52) v3(70.01,164.4) v3(70.22,163.5) v3(70.91,164.08) v3(76.51,173.7) v3(77.1,174.59) v3(77.39,173.7) v3(78.28,162.91) v3(78.56,164.81) v3(79.48,164.81) v3(80.26,157) v3(80.26,156.11) v3(81.13,157) v3(81.12,156.14) v3(82.98,156.43) v3(82.98,155.54) v3(83.62,163.42) v3(83.74,152.92) v3(83.74,152.03) v3(83.87,156.43) v3(83.87,155.54) v3(84.48,163.82) v3(84.48,162.93) v3(84.63,152.03) v3(85.37,163.82) v3(85.37,162.93) v3(86.44,167.2) v3(86.36,166.33) v3(86.36,165.45) v3(86.36,164.56) v3(86.36,163.67) v3(86.36,162.78) v3(87.25,166.33) v3(87.25,165.45) v3(87.25,164.56) v3(87.25,163.67) v3(87.4,167.2) v3(107.22,107.42) v3(107.21,106.49) v3(107.2,105.56) v3(108,111.98) v3(108,111.11) v3(108,106.9) v3(108,106.01) v3(108,105.12) v3(108,104.23) v3(108.76,107.33) v3(108.76,106.44) v3(108.76,105.55) v3(108.89,111.98) v3(108.86,111.11) v3(109.46,85.86) v3(109.65,107.33) v3(109.65,106.44) v3(109.65,105.55) v3(110.11,85.19) v3(110.56,85.94) v3(110.67,76.3) v3(111,85.15) v3(111.09,75.53) v3(111.51,85.9) v3(111.54,76.3) v3(111.84,67.25) v3(111.96,75.53) v3(112.43,76.3) v3(112.7,67.25) v3(112.86,75.54) v3(113.3,76.3) v3(113.56,67.25) v3(113.72,75.53) v3(114.43,67.25) v3(114.82,80.99) v3(114.79,80.05) v3(115.29,67.25) v3(115.62,80.6) v3(115.59,79.72) v3(115.6,78.83) v3(116.15,67.25) v3(116.39,80.19) v3(116.41,79.3) v3(116.38,78.43) v3(117.29,80.21) v3(117.31,79.32) v3(117.28,78.46) v3(118.11,79.72) v3(118.11,78.83) v3(118.92,80.23) v3(118.92,79.34) v3(118.92,78.42) v3(122.7,58.79) v3(123.59,58.79) v3(124.48,58.79) v3(125.36,58.79) v3(125.89,79.27) v3(125.91,67.32) v3(125.91,66.44) v3(125.91,65.55) v3(125.91,64.66) v3(126.8,79.21) v3(126.8,78.33) v3(126.8,67.32) v3(126.8,66.44) v3(126.8,65.55) v3(126.8,64.66) v3(127.69,79.17) v3(127.69,78.28) v3(127.69,77.39) v3(128.58,79.17) v3(128.58,78.28) v3(128.58,77.39) v3(128.58,76.5) v3(129.46,162.86) v3(129.46,79.17) v3(129.46,78.28) v3(129.46,77.39) v3(129.46,76.5) v3(130.1,163.44) v3(130.35,79.17) v3(130.35,78.28) v3(130.35,77.39) v3(130.35,76.5) v3(130.73,164.05) v3(131.24,79.17) v3(131.24,78.28) v3(131.24,77.39) v3(131.24,76.5) v3(133.27,78.71) v3(133.27,77.82) v3(134.93,90.31) v3(134.93,89.42) v3(134.93,88.53) v3(134.93,87.64) v3(136.53,73.75) v3(138.86,90.77) v3(138.86,89.88) v3(138.86,88.99) v3(139.75,90.77) v3(139.75,89.88) v3(139.75,88.99) v3(140.64,90.77) v3(140.64,89.88) v3(140.64,88.99) v3(144.83,101.44) v3(144.83,100.55) v3(145.47,103.22) v3(145.47,102.33) v3(145.72,108.17) v3(145.72,107.21) v3(145.72,101.44) v3(145.72,100.55) v3(146.36,103.22) v3(146.36,102.33) v3(146.61,108.17) v3(146.61,107.21) v3(146.61,101.44) v3(146.61,100.55) v3(147.24,103.22) v3(147.24,102.33) v3(147.5,107.03) v3(147.5,101.44) v3(147.5,100.55) v3(148.13,103.22) v3(148.13,102.33) v3(148.39,101.44) v3(148.39,100.55) v3(149.02,103.22) v3(149.02,102.33) v3(150.89,74.85) v3(151.78,74.66) v3(152.16,75.51) v3(152.71,74.65) v3(153.05,75.51) v3(153.93,75.51) v3(156.85,113.76) v3(156.85,112.87) v3(156.85,111.98) v3(156.85,111.09) v3(156.9,110.2) v3(156.9,109.31) v3(157.28,108.04) v3(157.28,107.15) v3(157.74,113.25) v3(157.74,112.36) v3(157.74,111.47) v3(157.74,110.58) v3(157.79,109.69) v3(157.79,108.81) v3(158.17,107.54) v3(158.67,110.2) v3(158.67,109.31) v3(158.67,108.42) v3(158.67,106.65) v3(159.18,107.54) v3(159.56,108.81) v3(160.88,63.85) v3(167.39,94.31) v3(168.17,94.71) v3(168.38,93.39) v3(168.5,79.06) v3(168.83,95.26) v3(169.06,94.34) v3(169.24,93.39) v3(169.73,95.17) v3(169.85,96.03) v3(169.95,94.34) v3(170.1,93.39) v3(170.31,79.96) v3(170.27,79.09) v3(170.64,95.19) v3(170.71,96.05) v3(170.84,94.34) v3(171.09,93.39) v3(171.13,79.08) v3(171.17,80) v3(171.5,95.26) v3(171.73,94.34) v3(171.96,93.39) v3(172.04,80) v3(171.99,79.14) v3(172.62,94.34) v3(172.82,93.39) v3(172.91,80.04) v3(173.74,93.39) v3(188.87,73.18) v3(189.35,72.39) v3(189.74,73.25) v3(190.28,72.49) v3(190.32,71.6) v3(190.66,73.32) v3(191.21,72.62) v3(191.19,71.73) v3(191.32,74.18) v3(191.69,73.38) v3(192.07,71.85) v3(192.29,72.7) v3(192.55,73.53) v3(203.23,62.72) v3(203.2,61.81) v3(203.2,60.92) v3(203.2,60.04) v3(204.11,62.72) v3(204.09,61.81) v3(204.09,60.92) v3(204.09,60.04) v3(205,62.72) v3(204.98,61.81) v3(204.98,60.92) v3(204.98,60.04) v3(216.18,68.92) v3(216.18,68.03) v3(216.18,67.14) v3(217.07,68.95) v3(217.07,68.06) v3(217.07,67.17) v3(217.07,66.28) v3(217.96,68.95) v3(217.96,68.06) v3(217.96,67.17) v3(217.96,66.28) v3(218.85,68.95) v3(218.85,68.06) v3(218.85,67.17) v3(218.85,66.28) v3(224.59,13.17) v3(224.59,12.29) v3(224.59,11.4) v3(224.82,83.7) v3(224.82,82.82) v3(225.48,13.17) v3(225.48,12.29) v3(225.48,11.4) v3(225.7,83.71) v3(225.7,82.82) v3(226.37,13.17) v3(226.37,12.29) v3(226.37,11.4) v3(226.72,83.71) v3(226.72,82.82) v3(227.25,13.17) v3(227.25,12.29) v3(227.25,11.4) v3(228.88,83.71) v3(228.88,82.82) v3(229.77,83.71) v3(229.77,82.82) v3(230.78,83.71) v3(230.78,82.82) v3(243.51,60.04) v3(246.43,21.18) v3(246.43,19.65) v3(246.43,18.76) v3(247.32,19.65) v3(247.32,18.76) v3(248.21,19.65) v3(248.21,18.76) v3(248.97,12.16) v3(249.1,19.65) v3(249.1,18.76) v3(249.86,12.16) v3(250.75,12.16) v3(250.93,21.17) v3(251.64,12.16) v3(251.92,21.12) v3(252.53,12.16) v3(252.91,21.05) v3(253.42,20.16) v3(253.42,12.16) v3(253.8,21.05) v3(255.5,57.35) v3(257.37,62.34) v3(257.37,61.46) v3(257.37,60.57) v3(257.96,50.86) v3(257.96,49.97) v3(258.37,36.29) v3(258.37,35.4) v3(259.23,37.23) v3(259.26,36.29) v3(259.26,35.4) v3(260.15,36.34) v3(260.15,35.45) v4(238.23,36.7) v4(238.23,35.35) v4(238.23,32.13) v4(238.26,33.43) v4(238.26,30.82) v4(239.52,36.67) v4(239.52,36.02) v4(239.52,32.77) v4(240.17,36.67) v4(240.17,35.37) v4(240.46,51.2) v4(241.1,40.62) v4(241.47,32.77) v4(241.73,52.59) v4(242.11,34.72) v4(242.24,52.6) v4(242.75,52.6) v4(242.77,29.56) v4(243.33,49.64) v4(243.44,33.43) v4(243.45,32.77) v4(243.54,51.12) v4(243.54,50.61) v4(243.54,50.1) v4(243.46,30.17) v4(244.07,35.37) v4(244.08,32.12) v4(244.08,30.82) v4(244.07,30.19) v4(244.07,29.53) v4(245.37,32.12) v4(245.4,29.54) v4(246.02,36.67) v4(246.03,35.36) v4(246.02,34.69) v4(265.99,22.83) v6(19.47,129.96) v6(19.46,127.28) v6(19.48,125.82) v6(19.99,132.48) v6(20.63,132.5) v6(20.94,127.98) v6(22.56,129.57) v6(23.22,145.32) v6(23.65,128.64) v6(23.87,145.32) v6(23.86,131.93) v6(23.86,131.14) v6(24.32,127.15) v6(24.52,145.32) v6(24.51,132.72) v6(25.32,132.5) v6(25.36,146.83) v6(25.62,122.79) v6(26.06,123.23) v6(26.19,131.94) v6(27.13,131.94) v6(27.1,131.32) v6(27.09,130.69) v6(27.09,130.05) v6(28.97,124.33) v6(29.26,144.41) v6(29.26,143.65) v6(29.26,142.89) v6(29.26,142.13) v6(29.29,136.79) v6(29.29,136.16) v6(29.29,135.52) v6(29.29,134.89) v6(29.39,139.33) v6(29.39,138.7) v6(29.85,131.94) v6(29.84,131.32) v6(29.84,130.69) v6(29.84,130.05) v6(29.9,136.79) v6(29.9,136.16) v6(29.9,135.52) v6(29.9,134.89) v6(29.87,133.24) v6(29.87,132.59) v6(30.02,139.33) v6(30.02,138.7) v6(30.75,132.57) v6(31.04,126.06) v6(31.06,128.03) v6(31.12,124.02) v6(31.67,132.6) v6(32.56,132.6) v6(32.56,131.94) v6(32.59,131.32) v6(32.58,130.69) v6(32.58,130.05) v6(33.58,144.41) v6(33.58,143.65) v6(33.58,142.89) v6(33.58,142.13) v6(34.21,136.79) v6(34.21,136.16) v6(34.21,135.52) v6(34.21,134.89) v6(35.32,131.32) v6(35.32,130.64) v6(35.31,130.03) v6(35.48,136.79) v6(35.48,136.16) v6(35.48,135.52) v6(35.48,134.89) v6(35.53,123.69) v6(37.14,132.55) v6(37.15,133.22) v6(38.05,132.59) v6(38.05,131.94) v6(38.07,131.32) v6(38.07,130.69) v6(38.07,130.05) v6(38.28,144.41) v6(38.28,143.65) v6(38.28,142.89) v6(38.28,142.13) v6(39.04,136.79) v6(39.04,136.16) v6(39.04,135.52) v6(39.04,134.89) v6(38.98,132.57) v6(39.02,124.47) v6(39.07,122.56) v6(39.08,120.52) v6(39.88,132.57) v6(40.79,133.23) v6(40.82,131.32) v6(40.81,130.69) v6(40.81,130.05) v6(41.58,137.05) v6(41.58,136.41) v6(41.58,135.78) v6(41.58,135.14) v6(41.73,124.45) v6(41.73,123.89) v6(43.55,131.21) v6(43.55,129.99) v6(43.74,142.51) v6(43.74,141.87) v6(43.74,141.24) v6(43.74,140.6) v6(43.74,139.97) v6(43.74,139.33) v6(43.74,138.7) v6(44.02,121.25) v6(44.15,137.05) v6(44.15,136.29) v6(44.15,135.52) v6(44.12,134.89) v6(44.12,134.25) v6(44.06,124.47) v6(46.28,132.6) v6(46.28,131.97) v6(46.3,131.32) v6(46.3,130.69) v6(46.6,124.47) v6(46.58,123.9) v6(47.22,132.6) v6(47.68,142.76) v6(47.68,142.2) v6(47.68,141.42) v6(47.68,140.86) v6(47.68,140.22) v6(47.68,139.66) v6(47.68,138.96) v6(47.68,138.4) v6(47.8,137.05) v6(47.8,136.29) v6(47.8,135.52) v6(47.8,134.89) v6(47.8,134.25) v6(48.11,132.6) v6(48.63,126.04) v6(49.01,133.22) v6(49.02,132.55) v6(49.04,131.32) v6(49.04,130.67) v6(49.05,130.01) v6(49.91,142.81) v6(49.91,142.25) v6(49.91,141.47) v6(49.91,140.91) v6(49.91,140.27) v6(49.91,139.71) v6(49.91,139.08) v6(49.91,138.52) v6(49.96,132.6) v6(50.89,133.22) v6(50.85,132.6) v6(51.23,137.05) v6(51.23,136.29) v6(51.23,135.52) v6(51.23,134.89) v6(51.23,134.25) v6(51.49,124.32) v6(51.74,132.55) v6(51.73,123.81) v6(51.77,131.89) v6(51.79,131.32) v6(51.78,130.62) v6(52.71,132.6) v6(53.62,132.6) v6(53.66,123.51) v6(54.05,143.32) v6(54.05,142.76) v6(54.05,141.98) v6(54.05,141.42) v6(54.05,140.53) v6(54.05,139.97) v6(54.05,139.34) v6(54.05,138.78) v6(54.28,136.29) v6(54.28,135.52) v6(54.28,134.89) v6(54.28,134.25) v6(54.53,133.24) v6(54.53,132.6) v6(54.51,131.92) v6(54.53,131.26) v6(54.53,130.69) v6(56.17,126.03) v6(57.18,131.31) v6(57.15,129.22) v6(57.99,132.16) v6(58.64,137.67) v6(59.29,137.67) v6(59.29,129.8) v6(61.24,134.52) v6(61.24,132.95) v6(61.24,131.37) v6(61.24,129.8) v6(62.26,125.58) v6(62.81,126.89) v6(62.81,125.64) v6(62.85,135.7) v6(62.85,134.13) v6(63.27,129.01) v6(63.37,125.64) v6(63.57,148.61) v6(64.57,143.88) v6(64.69,146.95) v6(89.15,132.6) v6(89.15,131.97) v6(89.71,131.97) v6(91.59,143.84) v6(91.67,138.42) v6(92.23,138.44) v6(92.23,131.84) v6(92.32,150.29) v6(92.25,147.94) v6(92.3,145.5) v6(92.3,143.9) v6(92.3,141.5) v6(93.1,145.5) v6(93.94,145.51) v6(93.9,143.1) v6(95.15,162.45) v6(95.15,161.89) v6(95.5,138.3) v6(96.29,145.53) v6(96.32,139.08) v6(97.71,131.49) v6(99.01,138.52) v6(99.9,126.89) v6(100,146.7) v6(100,145.56) v6(101.93,128.69) v6(101.93,127.91) v6(102.03,129.25) v6(102.3,126.98) v6(102.28,126.42) v6(102.54,128.82) v6(102.66,127.89) v6(104.06,184.02) v6(104.7,123.61) v6(104.7,122.14) v6(106.73,128.74) v6(106.73,127.91) v6(106.73,127.09) v6(107.31,130.6) v6(107.49,125.49) v6(107.49,123.08) v6(109.09,184.06) v6(109.75,182.2) v6(110.69,155.11) v6(111.56,183.99) v6(112.14,183.99) v6(113.41,113.07) v6(113.41,112.51) v6(113.39,99.68) v6(114.48,177.09) v6(114.71,153.53) v6(116.36,184.04) v6(117.68,150.87) v6(118.24,150.87) v6(119.43,150.87) v6(120.14,176.27) v6(120.21,177.07) v6(121.65,158.58) v6(121.92,127.09) v6(122.35,183.63) v6(122.68,127.09) v6(122.71,125.49) v6(122.91,183.63) v6(123.74,128.93) v6(124.21,160.6) v6(128.68,161.05) v6(128.97,127.01) v6(129.26,161.05) v6(133.2,100.32) v6(133.76,100.32) v6(136.06,110.16) v6(143.59,177.79) v6(146.08,145.15) v6(152.42,154.34)
