# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQ13: length 81.4
  TOP w0.159: v1(26.02,127.02) v6(26.02,128.02) ; v2(37.83,72.04) 37.45,72.41 37.04,72.41 36.87,72.24 36.87,72.01 37.52,71.36 38.7,71.36 38.81,71.25 38.81,70.74 39.63,69.93 CON1600.25
  IN1 w0.076: v6(26.02,128.02) 25.68,127.68 25.68,126.65 23.6,124.57 22.05,124.57 21.11,123.64 20.07,123.64 19.16,122.73 18.9,122.73
  IN1 w0.108: v2(37.83,72.04) 38.58,72.78 38.58,75.01 35.59,77.99 35.59,79.31 34.8,80.1 33.35,80.1 19.17,94.28 19.17,100.99 18.09,102.07 18.09,121.08 18.36,121.35 18.36,122.19 18.9,122.73
  BOTTOM w0.076: U0300.BK5 25.95,128.02 v6(26.02,128.02)
  BOTTOM w0.159: v2(37.83,72.04) 37.83,70.44 37.38,69.98 CON1601.24
M_CHA_DQ14: length 81.7
  TOP w0.159: v6(21.87,122.36) 21.87,121.81 v1(22.12,121.56) ; CON1600.42 43.88,76.24 43.04,75.4 42.63,75.4 42.29,75.06 42.29,73.7 42.16,73.57 41.78,73.57 41.68,73.67 41.68,74.01 41.45,74.24 v2(41.13,74.24)
  IN1 w0.108: v6(21.87,122.36) 22.04,122.19 22.23,122.19 22.46,122.42 22.59,122.42 22.71,122.29 22.71,122.17 21.67,121.12 20.69,121.12 20.34,120.77 20.34,103 21.42,101.92 21.42,95.22 33.53,83.11 35.78,83.11 38.47,80.42 38.47,80.06 38.94,79.59 38.94,77.84 40.84,75.94 40.84,75.38 40.94,75.28 41.5,75.28 41.67,75.11 41.67,72.27 41.58,72.18 41.33,72.18 41.25,72.26 41.25,72.86 40.56,73.55 40.56,74.11 40.69,74.24 v2(41.13,74.24)
  BOTTOM w0.076: v6(21.87,122.36) 22.7,122.36 23.65,123.31 23.65,123.82 24.33,124.5 25.01,124.5 25.18,124.67 U0300.BK1
  BOTTOM w0.159: CON1601.41 41.63,74.73 v2(41.13,74.24)
M_CHA_DQ15: length 80.9
  TOP w0.159: v6(22.22,122.8) 21.95,123.06 21.95,123.13 v1(21.7,123.38) ; CON1600.38 42.88,76.48 43.13,76.22 43.13,76.04 42.96,75.87 42.84,75.87 42.55,76.16 42.38,76.16 42.21,76 42.21,75.88 42.31,75.79 42.31,75.63 42.16,75.48 41.96,75.48 41.85,75.59 41.69,75.59 41.53,75.43 41.53,75.25 41.77,75.01 41.77,74.78 41.62,74.63 41.37,74.63 v2(41.13,74.87)
  IN1 w0.108: v6(22.22,122.8) 21.76,122.8 21.65,122.69 21.18,122.69 21.12,122.63 21.12,122.06 21.25,121.93 21.82,121.93 21.89,121.86 21.89,121.66 21.81,121.58 21.11,121.58 20.78,121.91 20.78,122.62 20.68,122.73 20.48,122.73 19.94,122.19 19.94,121.86 20.02,121.78 20.39,121.78 20.52,121.64 20.52,121.35 20.42,121.24 20.1,121.24 20,121.15 20,102.86 21.08,101.78 21.08,95.08 33.39,82.77 35.65,82.77 38,80.42 38,79.65 38.1,79.55 38.5,79.55 38.6,79.45 38.6,79.31 38.5,79.22 38.07,79.22 38,79.14 38,78.96 38.1,78.86 38.53,78.86 38.6,78.79 38.6,78.58 38.54,78.52 38.1,78.52 38.02,78.45 38.02,78.28 38.12,78.19 38.5,78.19 38.6,78.09 38.6,77.7 40.49,75.81 40.49,74.77 40.59,74.67 40.92,74.67 v2(41.13,74.87)
  BOTTOM w0.076: U0300.BK2 25.38,125.74 24.72,125.08 24.72,124.85 24.53,124.67 24.27,124.67 23.49,123.89 23.49,123.41 22.92,122.85 22.88,122.85 22.83,122.8 v6(22.22,122.8)
  BOTTOM w0.159: v2(41.13,74.87) 41.13,74.9 40.63,75.4 CON1601.37
M_CHA_DQ16: length 77.6
  TOP w0.159: CON1600.45 44.63,69.1 44.63,70.22 v2(42.75,72.1) ; v1(25.73,125.47) 26.38,126.12 26.38,126.22 v6(26.86,126.7)
  IN1 w0.076: 20.67,120.68 20.9,120.91 21.81,120.91 25.19,124.29 25.19,125.03 v6(26.86,126.7)
  IN1 w0.108: v2(42.75,72.1) 42.67,72.18 42.11,72.18 42,72.3 42,75.25 39.27,77.98 39.27,79.73 38.81,80.2 38.81,80.56 35.92,83.45 33.67,83.45 21.76,95.36 21.76,102.06 20.67,103.14 20.67,120.68
  BOTTOM w0.076: v6(26.86,126.7) 27,126.7 U0300.BG4
  BOTTOM w0.159: v2(42.75,72.1) 42.88,71.97 CON1601.46
M_CHA_DQ17: length 78.1
  TOP w0.159: v6(26.89,127.34) v1(26.89,128.03) ; CON1600.49 45.63,69.92 42.81,72.74 v2(42.75,72.74)
  IN1 w0.076: 21.01,116.22 21.01,120.27 21.48,120.74 21.88,120.74 25.36,124.22 25.36,124.68 27.23,126.54 27.23,126.99 v6(26.89,127.34)
  IN1 w0.108: v2(42.75,72.74) 42.34,73.14 42.34,75.39 39.61,78.12 39.61,79.87 39.14,80.34 39.14,80.7 36.06,83.78 33.81,83.78 22.09,95.5 22.09,102.2 21.01,103.28 21.01,116.22
  BOTTOM w0.076: U0300.BG5 26.99,127.34 v6(26.89,127.34)
  BOTTOM w0.159: CON1601.50 43.88,71.61 v2(42.75,72.74)
M_CHA_DQ18: length 78.5
  TOP w0.159: CON1600.50 45.87,77.3 45.87,76.14 45.51,75.78 44.6,75.78 43.08,74.26 v2(42.75,74.26) ; v1(27.37,125.35) 28.07,126.05 v6(28.49,126.05)
  IN1 w0.076: v6(28.49,126.05) 27.58,125.14 26.31,125.14 25.69,124.51 25.69,124.08 21.75,120.14
  IN1 w0.108: 21.75,120.14 21.75,103.5 23.56,101.69 23.56,101.1 23.37,100.92 23.37,100.41 23.5,100.28 23.63,100.28 23.76,100.15 23.76,99.91 23.63,99.79 23.5,99.79 23.37,99.66 23.37,99.42 23.5,99.29 23.63,99.29 23.76,99.17 23.76,98.97 23.63,98.84 23.5,98.84 23.37,98.71 23.37,98.51 23.5,98.39 23.63,98.39 24.05,97.97 24.05,94.49 34.09,84.46 34.22,84.46 34.32,84.55 34.32,84.73 34.45,84.85 34.82,84.85 34.95,84.73 34.95,84.61 35.1,84.46 36.34,84.46 39.82,80.98 39.82,80.62 40.28,80.15 40.28,78.4 43.16,75.53 43.16,74.67 v2(42.75,74.26)
  BOTTOM w0.076: U0300.BF4 28.49,126.63 v6(28.49,126.05)
  BOTTOM w0.159: CON1601.49 43.63,76.48 43.23,76.09 43.23,74.56 42.93,74.26 v2(42.75,74.26)
M_CHA_DQ19: length 77
  TOP w0.159: v1(27.5,126.82) 27.94,126.82 v6(28.48,127.37) ; CON1600.46 44.88,76.48 44.56,76.16 44.4,76.16 43.13,74.89 v2(42.75,74.89)
  IN1 w0.076: 21.35,120.23 21.7,120.58 21.95,120.58 25.52,124.15 25.52,124.6 28.29,127.37 v6(28.48,127.37)
  IN1 w0.108: 21.35,120.23 21.35,103.42 22.98,101.79 22.98,101.3 22.55,100.87 22.55,100.43 22.69,100.29 22.91,100.29 23.04,100.16 23.04,99.95 22.91,99.82 22.56,99.82 22.43,99.7 22.43,99.51 22.56,99.39 22.91,99.39 23.04,99.26 23.04,99.09 22.91,98.96 22.56,98.96 22.43,98.83 22.43,98.57 22.56,98.44 22.91,98.44 23.57,97.78 23.57,96.64 23.4,96.47 23.09,96.47 22.91,96.29 22.91,96.1 22.98,96.03 23.47,96.03 23.57,95.93 23.57,94.49 33.95,84.12 36.2,84.12 39.48,80.84 39.48,80.48 39.94,80.01 39.94,78.26 42.75,75.46 v2(42.75,74.89)
  BOTTOM w0.076: U0300.BF5 28.4,127.37 v6(28.48,127.37)
  BOTTOM w0.159: v2(42.75,74.89) 42.75,75.3 42.63,75.42 CON1601.45
M_CHA_DQ20: length 78.1
  TOP w0.159: v6(27.23,123.76) 26.58,123.11 v1(26.58,122.33) ; v2(44.93,75.25) 45.53,75.25 46.35,76.07 47.46,76.07 47.88,76.48 CON1600.58
  IN1 w0.108: v6(27.23,123.76) 27.15,123.68 27.15,123.6 24.16,120.61 24.16,113.84 24.44,113.56 25.02,113.56 25.15,113.43 25.15,113.13 25.11,113.09 24.52,113.09 24.39,112.97 24.39,112.79 24.52,112.67 25.22,112.67 25.5,112.4 25.5,98.93 27.8,96.64 27.8,93.45 27.89,93.36 28.03,93.36 28.25,93.57 28.39,93.57 28.49,93.47 28.49,93.33 28.27,93.12 28.27,92.98 28.37,92.88 28.51,92.88 28.72,93.09 28.86,93.09 28.96,92.99 28.96,92.86 28.75,92.64 28.75,92.5 28.85,92.4 28.99,92.4 29.2,92.62 29.34,92.62 29.44,92.52 29.44,92.38 29.35,92.3 29.22,92.17 29.22,92.03 29.32,91.93 29.46,91.93 29.68,92.14 29.82,92.14 29.91,92.04 29.91,91.9 29.7,91.69 29.7,91.55 29.8,91.45 29.94,91.45 30.15,91.67 30.29,91.67 30.39,91.57 30.39,91.43 30.18,91.21 30.18,91.07 30.27,90.98 30.41,90.98 30.63,91.19 30.77,91.19 30.87,91.09 30.87,90.95 30.65,90.74 30.65,90.6 30.75,90.5 30.89,90.5 31.1,90.71 31.24,90.71 31.34,90.61 31.34,90.48 31.13,90.26 31.13,90.12 31.23,90.02 31.37,90.02 31.43,90.08 31.75,90.08 31.97,89.86 31.97,89.28 33.93,87.32 35.71,87.32 41.42,81.61 41.42,81.26 41.88,80.79 41.88,80.3 42.29,79.9 42.29,78.62 44.73,76.18 44.73,75.45 v2(44.93,75.25)
  BOTTOM w0.076: v6(27.23,123.76) 27.43,123.97 27.54,123.97 27.71,124.14 27.71,125.37 U0300.BG2
  BOTTOM w0.159: v2(44.93,75.25) 45.31,75.25 46.13,76.06 CON1601.59
M_CHA_DQ21: length 78
  TOP w0.159: CON1600.62 48.88,76.26 48.3,75.68 46.71,75.68 45.64,74.61 v2(44.93,74.61)
  IN1 w0.076: v6(27.34,124.35) 27.13,124.13 27.08,124.13 26.56,123.61 25.92,123.61 25.29,122.98 25.29,122.96 24.77,122.44
  IN1 w0.108: 24.77,122.44 23.59,121.25 23.59,113.96 23.48,113.85 23.32,113.85 23.21,113.74 23.21,113.53 23.32,113.42 23.48,113.42 23.59,113.31 23.59,113.09 23.48,112.99 23.32,112.99 23.21,112.88 23.21,112.66 23.32,112.55 23.48,112.55 23.59,112.45 23.59,112.23 23.48,112.12 23.32,112.12 23.21,112.02 23.21,111.8 23.32,111.69 23.48,111.69 23.59,111.58 23.59,111.37 23.48,111.26 23.32,111.26 23.21,111.15 23.21,110.94 23.32,110.83 24.76,110.83 25,110.59 25,108.16 24.89,108.05 24.23,108.05 24.1,107.92 24.1,107.74 24.23,107.62 24.89,107.62 25,107.51 25,107.29 24.89,107.18 24.51,107.18 24.38,107.06 24.38,106.88 24.51,106.75 24.77,106.75 25,106.53 25,98.91 27.43,96.47 27.43,93.34 33.79,86.98 35.57,86.98 41.08,81.47 41.08,81.12 41.55,80.65 41.55,80.16 41.95,79.76 41.95,78.48 44.4,76.04 44.4,74.57 44.52,74.44 44.76,74.44 v2(44.93,74.61)
  BOTTOM w0.076: U0300.BG1 v6(27.34,124.35)
  BOTTOM w0.159: CON1601.63 47.13,75.41 46.33,74.61 v2(44.93,74.61)
M_CHA_DQ22: length 75.6
  TOP w0.159: v2(46.41,71.34) 46.56,71.34 47.56,70.33 47.71,70.33 48.13,69.91 48.13,69.11 CON1600.59
  IN1 w0.108: v6(28.46,124.03) 28.38,124.03 27.23,122.88 26.99,122.88 25.6,121.49 25.6,114.57 26.17,114 26.17,99.25 28.95,96.46 28.95,93.95 33.11,89.79 34.91,89.79 38.22,86.48 38.22,85.75 40.65,83.33 41.78,83.33 42.58,82.53 42.58,80.56 42.96,80.18 42.96,78.9 45.79,76.08 45.79,72.97 44.9,72.08 44.9,71.9 45.23,71.58 45.41,71.58 46.51,72.69 46.82,72.69 46.95,72.56 46.95,71.12 46.87,71.04 46.7,71.04 v2(46.41,71.34)
  BOTTOM w0.076: U0300.BF1 28.08,124.41 v6(28.46,124.03)
  BOTTOM w0.159: CON1601.58 45.88,70.81 v2(46.41,71.34)
M_CHA_DQ23: length 77.5
  TOP w0.159: v2(46.41,71.97) 46.47,71.97 47.73,70.72 47.88,70.72 48.38,70.22 48.82,70.22 49.13,69.92 CON1600.63 ; v6(28.48,124.6) 28.48,124.83 v1(28.9,125.26)
  IN1 w0.108: v2(46.41,71.97) 45.57,71.14 44.75,71.14 44.44,71.44 44.44,72.1 45.45,73.1 45.45,75.94 42.62,78.76 42.62,80.04 42.24,80.42 42.24,81.59 41.93,81.9 41.6,81.9 35.85,87.65 34.07,87.65 32.31,89.42 32.31,90.13 28.59,93.84 28.59,96.34 25.84,99.1 25.84,113.3 24.5,114.64 24.5,120.67 26.9,123.08 27.15,123.08 27.97,123.89 27.97,124.32 28.24,124.6 v6(28.48,124.6)
  BOTTOM w0.076: v6(28.48,124.6) 28.48,125.34 U0300.BF2
  BOTTOM w0.159: v2(46.41,71.97) 46.88,71.5 CON1601.62
M_CHA_DQ24: length 78.2
  TOP w0.159: v2(47.9,71.27) 48.25,71.27 48.36,71.16 48.36,70.79 48.52,70.63 48.72,70.63 48.77,70.68 49,70.68 49.36,70.31 50,70.31 50.13,70.18 CON1600.67
  IN1 w0.108: v6(27.33,121.54) 27.19,121.4 27.19,114.88 27.52,114.55 27.52,101.38 36.31,92.59 36.31,90.99 43.93,83.37 43.93,81.22 45.46,79.69 45.46,78.31 48.68,75.09 48.68,69.43 48.59,69.34 48.03,69.34 47.9,69.46 v2(47.9,71.27)
  BOTTOM w0.076: U0300.BD2 29.86,125.73 30.21,125.38 30.21,122.22 29.22,121.23 27.91,121.23 27.6,121.54 v6(27.33,121.54)
  BOTTOM w0.159: v1(27.99,120.64) 27.33,121.3 v6(27.33,121.54) ; v2(47.9,71.27) 47.88,71.25 CON1601.66
M_CHA_DQ25: length 80.5
  TOP w0.159: v2(47.92,71.95) 47.92,72.27 48.08,72.43 48.49,72.43 48.79,72.13 48.79,71.43 49.52,70.7 50.34,70.7 51.13,69.92 CON1600.71
  IN1 w0.108: v2(47.92,71.95) 47.54,71.57 47.39,71.57 47.28,71.68 47.28,72.81 47.41,72.94 47.85,72.94 47.98,72.81 47.98,72.72 48.1,72.6 48.25,72.6 48.35,72.69 48.35,74.95 45.12,78.17 45.12,79.55 43.59,81.08 43.59,83.23 35.92,90.9 33.43,90.9 31.39,92.95 31.39,97.04 27.18,101.24 27.18,114.41 26.61,114.99 26.61,121.67 27.04,122.1 v6(27.33,122.1)
  BOTTOM w0.076: v6(27.33,122.1) 27.53,122.1 28.01,121.61 29.17,121.61 30.05,122.49 30.05,124.9 U0300.BD1
  BOTTOM w0.159: v6(27.33,122.1) 26.68,122.1 26.14,121.56 v1(26.14,121.23) ; CON1601.70 48.88,69.92 48.34,70.45 48.34,71.53 v2(47.92,71.95)
M_CHA_DQ26: length 80.1
  TOP w0.159: CON1600.84 54.38,75.02 52.53,73.18 v2(50.89,73.18) ; v1(30.4,126.33) 30.66,126.33 v6(31.04,126.71)
  IN1 w0.108: v6(31.04,126.71) 30.58,126.25 30.58,125.7 30.06,125.18 30.06,122.94 29.12,122 29.12,102.01 44.2,86.93 44.2,86.77 44.01,86.59 44.01,86.43 44.24,86.2 44.4,86.2 44.58,86.39 44.74,86.39 44.97,86.16 44.97,86.01 44.78,85.82 44.78,85.67 45.01,85.44 45.16,85.44 45.35,85.63 45.5,85.63 45.8,85.32 45.8,82.3 45.53,82.03 45.53,81.89 45.63,81.79 45.77,81.79 46.04,82.07 46.18,82.07 46.28,81.97 46.28,81.83 46.01,81.55 46.01,81.42 46.1,81.32 46.24,81.32 46.52,81.59 46.66,81.59 46.76,81.49 46.76,81.35 46.54,81.14 46.54,81 46.83,80.71 47.53,80.71 48.04,80.21 48.04,77.96 51.31,74.69 51.31,73.6 v2(50.89,73.18)
  BOTTOM w0.076: v6(31.04,126.71) 30.92,126.71 U0300.BC4
  BOTTOM w0.159: v2(50.89,73.18) 51.61,73.9 51.61,75.05 52.13,75.56 CON1601.83
M_CHA_DQ27: length 79.8
  TOP w0.159: v2(50.89,73.81) 52.16,75.08 52.75,75.08 52.83,75.16 52.83,75.38 52.63,75.57 52.63,75.73 52.87,75.96 53.04,75.96 53.32,75.67 53.53,75.67 53.73,75.88 53.73,76.11 53.38,76.47 CON1600.80 ; v1(32.08,126.92) 31.64,127.36 v6(31.04,127.36)
  IN1 w0.108: v2(50.89,73.81) 50.51,73.81 49.94,74.38 49.94,74.65 50.01,74.73 50.17,74.73 50.24,74.81 50.24,75.28 47.7,77.82 47.7,80.07 47.42,80.35 46.59,80.35 45.17,81.78 45.17,82.95 45.34,83.12 45.34,84.42 43.61,86.15 43.61,87.04 42.02,88.63 41.51,88.63 41.28,88.86 41.28,89.37 41.13,89.53 40.98,89.53 40.83,89.38 40.68,89.38 40.53,89.53 40.53,89.69 40.67,89.83 40.67,89.98 40.51,90.14 40.37,90.14 40.22,89.99 40.07,89.99 39.91,90.14 39.91,90.3 40.06,90.44 40.06,90.59 39.91,90.75 39.75,90.75 39.56,90.55 39.41,90.55 39.25,90.7 39.25,90.86 39.45,91.05 39.45,91.21 39.29,91.36 39.14,91.36 38.77,90.99 38.63,90.99 38.45,91.17 38.45,91.28 38.84,91.66 38.84,91.82 28.78,101.87 28.78,122.01 29.79,123.03 29.79,126.11 v6(31.04,127.36)
  BOTTOM w0.076: v6(31.04,127.36) 30.92,127.36 U0300.BC5
  BOTTOM w0.159: CON1601.79 51.13,74.05 v2(50.89,73.81)
M_CHA_DQ28: length 79.6
  TOP w0.159: v1(30.07,127.86) 29.94,127.86 v6(29.45,127.36) ; CON1600.66 49.88,76.48 49.61,76.21 49.38,76.21 48,74.84 46.42,74.84 46.07,74.49 46.07,74.24 46.43,73.88 46.61,73.88 v2(46.81,74.08)
  IN1 w0.108: v6(29.45,127.36) 29.08,127 29.08,126.35 29.4,126.03 29.4,123.84 29.2,123.64 28.28,123.64 27.32,122.68 27.07,122.68 25.94,121.55 25.94,114.71 26.51,114.14 26.51,99.41 29.43,96.49 29.43,93.96 33.25,90.13 35.45,90.13 39.47,86.11 39.47,85.97 39.18,85.69 39.18,85.55 39.28,85.45 39.42,85.45 39.67,85.7 39.81,85.7 39.91,85.6 39.91,85.46 39.66,85.21 39.66,85.07 41.04,83.69 41.89,83.69 42.92,82.66 42.92,80.7 43.3,80.32 43.3,79.04 46.12,76.22 46.12,75.22 46.33,75.02 46.81,75.02 46.93,74.9 46.93,74.74 46.64,74.46 46.64,74.25 v2(46.81,74.08)
  BOTTOM w0.076: v6(29.45,127.36) 29.53,127.36 U0300.BD5
  BOTTOM w0.159: v2(46.81,74.08) 48.13,75.39 CON1601.67
M_CHA_DQ29: length 79.9
  TOP w0.159: CON1600.70 50.88,76.47 50.23,75.83 49.54,75.83 48.24,74.53 48.24,73.76 47.92,73.45 v2(46.81,73.45) ; v6(29.46,126.71) 29.38,126.8 v1(28.86,126.8)
  IN1 w0.108: v6(29.46,126.71) 29.6,126.58 29.6,123.59 29.45,123.44 28.35,123.44 27.4,122.49 27.15,122.49 26.27,121.61 26.27,114.85 26.85,114.28 26.85,101.1 31.05,96.9 31.05,92.81 33.33,90.53 35.59,90.53 41.66,84.46 41.89,84.46 43.25,83.09 43.25,80.84 43.64,80.45 43.64,80.05 43.79,79.9 44.3,79.9 44.78,79.41 44.78,78.03 46.57,76.25 46.57,75.52 46.69,75.4 47.41,75.4 47.67,75.15 47.67,73.64 47.47,73.45 v2(46.81,73.45)
  BOTTOM w0.076: v6(29.46,126.71) 29.53,126.71 U0300.BD4
  BOTTOM w0.159: v2(46.81,73.45) 46.87,73.45 49.13,75.7 CON1601.71
M_CHA_DQ30: length 78.1
  TOP w0.159: v2(51.49,70.49) 51.21,70.77 51.21,71.01 51.5,71.31 52.08,71.31 53.13,70.26 CON1600.79
  IN1 w0.108: v6(31.04,124.64) 30.68,124.28 30.68,122.65 29.79,121.76 29.79,102.29 46.61,85.47 46.61,82.59 48.71,80.49 48.71,78.24 52.02,74.93 52.02,67.82 51.88,67.68 51.62,67.68 51.49,67.81 v2(51.49,70.49)
  BOTTOM w0.076: U0300.BC1 30.6,125.09 v6(31.04,124.64)
  BOTTOM w0.159: CON1601.80 51.38,70.38 v2(51.49,70.49) ; v1(30.74,123.03) 30.56,123.21 30.56,124.15 v6(31.04,124.64)
M_CHA_DQ31: length 78.5
  TOP w0.159: v6(31.03,125.41) 31.22,125.41 v1(31.62,125.01) ; CON1600.83 54.13,70.3 54.03,70.39 53.55,70.39 52.24,71.69 52.24,72.3 52.06,72.48 51.66,72.48 51.52,72.34 v2(51.52,71.77)
  IN1 w0.108: v2(51.52,71.77) 51.52,71.12 50.49,70.08 50.25,70.08 50.08,70.25 50.08,70.44 51.11,71.47 51.11,71.94 51.68,72.51 51.68,74.79 48.38,78.1 48.38,80.35 46.28,82.45 46.28,85.33 29.45,102.15 29.45,121.85 30.48,122.88 30.48,124.86 v6(31.03,125.41)
  BOTTOM w0.076: v6(31.03,125.41) 30.92,125.41 U0300.BC2
  BOTTOM w0.159: v2(51.52,71.77) 51.84,71.77 52.38,71.24 52.38,69.1
M_CHA_DQ32: length 81.8
  TOP w0.159: CON1600.187 82.13,69.93 81.89,70.17 81.45,70.17 80.2,71.42 80.16,71.42 v2(79.93,71.64)
  IN1 w0.108: v2(79.93,71.64) 79.93,71.92 80.04,72.02 80.29,72.02 80.47,71.85 80.47,70.96 80.59,70.83 80.69,70.83 81.01,71.15 81.01,76.13 81.64,76.76 82.22,76.76 82.57,77.12 82.57,79.56 83.35,80.34 83.35,88.82 71.31,100.86 70.06,100.86 65.09,105.84 62.7,105.84 55.1,113.44 55.1,116.37 48.65,122.82 v6(48.65,122.87)
  BOTTOM w0.076: U0300.AB1 47.46,123.46 v1(47.87,123.05) 48.05,122.87 v6(48.65,122.87)
  BOTTOM w0.159: v2(79.93,71.64) 78.88,70.58 CON1601.182
M_CHA_DQ33: length 82.3
  TOP w0.159: v2(79.93,71.01) 80.06,71.01 81.13,69.94 CON1600.183
  IN1 w0.108: v6(48.64,123.47) 49.07,123.04 49.07,122.68 55.44,116.32 55.44,113.58 62.81,106.2 65.2,106.2 70.2,101.2 71.45,101.2 83.69,88.96 83.69,80.15 83.41,79.88 83.41,78.61 82.91,78.1 82.91,76.98 82.36,76.43 81.78,76.43 81.35,75.99 81.35,70.45 81.14,70.25 80.06,70.25 79.93,70.37 v2(79.93,71.01)
  BOTTOM w0.076: U0300.AB2 47.46,125.73 47.8,125.39 47.8,124.24 48.57,123.47 v6(48.64,123.47)
  BOTTOM w0.159: v2(79.93,71.01) 79.88,70.95 CON1601.186 ; v6(48.64,123.47) 49.05,123.06 v1(49.05,121.75)
M_CHA_DQ34: length 79.5
  TOP w0.159: CON1600.169 77.63,70.01 v2(77.14,70.5)
  IN1 w0.076: 52.91,115.88 46.83,121.95 46.74,121.95 46.22,122.47 46.22,124.64 47.21,125.63 47.21,125.92 v6(48.64,127.36)
  IN1 w0.108: v2(77.14,70.5) 78.95,72.31 78.95,76.77 80.31,78.13 80.31,80.31 80.66,80.66 80.66,82.97 80.88,83.19 80.88,88.29 80.55,88.63 79.6,88.63 64.42,103.8 62.03,103.8 53.06,112.78 53.06,115.72 52.91,115.88
  BOTTOM w0.076: U0300.AA4 48.32,127.04 v6(48.64,127.36)
  BOTTOM w0.159: v2(77.14,70.5) 76.88,70.24 CON1601.174
M_CHA_DQ35: length 81.4
  TOP w0.159: CON1600.173 78.63,70.13 77.62,71.13 v2(77.14,71.13)
  IN1 w0.076: 52.72,115.49 52.72,115.83 46.76,121.79 46.67,121.79 46.05,122.4 46.05,124.71 47.04,125.7 v6(47.04,126.73)
  IN1 w0.108: v2(77.14,71.13) 78.61,72.61 78.61,76.91 79.78,78.08 79.78,80.96 80.21,81.39 80.21,82.49 79.85,82.84 79.85,84.04 80.54,84.73 80.54,87.8 80.16,88.19 79.56,88.19 64.57,103.17 62.19,103.17 52.72,112.64 52.72,115.49
  BOTTOM w0.076: U0300.AA5 47.78,127.27 47.78,126.91 47.59,126.72 47.33,126.72 47.32,126.73 v6(47.04,126.73)
  BOTTOM w0.159: v2(77.14,71.13) 76.63,71.13 75.88,70.38 CON1601.170
M_CHA_DQ36: length 82.2
  TOP w0.159: v2(78.2,74.54) 78.89,74.54 79.02,74.67 79.02,74.92 78.88,75.06 CON1600.174
  IN1 w0.102: 52.05,115.2 52.05,116.02 46.63,121.44 46.53,121.44 45.71,122.26 45.71,124.91 46.63,125.83 46.63,126.28 46.49,126.41 46.49,127.46 v6(47.03,128)
  IN1 w0.108: v2(78.2,74.54) 77.63,75.11 77.63,76.88 78.92,78.17 78.92,80.18 78.68,80.42 78.68,84.71 78.99,85.02 78.99,85.47 78.89,85.57 78.38,85.57 78.28,85.67 78.28,85.81 78.38,85.91 78.89,85.91 78.99,86 78.99,86.14 78.89,86.24 78.38,86.24 78.28,86.34 78.28,86.48 78.38,86.58 78.89,86.58 78.99,86.68 78.99,86.82 78.89,86.92 78.41,86.92 78.31,87.01 78.31,87.15 78.41,87.25 78.89,87.25 78.99,87.35 78.99,87.55 67.11,99.43 64.82,99.43 52.05,112.2 52.05,115.2
  BOTTOM w0.076: v6(47.03,128) 47.34,127.69 U0300.AB5
  BOTTOM w0.159: v2(78.2,74.54) 78.01,74.54 76.52,76.04 75.85,76.04 75.63,76.26 CON1601.169
M_CHA_DQ37: length 80.8
  TOP w0.159: CON1600.170 77.88,75.5 v2(78.2,75.17)
  IN1 w0.076: v6(47.04,127.38) 46.67,127.01 46.67,126.48 46.8,126.35 46.8,125.75 45.89,124.83 45.89,122.34 46.61,121.61 46.7,121.61 52.38,115.93 52.38,115.46
  IN1 w0.108: 52.38,115.46 52.38,112.34 64.96,99.77 67.25,99.77 79.17,87.85 80.02,87.85 80.21,87.66 80.21,87.44 80.11,87.34 79.42,87.34 79.32,87.24 79.32,87.1 79.42,87 80.11,87 80.21,86.91 80.21,86.77 80.11,86.67 79.42,86.67 79.32,86.57 79.32,86.43 79.42,86.33 80.11,86.33 80.21,86.23 80.21,86.09 80.11,86 79.42,86 79.32,85.9 79.32,85.76 79.42,85.66 80.11,85.66 80.21,85.56 80.21,84.95 80.06,84.8 79.24,84.8 79.02,84.57 79.02,80.56 79.26,80.32 79.26,78.03 78.22,76.99 78.22,75.19 v2(78.2,75.17)
  BOTTOM w0.076: v6(47.04,127.38) 47.03,127.38 47.37,127.04 U0300.AB4
  BOTTOM w0.159: CON1601.173 76.63,76.48 77.58,75.52 77.86,75.52 v2(78.2,75.17)
M_CHA_DQ38: length 80.5
  TOP w0.159: v2(80.19,75.96) 80.36,75.96 80.88,76.47 CON1600.182 ; v6(48.64,124.64) 48.93,124.93 v1(49.2,124.93)
  IN1 w0.108: v6(48.64,124.64) 47.8,123.8 47.8,122.47 49.18,121.09 49.46,121.09 54.43,116.12 54.43,113.16 62.42,105.17 64.81,105.17 70.37,99.6 70.51,99.6 70.84,99.93 70.97,99.93 71.07,99.83 71.07,99.69 70.75,99.37 70.75,99.23 70.85,99.13 70.99,99.13 71.31,99.45 71.45,99.45 71.55,99.36 71.55,99.22 71.22,98.89 71.22,98.75 71.32,98.65 71.46,98.65 71.79,98.98 71.93,98.98 72.03,98.88 72.03,98.74 71.7,98.41 71.7,98.28 71.8,98.18 71.94,98.18 72.26,98.5 72.4,98.5 72.5,98.4 72.5,98.26 72.18,97.94 72.18,97.8 72.27,97.7 72.41,97.7 72.74,98.03 72.88,98.03 72.98,97.93 72.98,97.79 72.65,97.46 72.65,97.32 72.75,97.22 72.89,97.22 73.22,97.55 73.35,97.55 73.45,97.45 73.45,97.31 73.13,96.99 73.13,96.85 73.23,96.75 73.37,96.75 73.69,97.07 73.83,97.07 73.93,96.98 73.93,96.84 73.6,96.51 73.6,96.37 73.7,96.27 73.84,96.27 74.17,96.6 74.31,96.6 74.41,96.5 74.41,96.36 74.08,96.03 74.08,95.9 77.48,92.5 78.72,92.5 82.16,89.06 82.16,84.22 82.68,83.7 82.68,80.74 81.9,79.96 81.9,77.97 80.19,76.26 v2(80.19,75.96)
  BOTTOM w0.076: v6(48.64,124.64) 48.64,125.29 U0300.AA2
  BOTTOM w0.159: CON1601.187 80.13,76.02 v2(80.19,75.96)
M_CHA_DQ39: length 82.7
  TOP w0.159: CON1600.186 81.88,76.48 80.72,75.33 v2(80.19,75.33)
  IN1 w0.108: v2(80.19,75.33) 80.19,74.37 80.29,74.27 80.49,74.27 80.6,74.37 80.6,76.19 81.51,77.1 82.08,77.1 82.24,77.26 82.24,79.81 83.02,80.6 83.02,84.46 82.92,84.56 82.6,84.56 82.5,84.65 82.5,84.79 82.6,84.89 82.92,84.89 83.02,84.99 83.02,85.13 82.92,85.23 82.6,85.23 82.5,85.33 82.5,85.47 82.6,85.57 82.92,85.57 83.02,85.66 83.02,85.8 82.92,85.9 82.6,85.9 82.5,86 82.5,86.14 82.6,86.24 82.92,86.24 83.02,86.34 83.02,86.48 82.92,86.57 82.6,86.57 82.5,86.67 82.5,86.81 82.6,86.91 82.92,86.91 83.02,87.01 83.02,87.15 82.92,87.25 82.6,87.25 82.5,87.35 82.5,87.49 82.6,87.58 82.92,87.58 83.02,87.68 83.02,87.82 82.92,87.92 82.6,87.92 82.5,88.02 82.5,88.16 82.6,88.26 82.92,88.26 83.02,88.36 83.02,88.68 71.17,100.53 69.93,100.53 64.95,105.5 62.56,105.5 54.77,113.3 54.77,116.42 49.52,121.67 49.11,121.67 48.16,122.62 48.16,123.6 v6(48.63,124.08)
  BOTTOM w0.076: v6(48.63,124.08) 48.2,124.52 U0300.AA1
  BOTTOM w0.159: v6(48.63,124.08) 48.96,124.08 v1(49.97,123.08) ; v2(80.19,75.33) 79.13,76.39 CON1601.183
M_CHA_DQ40: length 83.4
  TOP w0.159: CON1600.190 82.88,76.16 82.79,76.07 82.03,76.07 80.92,74.97 80.92,74.77 81.13,74.56 81.36,74.56 81.76,74.97 81.76,75.07 v2(82.3,75.61)
  IN1 w0.108: v2(82.3,75.61) 82.49,75.61 84.13,77.24 84.13,77.41 84.05,77.48 83.67,77.48 83.58,77.57 83.58,77.82 83.68,77.92 84.15,77.92 84.26,78.02 84.26,79.65 84.84,80.24 84.84,80.38 84.76,80.46 84.41,80.46 84.36,80.51 84.36,80.76 84.44,80.84 85.06,80.84 85.14,80.91 85.14,81.14 85.06,81.22 84.48,81.22 84.36,81.34 84.36,82.77 84.46,82.87 84.92,82.87 85.01,82.97 85.01,83.11 84.92,83.21 84.46,83.21 84.36,83.31 84.36,89.24 71.73,101.87 70.48,101.87 65.48,106.88 63.09,106.88 56.11,113.85 56.11,116.21 49.58,122.74 49.58,126.44 v6(51.16,128.02)
  BOTTOM w0.076: v6(51.16,128.02) 51.16,128.02 50.4,128.02 50.07,127.69 U0300.V5
  BOTTOM w0.159: CON1601.195 82.13,75.78 v2(82.3,75.61)
M_CHA_DQ41: length 85.6
  TOP w0.159: v2(84.51,73.93) 84.51,73.93 84.51,73.22 84.63,73.09 86.11,73.09 86.24,73.23 86.24,75.8 86.6,76.16 87.18,76.16 87.38,76.36 CON1600.208
  IN1 w0.076: v6(51.15,125.4) 52.19,124.37 52.19,121.94 52.33,121.79
  IN1 w0.108: 52.33,121.79 58.36,115.76 58.36,114.79 61.15,111.99 62.72,111.99 65.55,109.17 66.36,109.17 71.17,104.37 72.42,104.37 87.4,89.38 87.4,78.17 86.58,77.34 86.58,76.51 85.43,75.37 85.43,72.65 85.22,72.45 84.79,72.45 84.66,72.57 84.66,73.78 v2(84.51,73.93)
  BOTTOM w0.076: U0300.V2 49.97,125.73 50.31,125.4 v6(51.15,125.4)
  BOTTOM w0.159: v2(84.51,73.93) 84.76,73.93 85.13,74.29 CON1601.207
M_CHA_DQ42: length 83.6
  TOP w0.159: v2(81.84,71.31) 81.23,71.92 80.98,71.92 80.72,71.67 80.72,71.46 81.61,70.58 82.04,70.58 82.4,70.22 83.05,70.22 83.13,70.14 CON1600.191
  IN1 w0.108: v6(50.87,124.34) 50.39,123.86 50.39,122.49 56.79,116.1 56.79,114.13 63.37,107.55 65.76,107.55 70.76,102.55 72.01,102.55 85.27,89.28 85.27,84.8 85.83,84.24 85.83,80.28 85,79.45 85,77.17 83.24,75.4 83.24,74.13 82.87,73.77 82.87,72.4 82.63,72.15 82.63,70.73 82.75,70.6 82.8,70.6 82.92,70.47 82.92,70.2 82.8,70.07 82.04,70.07 81.84,70.27 v2(81.84,71.31)
  BOTTOM w0.076: v6(50.87,124.34) 50.71,124.49 U0300.U1
  BOTTOM w0.159: v2(81.84,71.31) 81.84,71.01 81.88,70.97 CON1601.194
M_CHA_DQ43: length 84
  TOP w0.159: v2(84.51,71.77) 84.51,72.23 84.68,72.4 86.03,72.4 86.24,72.19 86.24,70.49 86.39,70.35 86.92,70.35 87.13,70.14 CON1600.207
  IN1 w0.076: 52.5,121.9 52.35,122.05 52.35,124.89 v6(51.16,126.08)
  IN1 w0.108: v2(84.51,71.77) 84.76,72.03 85.06,72.03 85.28,71.81 85.28,71.56 85.34,71.49 85.56,71.49 85.76,71.69 85.76,75.23 86.91,76.37 86.91,77.2 87.74,78.03 87.74,89.52 72.56,104.7 71.31,104.7 66.5,109.51 65.69,109.51 62.84,112.36 61.26,112.36 58.7,114.93 58.7,115.71 52.5,121.9
  BOTTOM w0.076: v6(51.16,126.08) 50.82,125.74 U0300.U2
  BOTTOM w0.159: CON1601.208 85.38,70.9 v2(84.51,71.77)
M_CHA_DQ44: length 84.5
  TOP w0.159: v2(84.51,74.54) 84.86,74.54 85.14,74.26 85.14,74.01 85.27,73.88 85.52,73.88 85.65,74.01 85.65,74.44 85.01,75.08 85.01,75.24 85.12,75.36 85.28,75.36 85.47,75.16 85.63,75.16 85.75,75.28 85.75,75.44 85.65,75.53 85.65,75.76 86.38,76.48 CON1600.204
  IN1 w0.076: 52.14,121.71 52.01,121.83 52.01,122.99 51.24,123.77 v6(50.87,123.77)
  IN1 w0.108: 52.14,121.71 58.02,115.82 58.02,114.65 61.29,111.38 62.66,111.38 65.2,108.84 66.22,108.84 71.03,104.03 72.28,104.03 87.07,89.24 87.07,89.04 86.97,88.94 86.61,88.94 86.51,88.84 86.51,88.7 86.61,88.6 86.97,88.6 87.07,88.51 87.07,88.37 86.97,88.27 86.61,88.27 86.51,88.17 86.51,88.03 86.61,87.93 86.97,87.93 87.07,87.83 87.07,87.69 86.97,87.59 86.61,87.59 86.51,87.5 86.51,87.36 86.61,87.26 86.97,87.26 87.07,87.16 87.07,87.02 86.97,86.92 86.61,86.92 86.51,86.82 86.51,86.68 86.61,86.58 86.97,86.58 87.07,86.49 87.07,86.35 86.97,86.25 86.61,86.25 86.51,86.15 86.51,86.01 86.61,85.91 86.97,85.91 87.07,85.81 87.07,85.67 86.97,85.57 86.61,85.57 86.51,85.48 86.51,85.34 86.61,85.24 86.97,85.24 87.07,85.14 87.07,78.31 86.24,77.48 86.24,76.65 84.89,75.31 84.89,75.08 85.08,74.9 85.08,74.59 84.87,74.38 84.67,74.38 v2(84.51,74.54)
  BOTTOM w0.076: U0300.V1 49.97,124.67 v6(50.87,123.77)
  BOTTOM w0.159: v2(84.51,74.54) 84.13,74.92 CON1601.203
M_CHA_DQ45: length 85.2
  TOP w0.159: v2(82.3,74.36) 82.3,73.95 81.92,73.57 81.92,73.17 82.02,73.07 82.88,73.07 83.03,73.21 83.03,75.23 83.88,76.08 CON1600.194
  IN1 w0.108: v6(48.64,126.71) 49.27,126.08 49.27,122.78 55.78,116.27 55.78,113.71 62.95,106.54 65.34,106.54 70.34,101.54 71.59,101.54 84.03,89.1 84.03,79.98 83.75,79.7 83.75,78.47 83.25,77.96 83.25,76.84 82.5,76.09 81.92,76.09 81.68,75.85 81.68,73.29 81.73,73.24 82.02,73.24 82.09,73.32 82.09,74.16 v2(82.3,74.36)
  BOTTOM w0.076: v6(48.64,126.71) 49.65,126.71 U0300.V4
  BOTTOM w0.159: CON1601.191 81.13,75.23 81.99,74.36 v2(82.3,74.36)
M_CHA_DQ46: length 85.3
  TOP w0.159: v1(50.42,127.35) 50.44,127.37 v6(51.17,127.37) ; v2(81.84,71.95) 82.3,71.49 82.3,70.93 82.6,70.63 83.44,70.63 83.79,70.98 83.97,70.98 84.28,70.67 84.9,70.67 85,70.58 85,70.25 84.92,70.17 84.35,70.17 84.13,69.94 CON1600.195
  IN1 w0.108: v2(81.84,71.95) 82.53,72.64 82.53,73.91 82.9,74.27 82.9,75.54 84.66,77.31 84.66,79.59 85.49,80.42 85.49,84.04 84.94,84.6 84.94,89.14 71.87,102.21 70.62,102.21 65.62,107.21 63.23,107.21 56.45,113.99 56.45,116.16 50.09,122.51 50.09,126.3 v6(51.17,127.37)
  BOTTOM w0.076: U0300.U5 50.86,127.69 v6(51.17,127.37)
  BOTTOM w0.159: v2(81.84,71.95) 80.88,70.98 CON1601.190
M_CHA_DQ47: length 83.5
  TOP w0.159: v2(84.51,71.13) 84.98,71.13 85.12,70.99 85.37,70.99 85.46,71.08 85.46,71.34 85.36,71.44 85.22,71.44 85.12,71.54 85.12,71.77 85.24,71.89 85.71,71.89 85.86,71.74 85.86,70.33 86.13,70.06 CON1600.203
  IN1 w0.108: v6(51.18,126.75) 52.53,125.4 52.53,122.15 59.03,115.65 59.03,115.06 61.25,112.85 62.82,112.85 65.82,109.85 66.64,109.85 71.45,105.04 72.7,105.04 88.08,89.66 88.08,77.89 87.25,77.06 87.25,76.23 86.1,75.09 86.1,71.51 85.72,71.13 v2(84.51,71.13)
  BOTTOM w0.076: U0300.U4 50.89,127.04 v6(51.18,126.75)
  BOTTOM w0.159: CON1601.204 84.38,71 v2(84.51,71.13)
M_CHA_DQ48: length 90.7
  TOP w0.159: CON1600.228 92.38,76.18 92.13,75.94 91.51,75.94 91.18,75.6 91.18,74.18 91.01,74 89.94,74 89.78,74.16 89.78,74.69 v2(89.78,74.69)
  IN1 w0.108: v2(89.78,74.69) 89.78,73.37 89.71,73.29 88.67,73.29 88.57,73.19 88.57,72.86 88.67,72.76 90.45,72.76 90.54,72.85 90.54,75.77 92.73,77.97 92.73,79.55 92.49,79.78 92.49,89.38 73.91,107.96 72.96,107.96 65.33,115.59 65.33,119.14 62.9,121.57 55.9,121.57 54.24,123.22 54.24,124.82 v6(53.65,125.41)
  BOTTOM w0.076: U0300.R2 52.82,125.41 v6(53.65,125.41)
  BOTTOM w0.159: v2(89.78,74.69) 90.16,74.31 90.55,74.31 90.78,74.54 90.78,76.34 90.76,76.35 90.75,76.35 90.71,76.4 90.71,76.41 90.63,76.49 CON1601.229
M_CHA_DQ49: length 91.8
  TOP w0.159: CON1600.216 89.38,76.14 87.64,74.41 87.64,73.23 87.45,73.04 86.87,73.04 86.68,73.23 86.68,74.44 v2(86.68,74.44)
  IN1 w0.108: v6(53.66,127.97) 53.65,127.97 52.99,127.97 52.93,127.9 52.93,122.33 55.5,119.75 55.57,119.75 56.1,119.22 56.24,119.22 56.5,119.48 56.64,119.48 56.74,119.38 56.74,119.24 56.48,118.98 56.48,118.84 56.58,118.74 56.72,118.74 56.98,119 57.11,119 57.21,118.9 57.21,118.76 56.95,118.5 56.95,118.36 57.05,118.27 57.19,118.27 57.45,118.53 57.59,118.53 57.69,118.43 57.69,118.29 57.43,118.03 57.43,117.89 57.53,117.79 57.67,117.79 57.93,118.05 58.07,118.05 58.17,117.95 58.17,117.81 57.91,117.55 57.91,117.41 58,117.31 58.14,117.31 58.4,117.57 58.54,117.57 58.64,117.47 58.64,117.34 58.38,117.08 58.38,116.94 58.48,116.84 58.62,116.84 58.88,117.1 59.02,117.1 59.12,117 59.12,116.86 58.86,116.6 58.86,116.46 58.96,116.36 59.1,116.36 59.36,116.62 59.49,116.62 59.59,116.52 59.59,116.38 59.33,116.12 59.33,115.98 59.59,115.73 59.59,115.54 61.34,113.78 63.94,113.78 65.44,112.28 65.44,112.14 65.31,112.01 65.31,111.87 65.41,111.77 65.55,111.77 65.68,111.9 65.82,111.9 72.01,105.71 72.98,105.71 88.75,89.94 88.75,83.11 89.44,82.42 89.44,78.31 87.92,76.78 87.92,75.68 v2(86.68,74.44)
  BOTTOM w0.076: U0300.P5 53.51,127.97 v6(53.66,127.97)
  BOTTOM w0.159: v2(86.68,74.44) 86.68,74.1 86.9,73.88 87.22,73.88 87.53,74.19 87.53,75.48 87.13,75.88 CON1601.215
M_CHA_DQ50: length 89
  TOP w0.159: CON1600.212 88.38,76.48 88.11,76.21 88.11,76.07 88.37,75.82 88.37,75.7 88.12,75.45 87.93,75.45 87.55,75.83 87.4,75.83 87.2,75.63 87.2,75.5 87.63,75.07 87.63,74.95 87.48,74.8 86.95,74.8 v2(86.68,75.07)
  IN1 w0.108: v6(52.08,126.72) 51.66,127.14 51.66,128.69 51.87,128.89 55.41,128.89 55.55,128.75 55.55,128.55 55.41,128.41 52.88,128.41 52.73,128.26 52.73,122.23 59.37,115.59 59.37,115.2 61.29,113.28 62.87,113.28 65.96,110.18 66.78,110.18 71.59,105.38 72.84,105.38 88.41,89.8 88.41,82.97 89.11,82.28 89.11,81 88.41,80.31 88.41,77.75 87.58,76.92 87.58,75.98 v2(86.68,75.07)
  BOTTOM w0.076: v6(52.08,126.72) 52.4,127.04 U0300.R4
  BOTTOM w0.159: v2(86.68,75.07) 86.13,75.62 CON1601.211
M_CHA_DQ51: length 90.2
  TOP w0.159: CON1600.215 89.13,70.39 87.9,71.62 87.38,71.62 87.22,71.77 87.22,72.46 87.12,72.56 86.77,72.56 86.68,72.47 v2(86.68,71.64)
  IN1 w0.076: v6(53.65,127.37) 53.11,126.83 53.11,122.4 55.58,119.93 56.79,119.93 59.78,116.94 59.78,115.82
  IN1 w0.108: v2(86.68,71.64) 87.63,71.64 87.71,71.72 87.71,72.07 87.61,72.17 86.54,72.17 86.44,72.27 86.44,72.41 86.54,72.5 87.15,72.5 87.25,72.6 87.25,72.74 87.15,72.84 86.54,72.84 86.44,72.94 86.44,73.08 86.54,73.18 87.15,73.18 87.25,73.28 87.25,73.42 87.15,73.51 86.79,73.51 86.69,73.61 86.69,73.75 86.79,73.85 87.15,73.85 87.25,73.95 87.25,74.51 88.26,75.52 88.26,76.64 89.87,78.26 89.87,84.6 89.09,85.39 89.09,90.08 73.11,106.05 72.15,106.05 64.08,114.12 61.48,114.12 59.78,115.82
  BOTTOM w0.076: v6(53.65,127.37) 53.56,127.37 U0300.P4
  BOTTOM w0.159: v2(86.68,71.64) 86.98,71.95 87.23,71.95 87.38,71.8 CON1601.216
M_CHA_DQ52: length 88.3
  TOP w0.159: CON1600.225 91.63,70.57 91.54,70.65 91.54,71.26 91.44,71.36 91.19,71.36 91.11,71.29 91.11,70.8 91.01,70.7 90.83,70.7 90.75,70.78 90.75,70.91 90.65,71.01 v2(90.48,71.01)
  IN1 w0.076: v6(53.65,126.72) 54.64,125.73 54.64,123.37 55.38,122.62 55.84,122.62 55.97,122.49
  IN1 w0.108: v2(90.48,71.01) 90.48,70.6 90.63,70.45 91.44,70.45 91.59,70.6 91.59,73.48 91.21,73.86 91.21,75.5 93.88,78.17 93.88,82.74 93.16,83.46 93.16,89.66 74.19,108.63 73.24,108.63 66.09,115.78 66.09,119.27 63.36,122 56.46,122 55.97,122.49
  BOTTOM w0.076: U0300.R5 52.49,127.69 52.81,127.37 52.81,127 53.1,126.72 v6(53.65,126.72)
  BOTTOM w0.159: CON1601.228 90.38,70.37 90.48,70.47 v2(90.48,71.01)
M_CHA_DQ53: length 90
  TOP w0.159: v2(90.48,71.64) 90.91,71.64 91.01,71.74 91.01,72.51 91.14,72.63 91.74,72.63 91.94,72.43 91.94,70.8 92.63,70.12 CON1600.229
  IN1 w0.108: v2(90.48,71.64) 90.78,71.64 90.86,71.57 90.86,71.24 90.96,71.13 91.16,71.13 91.25,71.22 91.25,73.34 90.87,73.72 90.87,75.64 93.06,77.83 93.06,78.68 93.16,78.78 93.42,78.78 93.52,78.88 93.52,79.02 93.42,79.11 93.16,79.11 93.06,79.21 93.06,79.35 93.16,79.45 93.42,79.45 93.52,79.55 93.52,79.69 93.42,79.79 92.96,79.79 92.83,79.92 92.83,80.62 92.94,80.74 93.22,80.74 93.32,80.84 93.32,80.97 93.22,81.07 92.92,81.07 92.83,81.17 92.83,89.52 74.05,108.3 73.1,108.3 65.71,115.69 65.71,119.23 63.16,121.78 55.97,121.78 54.44,123.3 54.44,125.28 v6(53.65,126.07)
  BOTTOM w0.076: U0300.P2 53.55,126.07 v6(53.65,126.07)
  BOTTOM w0.159: v2(90.48,71.64) 89.38,70.54 CON1601.224
M_CHA_DQ54: length 89.2
  TOP w0.159: v2(86.68,71.01) 86.88,70.8 87.07,70.8 87.5,71.23 87.67,71.23 87.83,71.07 87.83,70.93 87.45,70.55 87.45,70.4 87.6,70.25 87.78,70.25 88.18,70.64 88.33,70.64 88.48,70.49 88.48,70.27 88.13,69.92 CON1600.211
  IN1 w0.076: v6(53.65,124.07) 53.65,124.06 53.27,123.68 53.27,122.47 55.58,120.16 56.95,120.16 59.95,117.16 59.95,116.13 60.03,116.05
  IN1 w0.108: 60.03,116.05 61.62,114.46 64.22,114.46 72.29,106.39 73.25,106.39 89.42,90.22 89.42,85.53 90.21,84.74 90.21,78.12 88.59,76.51 88.59,75.32 87.63,74.36 87.63,73.95 87.8,73.78 88,73.78 88.14,73.64 88.14,71.11 88.34,70.91 89.31,70.91 89.38,70.98 89.38,71.29 89.51,71.41 89.84,71.41 89.97,71.29 89.97,70.14 89.87,70.05 86.82,70.05 86.68,70.19 v2(86.68,71.01)
  BOTTOM w0.076: U0300.R1 53.36,124.22 53.5,124.22 53.65,124.06 v6(53.65,124.07)
  BOTTOM w0.159: v2(86.68,71.01) 86.38,70.71 CON1601.212
M_CHA_DQ55: length 88.5
  TOP w0.159: v2(89.78,75.95) 89.78,76.06 89.89,76.16 90.14,76.16 90.25,76.06 90.25,75.14 90.33,75.05 90.56,75.05 90.65,75.15 90.65,76.06 90.78,76.19 91.08,76.19 91.38,76.48 CON1600.224
  IN1 w0.108: v6(53.65,124.65) 53.78,124.65 54.05,124.38 54.05,123.14 55.94,121.25 59.06,121.25 59.16,121.15 59.16,120.28 59.26,120.18 59.4,120.18 59.49,120.28 59.49,121.15 59.59,121.25 59.73,121.25 59.83,121.15 59.83,120.28 59.93,120.18 60.07,120.18 60.17,120.28 60.17,121.15 60.27,121.25 60.41,121.25 60.5,121.15 60.5,120.28 60.6,120.18 60.74,120.18 60.84,120.28 60.84,121.15 60.94,121.25 61.08,121.25 61.18,121.15 61.18,120.28 61.28,120.18 61.41,120.18 61.51,120.28 61.51,121.15 61.61,121.25 61.75,121.25 61.85,121.15 61.85,120.28 61.95,120.18 62.09,120.18 62.19,120.28 62.19,121.15 62.28,121.25 62.71,121.25 64.8,119.16 64.8,115.64 72.82,107.62 73.77,107.62 92.15,89.24 92.15,81.22 92.06,81.12 91.84,81.12 91.75,81.02 91.75,80.89 91.84,80.79 92.06,80.79 92.15,80.69 92.15,79.64 92.39,79.41 92.39,78.11 92.16,77.89 92.02,77.89 91.74,78.18 91.6,78.18 91.5,78.08 91.5,77.94 91.79,77.65 91.79,77.51 90.23,75.95 v2(89.78,75.95)
  BOTTOM w0.076: U0300.P1 53.24,125.09 53.65,124.67 v6(53.65,124.65)
  BOTTOM w0.159: CON1601.225 89.63,76.11 v2(89.78,75.95)
M_CHA_DQ56: length 87.7
  TOP w0.159: v2(91.62,75.33) 91.84,75.1 92.43,75.1 93.37,76.04 93.37,77.29 CON1600.232
  IN1 w0.076: 66.43,119.31 63.42,122.32 57.07,122.32 56.6,122.79 55.45,122.79 54.8,123.43 54.8,126.44 v6(54.56,126.67)
  IN1 w0.108: v2(91.62,75.33) 92.02,74.92 92.28,74.92 92.73,75.37 92.73,75.51 92.31,75.93 92.31,76.07 92.41,76.17 92.55,76.17 92.97,75.75 93.11,75.75 93.21,75.85 93.21,75.99 92.79,76.4 92.79,76.54 92.88,76.64 93.02,76.64 93.44,76.22 93.58,76.22 93.68,76.32 93.68,76.46 93.26,76.88 93.26,77.02 93.36,77.12 93.5,77.12 93.92,76.7 94.06,76.7 94.22,76.86 94.22,77.03 94.21,77.03 93.9,77.33 93.9,77.51 94.06,77.66 94.19,77.66 94.5,77.36 94.66,77.36 95.15,77.84 95.15,78.12 95.04,78.22 94.44,78.22 94.22,78.44 94.22,81.08 94.51,81.37 94.51,82.56 94.21,82.87 94.21,83.25 94.51,83.55 94.51,83.61 93.98,84.14 93.68,84.14 93.5,84.31 93.5,89.79 74.33,108.97 73.42,108.97 66.43,115.96 66.43,119.31
  BOTTOM w0.076: U0300.M4 54.93,127.04 v6(54.56,126.67)
  BOTTOM w0.159: v2(91.62,75.33) 91.63,75.33 CON1601.233
M_CHA_DQ57: length 89.3
  TOP w0.159: v1(57.56,124.05) 57.15,123.64 v6(57.15,123.1) ; v2(92.38,71.01) 92.53,71.16 93.34,71.16 93.47,71.03 93.47,70.83 93.4,70.75 93.14,70.75 93.01,70.63 93.01,70.42 93.12,70.32 93.47,70.32 93.63,70.17 CON1600.233
  IN1 w0.108: v2(92.38,71.01) 92.38,70.4 92.73,70.05 94.72,70.05 94.82,70.14 94.82,71.08 94.72,71.19 94.26,71.19 93.29,72.15 93.29,74.49 96.16,77.36 96.16,80.34 95.66,80.83 95.66,85.09 95.1,85.66 95.1,86.7 94.51,87.29 94.51,90.21 74.74,109.98 73.84,109.98 67.47,116.35 67.47,119.48 63.46,123.48 57.53,123.48 v6(57.15,123.1)
  BOTTOM w0.076: v6(57.15,123.1) 57.15,123.1 56.7,123.1 55,124.8 U0300.M1
  BOTTOM w0.159: v2(92.38,71.01) 92.38,71 CON1601.236
M_CHA_DQ58: length 88.5
  TOP w0.159: v2(95.66,71.01) 96.01,71.36 96.93,71.36 97.63,70.66 CON1600.249
  IN1 w0.108: v2(95.66,71.01) 96.44,71.8 97.72,71.8 97.84,71.92 97.84,72.23 97.72,72.35 97.26,72.35 97.13,72.48 97.13,72.76 97.26,72.89 97.88,72.89 98.11,73.12 98.11,73.63 98.63,74.14 98.63,86.13 97.16,87.59 97.16,90.26 76.23,111.19 75.54,111.89 75.02,111.89 71.56,115.35 71.56,115.35 70.64,116.27 70.64,119.98 68.71,121.91 67.54,121.91 64.85,124.6 58.3,124.6 v6(56.19,126.71)
  BOTTOM w0.076: v6(56.19,126.71) 56.07,126.71 U0300.L4
  BOTTOM w0.159: CON1601.246 94.88,70.88 95,71.01 v2(95.66,71.01)
M_CHA_DQ59: length 89.4
  TOP w0.159: v2(95.75,74.54) 97.67,74.54 97.88,74.75 CON1600.250
  IN1 w0.108: v2(95.75,74.54) 95.76,74.53 95.76,72.36 95.89,72.23 96.65,72.23 96.77,72.36 96.77,73.23 96.88,73.34 97.35,73.34 98.29,74.28 98.29,85.96 96.83,87.42 96.83,90.12 75.9,111.05 75.4,111.56 74.52,111.56 70.13,115.94 70.13,120.01 68.96,121.18 67.79,121.18 64.62,124.35 57.56,124.35 57.01,124.9 56.69,124.9 56.34,124.54 v6(56.25,124.54)
  BOTTOM w0.076: v6(56.25,124.54) 56.09,124.7 56.09,125.38 55.74,125.73 U0300.L2
  BOTTOM w0.159: CON1601.249 95.63,76.17 96.18,75.61 96.18,74.98 v2(95.75,74.54)
M_CHA_DQ60: length 88.7
  TOP w0.159: v2(91.62,74.69) 92.58,74.69 94.38,76.48 CON1600.236
  IN1 w0.076: v6(54.58,127.34) 54.58,127.32 54.97,126.94 54.97,123.5 55.52,122.95 56.67,122.95 57.14,122.48 63.64,122.48 66.76,119.36
  IN1 w0.108: v2(91.62,74.69) 91.92,74.39 91.92,73.01 92.08,72.86 92.41,72.86 92.56,73.01 92.56,74.71 95.48,77.64 95.48,79.54 95.28,79.75 94.67,79.75 94.56,79.86 94.56,80.74 94.99,81.17 94.99,83.61 93.84,84.76 93.84,89.93 74.46,109.31 73.56,109.31 66.76,116.1 66.76,119.36
  BOTTOM w0.076: v6(54.58,127.34) 54.74,127.5 54.81,127.5 U0300.M5
  BOTTOM w0.159: v2(91.62,74.69) 92.63,75.7 CON1601.237
M_CHA_DQ61: length 90.7
  TOP w0.159: v2(92.38,71.64) 92.94,72.2 93.47,72.2 93.83,71.85 93.83,71.36 94.08,71.11 94.95,71.11 95.1,70.96 95.1,70.63 94.95,70.48 94.77,70.48 94.63,70.33 CON1600.237 ; v1(58.19,122.52) 58.19,122.62 v6(57.71,123.1)
  IN1 w0.108: v6(57.71,123.1) 63.41,123.1 67.13,119.38 67.13,116.21 73.7,109.64 74.6,109.64 94.17,90.07 94.17,85.27 94.26,85.18 94.89,85.18 95.33,84.75 95.33,80.69 95.82,80.2 95.82,77.5 92.95,74.63 92.95,72.01 93.93,71.04 93.93,70.65 93.7,70.42 93.04,70.42 92.96,70.5 92.96,71.44 92.76,71.64 v2(92.38,71.64)
  BOTTOM w0.076: U0300.M2 55.38,125.36 55.38,124.66 56.55,123.49 57.53,123.49 57.71,123.31 v6(57.71,123.1)
  BOTTOM w0.159: v2(92.38,71.64) 91.38,70.64 CON1601.232
M_CHA_DQ62: length 87.7
  TOP w0.159: v2(95.66,70.37) 95.82,70.37 96.42,70.98 96.67,70.98 96.95,70.7 96.95,70.52 96.63,70.19 CON1600.245
  IN1 w0.108: v2(95.66,70.37) 97.88,70.37 98.01,70.5 98.01,71.29 98.14,71.41 98.32,71.41 98.45,71.54 98.45,73.49 98.96,74 98.96,86.29 97.5,87.75 97.5,90.4 76.57,111.33 75.68,112.23 75.16,112.23 71,116.39 71,120.15 68.89,122.27 67.66,122.27 64.99,124.93 58.48,124.93 57.07,126.34 57.07,126.47 v6(56.19,127.36)
  BOTTOM w0.076: v6(56.19,127.36) 56.07,127.36 U0300.L5
  BOTTOM w0.159: v2(95.66,70.37) 95.88,70.15 CON1601.250
M_CHA_DQ63: length 90.3
  TOP w0.159: CON1600.246 96.88,75.92 96.95,75.84 97.33,75.84 97.46,75.71 97.46,75.33 97.33,75.2 v2(95.75,75.2) ; v6(56.85,124.51) 57.65,125.31 v1(57.93,125.31)
  IN1 w0.108: v2(95.75,75.2) 96.15,74.79 96.29,74.79 96.57,74.51 96.57,73.97 96.7,73.85 96.95,73.85 97.08,73.97 97.08,76.16 97.21,76.28 97.38,76.28 97.51,76.16 97.51,74.41 97.61,74.31 97.69,74.31 97.85,74.31 97.95,74.42 97.95,85.81 96.49,87.27 96.49,89.98 75.56,110.92 75.26,111.22 74.38,111.22 69.68,115.92 69.68,119.93 68.86,120.74 67.74,120.74 64.39,124.09 57.27,124.09 v6(56.85,124.51)
  BOTTOM w0.076: v6(56.85,124.51) 56.51,124.18 56.1,124.18 55.74,124.53 U0300.L1
  BOTTOM w0.159: CON1601.245 94.63,75.56 94.98,75.2 v2(95.75,75.2)
M_CHA_DQS0: length 84.5
  TOP w0.159: v2(35.85,72.99) 36.28,72.55 36.28,72.53 36.3,72.52 36.3,70.42 36.63,70.1 CON1600.13
  IN1 w0.076: v6(19.89,126.31) 19.24,126.31 18.99,126.06 18.99,125.74 18.73,125.48 18.25,125.48 18.22,125.46 18.21,125.46
  IN1 w0.114: v2(35.85,72.99) 35.62,72.76 35.02,72.76 34.81,72.97 34.81,74.12 33.27,75.65 33.27,76.12 16.3,93.09 16.3,99.8 15.22,100.88 15.22,109.6 14.96,109.86 14.71,109.86 14.59,109.97 14.59,110.2 14.71,110.31 14.96,110.31 15.19,110.55 15.19,110.95 14.96,111.18 14.71,111.18 14.59,111.29 14.59,111.97 14.71,112.08 14.92,112.08 15.15,112.31 15.15,112.71 14.92,112.94 14.71,112.94 14.59,113.06 14.59,119.85 13.85,120.59 13.85,121.37 14.17,121.69 14.17,122.37 13.85,122.69 13.85,122.94 14.18,123.28 14.35,123.28 14.73,122.9 15.08,122.9 15.36,123.18 15.36,123.49 14.96,123.89 14.96,124.05 16.36,125.46 18.21,125.46
  BOTTOM w0.076: v6(19.89,126.31) 19.98,126.4 19.98,126.89 20.05,126.95 20.05,126.94 20.71,127.6 22.35,127.6 22.49,127.46 U0300.BP5
  BOTTOM w0.159: CON1601.13 34.63,76.26 34.75,76.14 34.84,76.14 34.91,76.06 34.91,75.83 34.84,75.76 34.51,75.76 34.39,75.63 34.39,74.19 35.58,72.99 v2(35.85,72.99)
M_CHA_DQS0#: length 84.4
  TOP w0.159: CON1600.11 36.13,70.23 36.04,70.32 36.04,71.73 35.92,71.85 35.48,71.85 35.36,71.97 35.36,72.23 35.48,72.35 v2(35.85,72.35)
  IN1 w0.076: 18.16,125.66 18.23,125.66 18.25,125.65 18.67,125.65 18.83,125.81 18.83,126.13 19.17,126.47 19.5,126.47 19.84,126.81 20.28,126.81 v6(20.38,126.72)
  IN1 w0.114: v2(35.85,72.35) 35.65,72.55 34.94,72.55 34.61,72.89 34.61,74.03 33.07,75.57 33.07,76.03 16.09,93.01 16.09,99.71 15.01,100.8 15.01,109.52 14.88,109.65 14.62,109.65 14.39,109.89 14.39,110.29 14.62,110.52 14.88,110.52 14.99,110.63 14.99,110.86 14.88,110.98 14.62,110.98 14.39,111.21 14.39,112.05 14.62,112.28 14.83,112.28 14.95,112.4 14.95,112.63 14.83,112.74 14.62,112.74 14.39,112.97 14.39,119.77 13.65,120.51 13.65,121.46 13.97,121.78 13.97,122.29 13.65,122.61 13.65,123.03 14.1,123.48 14.43,123.48 14.81,123.1 14.99,123.1 15.15,123.26 15.15,123.4 14.75,123.8 14.75,124.13 16.28,125.66 18.16,125.66
  BOTTOM w0.076: v6(20.38,126.72) 20.38,127.04 20.78,127.44 22.05,127.44 U0300.BR5
  BOTTOM w0.159: v2(35.85,72.35) 34.13,74.08 CON1601.11
M_CHA_DQS1: length 82
  TOP w0.159: v2(40,72.43) 40.55,72.43 40.63,72.51 40.63,72.76 40.52,72.87 39.62,72.87 39.52,72.98 39.52,74.22 41.51,76.21 41.63,76.21 41.88,76.46 CON1600.34
  IN1 w0.076: 18.81,122.03 18.81,122.12 19.09,122.4 19.3,122.4 20.21,123.31 21.25,123.31 22.12,124.18 23.66,124.18 v6(24.1,123.74)
  IN1 w0.114: v2(40,72.43) 39.65,72.43 39.3,72.78 39.3,75.31 36.32,78.29 36.32,80.04 34.9,81.45 33.02,81.45 19.89,94.58 19.89,101.29 18.81,102.37 18.81,122.03
  BOTTOM w0.076: U0300.BK3 25.7,126.39 26.14,125.95 26.14,125.53 25.74,125.13 25.74,124.64 24.73,123.63 24.22,123.63 v6(24.1,123.74)
  BOTTOM w0.159: v2(40,72.43) 40.34,72.43 40.59,72.18 40.59,71.87 40.46,71.75 40.46,71.37 39.85,70.75 39.85,70.07 39.88,70.05 CON1601.34
M_CHA_DQS1#: length 81
  TOP w0.159: CON1600.32 41.38,76.44 39.26,74.33 39.26,72.53 v2(40,71.79)
  IN1 w0.076: v6(24.51,124.13) 23.95,124.13 23.73,124.35 22.06,124.35 21.18,123.48 20.14,123.48 19.23,122.57 19.02,122.57 18.61,122.15
  IN1 w0.114: v2(40,71.79) 39.09,72.69 39.09,75.23 36.11,78.21 36.11,79.95 34.82,81.25 32.94,81.25 19.69,94.5 19.69,101.2 18.61,102.29 18.61,122.15
  BOTTOM w0.076: v6(24.51,124.13) 25,124.13 25.58,124.71 25.58,125.2 25.97,125.59 25.97,125.88 25.79,126.06 25.16,126.06 U0300.BL3
  BOTTOM w0.159: v2(40,71.79) 40.13,71.66 40.13,71.4 39.59,70.86 39.59,70.25 39.38,70.03 CON1601.32
M_CHA_DQS2: length 78.7
  TOP w0.159: v2(44.93,73.95) 45.39,73.5 45.39,73.46 45.69,73.16 45.69,71.76 45.45,71.51 45.45,71.27 46.23,70.48 46.62,70.48 47.13,69.97 CON1600.55
  IN1 w0.076: 22.47,115.44 22.47,120.39 26.17,124.1 v7(26.39,124.1)
  IN1 w0.114: 22.47,115.44 22.47,103.8 24.48,101.79 24.48,98.56 25.34,97.71 25.34,94.49 33.36,86.46 35.35,86.46 40.56,81.25 40.56,80.89 41.02,80.43 41.02,79.96 41.43,79.54 41.43,78.27 43.88,75.82 43.88,74.26 43.56,73.95 43.56,73.78 43.82,73.52 43.98,73.52 44.27,73.8 44.78,73.8 v2(44.93,73.95)
  BOTTOM w0.076: v7(26.39,124.1) 26.62,124.32 26.8,124.32 27.03,124.55 27.03,125.89 27.19,126.06 27.69,126.06 28.01,126.39 U0300.BF3
  BOTTOM w0.159: v2(44.93,73.95) 44.74,73.76 44.2,73.76 44.08,73.88 44.08,75.48 44.42,75.83 45,75.83 45.13,75.95 CON1601.55
M_CHA_DQS2#: length 78.7
  TOP w0.159: v2(44.93,73.32) 45.15,73.32 45.43,73.04 45.43,72.86 45.26,72.68 45.01,72.68 44.91,72.58 44.91,72.38 45.01,72.28 45.38,72.28 45.43,72.23 45.43,71.87 45.19,71.62 45.19,71.16 46.13,70.22 46.51,70.22 46.63,70.1 CON1600.53
  IN1 w0.076: 22.26,115.44 22.26,115.49 22.3,115.52 22.3,120.46 25.98,124.14 25.98,124.25 26.44,124.71 v6(26.64,124.71)
  IN1 w0.114: 22.26,115.44 22.26,103.71 24.28,101.7 24.28,98.48 25.13,97.62 25.13,94.41 33.28,86.26 35.27,86.26 40.36,81.17 40.36,80.8 40.82,80.35 40.82,79.87 41.23,79.46 41.23,78.18 43.68,75.74 43.68,74.35 43.36,74.03 43.36,73.7 43.74,73.32 44.07,73.32 44.35,73.6 44.6,73.6 44.69,73.51 44.69,73.42 44.79,73.32 v2(44.93,73.32)
  BOTTOM w0.076: v6(26.64,124.71) 26.86,124.92 26.86,125.96 27.29,126.39 U0300.BG3
  BOTTOM w0.159: CON1601.53 44.63,76.21 44.5,76.09 44.27,76.09 43.82,75.63 43.82,73.78 44.09,73.5 44.76,73.5 v2(44.93,73.32)
M_CHA_DQS3: length 80.8
  TOP w0.159: CON1600.76 52.38,76.27 49.97,73.86 49.97,72.58 50.18,72.37 50.35,72.37 50.62,72.1 50.62,71.74 v2(50.17,71.29)
  IN1 w0.076: v2(28.49,122.32) 28.29,122.13 28.29,121.67 27.85,121.22 27.85,121.2
  IN1 w0.114: v2(50.17,71.29) 50.6,71.71 50.6,72.09 50.2,72.48 49.62,72.48 49.4,72.7 49.4,75.39 46.18,78.61 46.18,80.03 44.65,81.56 44.65,83.75 42.14,86.25 42.14,86.41 42.38,86.65 42.38,86.98 42.02,87.34 41.69,87.34 41.45,87.11 41.29,87.11 37.33,91.07 37.33,92.59 28.26,101.66 28.26,115.12 27.85,115.54 27.85,121.2
  BOTTOM w0.076: v2(28.49,122.32) 28.89,122.32 29.01,122.45 29.24,122.45 29.52,122.73 29.52,125.87 29.7,126.06 30.27,126.06 U0300.BC3
  BOTTOM w0.159: v2(50.17,71.29) 49.93,71.53 49.9,71.53 49.68,71.74 49.68,72.14 49.56,72.27 49.28,72.27 49.17,72.15 49.17,70.91 49.45,70.63 49.71,70.63 50.38,69.96 CON1601.76
M_CHA_DQS3#: length 80.7
  TOP w0.159: CON1600.74 51.88,76.13 49.71,73.97 49.71,72.15 49.43,71.88 49.43,71.73 49.62,71.54 49.79,71.54 v2(50.17,71.92)
  IN1 w0.076: 27.64,121.25 28.1,121.71 28.1,122.23 28.03,122.3 27.9,122.3 27.81,122.39 27.81,122.57 27.89,122.65 28.21,122.65 v7(28.57,123.01)
  IN1 w0.114: v2(50.17,71.92) 50.17,72.23 50.12,72.28 49.54,72.28 49.2,72.61 49.2,75.3 45.97,78.53 45.97,79.95 44.44,81.48 44.44,83.67 41.94,86.17 41.94,86.5 42.17,86.73 42.17,86.89 41.93,87.14 41.77,87.14 41.54,86.9 41.21,86.9 37.13,90.98 37.13,92.51 28.06,101.57 28.06,115.04 27.64,115.45 27.64,121.25
  BOTTOM w0.076: U0300.BD3 29.7,126.23 29.64,126.23 29.35,125.94 29.35,122.79 29.17,122.61 28.97,122.61 28.92,122.66 28.92,122.79 28.99,122.86 28.99,122.94 28.93,123.01 v7(28.57,123.01)
  BOTTOM w0.159: CON1601.74 49.88,70.08 49.59,70.37 49.34,70.37 48.9,70.8 48.9,72.26 49.17,72.53 49.69,72.53 49.94,72.27 49.94,72.04 50.06,71.92 v2(50.17,71.92)
M_CHA_DQS4: length 84.3
  TOP w0.159: v2(80.06,73.8) 80.52,73.35 80.52,72.96 79.43,71.88 79.43,70.72 80.13,70.03 CON1600.179
  IN1 w0.076: 53.85,115.58 53.85,115.83 47.25,122.43 47.25,122.62 46.99,122.88 46.99,122.98 47.04,123.03 47.4,123.03 47.48,123.1 47.48,123.21 47.4,123.28 46.6,123.28 v6(46.6,123.28)
  IN1 w0.114: v2(80.06,73.8) 79.98,73.73 79.79,73.73 79.67,73.85 79.67,76.47 81.38,78.19 81.38,81.07 81.53,81.22 81.97,81.22 82.14,81.39 82.14,82.32 81.91,82.54 81.72,82.54 81.61,82.66 81.61,88.89 80.79,89.71 80.38,89.71 80.2,89.52 79.72,89.52 79.4,89.84 79.4,90.25 78.95,90.7 78.55,90.7 64.72,104.52 62.33,104.52 53.85,113.01 53.85,115.58
  BOTTOM w0.076: U0300.AB3 47.42,126.39 46.96,125.94 46.96,123.65 v6(46.6,123.28)
  BOTTOM w0.159: CON1601.179 78.13,76.47 79.23,75.37 79.23,74.01 79.36,73.88 79.55,73.88 79.65,73.98 79.65,74.27 79.76,74.37 79.96,74.37 80.06,74.27 v2(80.06,73.8)
M_CHA_DQS4#: length 84.3
  TOP w0.159: v2(80.06,73.17) 79.76,73.47 79.58,73.47 79.4,73.29 79.4,73.06 79.69,72.78 79.69,72.5 79.17,71.99 79.17,70.61 79.63,70.16 CON1600.177
  IN1 w0.076: v7(46.65,122.63) 46.65,122.63 46.77,122.75 46.89,122.75 47.09,122.55 47.09,122.36 53.66,115.78 53.66,115.61 53.65,115.59 53.65,115.58
  IN1 w0.114: 53.65,115.58 53.65,112.92 62.25,104.32 64.64,104.32 78.46,90.49 78.87,90.49 79.2,90.16 79.2,89.76 79.64,89.32 80.28,89.32 80.47,89.5 80.7,89.5 81.4,88.8 81.4,82.57 81.64,82.34 81.83,82.34 81.93,82.23 81.93,81.48 81.88,81.42 81.45,81.42 81.18,81.15 81.18,78.27 79.47,76.56 79.47,73.76 v2(80.06,73.17)
  BOTTOM w0.076: U0300.AA3 47.87,126.06 47.32,126.06 47.13,125.87 47.13,123.11 v7(46.65,122.63)
  BOTTOM w0.159: v2(80.06,73.17) 79.61,73.62 79.25,73.62 78.97,73.9 78.97,75.26 78.01,76.22 77.87,76.22 77.63,76.47 CON1601.177
