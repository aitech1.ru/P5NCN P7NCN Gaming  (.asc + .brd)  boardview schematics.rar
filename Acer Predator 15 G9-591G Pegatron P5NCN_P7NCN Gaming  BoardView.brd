# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FAN0_TACH: length 148.7
  TOP w0.102: v2(107.14,36.81) 108.28,37.95 U3001.47
  IN2 w0.102: v2(33.04,94.78) 32.11,93.85 32.11,79.06 34.72,76.44 34.72,76.44 34.79,76.37 34.79,69.15 35.74,68.2 35.74,66.73 39.4,63.08 39.4,61.19 39.8,60.78 39.8,58.01 40.85,56.95 53.06,56.95 53.77,56.24 53.77,53.64 55.41,52 64.79,52 65.67,51.12 75.85,51.12 76.44,50.54 99.07,50.54 102.84,46.77 v2(107.29,46.77)
  BOTTOM w0.102: v2(107.29,46.77) 107.29,44.67 107.47,44.49 107.47,39.7 v1(107.13,39.36) 107.14,39.35 v2(107.14,36.81) ; v2(33.04,94.78) 33.04,102.53 38.7,108.2 39.16,108.2 39.64,108.67 D5001.3 39.64,109.73 39.12,110.25 R5003.2 R5005.1
FAN1_PWM: length 108.1
  TOP w0.102: U3001.31 113.12,44.41 112.8,44.08 v2(112.7,44.08)
  IN2 w0.102: v2(112.7,44.08) 112.7,44.83 113.71,45.85 115.14,45.85 116.29,47.01 117.81,47.01 118.9,45.91 122.89,45.91 124.11,47.13 133.11,47.13 133.54,47.57 139.96,47.57 143.52,51.13 143.52,53.5 144.48,54.45 145.51,54.45 147.06,56 148.83,56 149.89,57.07 149.89,57.44 152.68,60.23 154.76,60.23 157.54,63.01 157.54,63.82 158.91,65.19 168.02,65.19 170,67.17 174.32,67.17 175.59,68.44 175.59,69.39 176.53,70.32 177.45,70.32 178.17,71.04 180.24,71.04 181.49,72.29 186.75,72.29 v2(187.45,72.99)
  BOTTOM w0.102: v2(187.45,72.99) 187.43,73.01 187.43,78.53 188.02,79.12 188.2,79.12 188.42,79.33 188.42,81.72 188.85,82.15 191.04,82.15 191.81,82.92 191.81,83.64 R5007.2 R5010.1 ; v1(111.95,44.18) 112.61,44.18 v2(112.7,44.08)
FAN1_TACH: length 191.2
  TOP w0.102: U3001.48 113.6,37.55 114.68,36.47 v2(114.68,35.68) ; v1(189.66,68.67) v2(189.66,69.31)
  IN1 w0.102: v2(189.66,69.31) 190.24,68.73 193.33,68.73 199.4,62.66 199.4,60.5 199.86,60.04 200.88,60.04 201.21,60.36 201.21,62.39 203.03,64.22 213.2,64.22 213.77,64.79 215.22,64.79 216.13,63.88 219.15,63.88 219.74,63.29 219.74,60.14 219.59,59.99 219.59,59.35 217.61,57.37 214.12,57.37 213.6,56.85 213.6,49.53 209.52,45.45 209.52,43.83 v2(208.92,43.22)
  IN2 w0.102: v2(114.68,35.68) 116.05,35.68 116.54,35.19 123.5,35.19 124.8,36.49 139.18,36.49 140.85,38.17 167.32,38.17 168.54,36.95 184.03,36.95 184.87,37.79 193.55,37.79 194.01,38.24 203.28,38.24 206.78,41.75 207.73,41.75 208.92,42.93 v2(208.92,43.22)
  BOTTOM w0.102: v2(189.66,69.31) 189.44,69.31 188.46,70.3 188.46,71.62 187.58,72.5 187.37,72.5 187.04,72.82 187.04,78.49 187.87,79.32 188.12,79.32 188.22,79.42 188.22,81.57 187.9,81.88 D5003.3 187,82.59 187.58,83.17 189,83.17 189.94,84.11 R5008.2 R5009.1
FAN2_DETECT: length 95.8
  TOP w0.102: v2(114.04,32.16) 114.21,32.16 114.32,32.05 U3001.69 ; v2(31.72,33.42) 30.73,32.43 28.63,32.43 v1(28.37,32.17) 28.12,32.17 26.9,30.95 R5124.2
  IN1 w0.102: v2(31.72,33.42) 32.26,33.96 51.39,33.96 52.09,34.66 67.72,34.66 68.56,33.82 82.08,33.82 84.97,36.72 105.96,36.72 110.89,31.79 113.67,31.79 v2(114.04,32.16)
FAN2_PWM: length 64.7
  TOP w0.102: v2(113.79,43.3) 113.24,42.75 112.51,42.75 112.27,42.99 112.27,44.39 112.34,44.47 112.56,44.47 112.72,44.63 U3001.32 ; v2(151.18,43.25) 151.79,43.25 152.81,42.23 v1(152.81,41.5) 152.82,41.48 152.82,34.7 154.21,33.32 155.62,33.32 156.52,32.42 156.52,32.26 157.44,31.34 158.42,31.34 158.88,30.88 R5139.1
  IN2 w0.102: v2(151.18,43.25) 148.84,43.25 147.8,42.21 147.8,40.68 147.03,39.91 135.94,39.91 135.12,40.73 133.36,40.73 129.25,44.84 118.52,44.84 118.37,44.98 115.47,44.98 v2(113.79,43.3)
FAN2_TACH: length 99.4
  TOP w0.102: v2(33.28,32.67) 32.83,32.67 30.39,30.23 29.21,30.23 v1(28.91,29.93) 28.6,29.63 R5125.2 ; v2(114.94,32.16) 116.12,32.16 117.83,30.45 118.19,30.45 118.32,30.32 U3001.79
  IN1 w0.102: v2(114.94,32.16) 114.94,31.82 114.71,31.59 110.8,31.59 105.88,36.52 85.06,36.52 81.96,33.42 68.58,33.42 67.54,34.45 52.28,34.45 51.06,33.24 33.86,33.24 v2(33.28,32.67)
FAN_REVERSE: length 227
  TOP w0.102: U3001.29 113.92,45.94 113.31,46.55 v2(112.98,46.55) ; R5016.1 183.28,74.89 182.68,74.29 182.68,73.07 182.4,72.79 179.15,72.79 178.45,72.09 v2(178.45,71.61) ; R5015.1 29.69,110.56 30.33,109.92 30.33,106.46 32.06,104.74 v1(32.06,104.01) 31.93,103.88 v2(31.93,95.57)
  IN2 w0.102: v2(31.93,95.57) 31.7,95.34 31.7,78.85 34.38,76.17 34.38,68.86 35.1,68.14 35.1,66.79 38.99,62.91 38.99,61.02 39.4,60.61 39.4,57.7 40.61,56.48 49.54,56.48 50.28,55.74 50.28,54.18 52.87,51.59 64.62,51.59 65.5,50.72 75.68,50.72 76.34,50.06 98.74,50.06 102.93,45.86 112.29,45.86 v2(112.98,46.55) 112.98,47.31 113.48,47.82 118.15,47.82 118.35,47.62 123.44,47.62 124,48.18 131.52,48.18 131.8,48.45 136.61,48.45 137.42,49.27 140.79,49.27 142.84,51.32 142.84,53.68 143.19,54.03 143.19,55.9 144.52,57.22 148.95,57.22 152.52,60.8 154.75,60.8 157.13,63.17 157.13,64.03 158.7,65.6 167.86,65.6 169.83,67.58 172.16,67.58 175.12,70.53 177.37,70.53 v2(178.45,71.61)
FB_A: length 7.1
  TOP w0.152: v2(11.35,173.12) 11.35,173.12 v1(12.01,173.78) 11.74,174.06 R80100.2 11.94,175.73 12.62,175.73 13.13,176.24 R8049.2 13.18,176.42 13.59,176.83 R8080.2
  BOTTOM w0.152: v2(11.35,173.12) 11.07,173.41 U8000.17
FB_B: length 5.4
  BOTTOM w0.102: R8015.2 15.05,178.37 v1(14.94,178.26)
  BOTTOM w0.203: R8015.2 16.15,178.53 R8037.2 R8023.2 15.18,179.21 13.75,177.78 U8000.5
FB_C: length 6.7
  TOP w0.102: R8099.1 3.48,178.02 R8079.1 R8047.1 4.88,177.62 v2(5.09,177.4)
  BOTTOM w0.152: U8000.30 7.14,176.98 6.83,177.29 6.22,177.29 5.52,176.6 5.04,176.6 v1(4.82,176.82) 4.82,177.13 v2(5.09,177.4)
FBA_CLK0: length 36.8
  TOP w0.133: R7602.1 121.67,176.54 121.2,176.54 120.95,176.3 v7(120.95,176.3)
  IN1 w0.102: v6(109.1,153.5) 109.1,153.21 109.02,153.13 108.8,153.13 108.67,153.27 108.67,156.4 107.75,157.32 107.75,159.22 107.08,159.89 107.08,160.15 107.54,160.6 107.72,160.6 108.05,160.27 108.61,160.27 108.98,160.63 108.98,161.11 112.65,164.77 113.61,164.77 116.77,167.93 117.06,167.93 117.95,168.82 117.95,173.9 117.94,173.91 117.94,173.93 117.8,174.07 117.8,175.15 117.98,175.33 118.35,175.33 118.88,175.85 119.62,175.85 119.79,175.68 120.45,175.68 120.73,175.96 120.73,176.24 120.78,176.3 v7(120.95,176.3)
  BOTTOM w0.133: U7600.J12 120.53,176.41 120.64,176.3 v7(120.95,176.3) ; U7000.AF41 108.57,153.9 108.46,153.79 108.46,153.6 108.56,153.5 v6(109.1,153.5)
FBA_CLK0#: length 36.8
  TOP w0.133: R7602.2 121.69,176.88 121.18,176.88 v6(120.96,177.09)
  IN1 w0.102: v6(120.96,177.09) 120.54,176.66 120.54,176.04 120.37,175.87 119.87,175.87 119.7,176.04 118.8,176.04 118.28,175.52 117.9,175.52 117.61,175.22 117.61,173.99 117.65,173.95 117.75,173.85 117.75,173.83 117.75,173.82 117.75,168.9 116.98,168.12 116.69,168.12 113.53,164.97 112.57,164.97 108.79,161.19 108.79,160.71 108.53,160.46 108.13,160.46 107.8,160.79 107.46,160.79 106.89,160.23 106.89,159.81 107.56,159.15 107.56,157.24 108.48,156.32 108.48,153.19 108.72,152.94 108.87,152.94 v6(109.08,152.73)
  BOTTOM w0.133: U7600.J11 120.96,177.04 v6(120.96,177.09) ; U7000.AF40 108.71,153.1 v6(109.08,152.73)
FBA_CLK1: length 34.3
  TOP w0.133: v6(113.61,177.08) 113.37,176.83 112.87,176.83 R7603.1
  IN1 w0.102: v6(113.61,177.08) 113.8,176.89 113.96,176.89 114.51,176.33 115.98,176.33 116.33,176.68 117.01,176.68 117.39,176.3 117.39,175.95 116.65,175.21 116.65,174.21 117.25,173.61 117.25,169.92 116.64,169.31 116.64,168.79 114.55,166.69 114.24,166.69 114.18,166.76 113.99,166.76 113.74,166.52 113.74,165.89 113.32,165.47 112.3,165.47 108.02,161.19 106.38,161.19 105.4,160.21 105.4,159.84 106.31,158.92 106.31,157.09 v7(105.92,156.69)
  BOTTOM w0.133: v6(113.61,177.08) 113.61,177.07 U7601.J12 ; v7(105.92,156.69) 105.92,156.68 U7000.AJ44
FBA_CLK1#: length 33.8
  TOP w0.133: v7(113.62,176.27) 113.45,176.44 112.79,176.44 R7603.2
  IN1 w0.102: v7(113.62,176.27) 113.46,176.42 113.46,176.54 113.62,176.7 113.88,176.7 114.44,176.14 116.06,176.14 116.41,176.49 116.93,176.49 117.2,176.22 117.2,176.03 116.46,175.29 116.46,174.13 117.06,173.54 117.06,169.99 116.45,169.38 116.45,168.86 114.47,166.89 114.32,166.89 114.25,166.95 113.91,166.95 113.55,166.6 113.55,165.97 113.25,165.66 112.22,165.66 107.94,161.38 106.3,161.38 105.21,160.29 105.21,159.76 106.12,158.84 106.12,157.67 v6(105.93,157.48)
  BOTTOM w0.133: v6(105.93,157.48) 105.93,157.23 106.06,157.1 U7000.AJ45 ; U7601.J11 113.46,176.67 113.62,176.52 v7(113.62,176.27)
FBA_CMD0: length 26
  TOP w0.133: v6(115.36,161.23) 115.56,161.43 115.62,161.43 116.84,162.65 116.84,163.21 118.08,164.45 v1(118.08,165.64) 118.08,166.42 123.04,171.38 123.04,173.14 123.83,173.93 123.83,174.68 125.73,176.58 126.87,176.58 v6(128.14,177.86)
  BOTTOM w0.133: v6(115.36,161.23) 115.5,161.09 115.5,159.1 U7000.U47 ; v6(128.14,177.86) U7600.G3
FBA_CMD1: length 34.2
  TOP w0.133: R7100.1 115.37,162.43 v6(115.7,162.1)
  BOTTOM w0.133: U7000.U48 116.28,159.88 116.28,161.51 v6(115.7,162.1) 116.99,162.1 117.35,162.45 119.97,162.45 123.96,166.44 v1(129.01,166.44) 129.45,166.44 130.93,167.92 130.93,176.53 130.36,177.1 128.16,177.1 U7600.J3
FBA_CMD2: length 30.8
  TOP w0.133: R7102.2 115.98,163.01 v6(115.98,162.63)
  BOTTOM w0.133: U7600.J2 128.93,176.27 130,176.27 130.53,175.74 130.53,168.93 v1(129.92,168.32) 129.73,168.13 129.73,167.29 129.49,167.05 124,167.05 119.78,162.83 116.18,162.83 v6(115.98,162.63) 115.57,162.63 115.27,162.32 115.27,161.89 115.9,161.26 U7000.U49
FBA_CMD3: length 25.7
  TOP w0.133: v6(127.34,176.26) 127.29,176.22 127.07,176.22 127.03,176.18 125.89,176.18 124.24,174.53 124.24,173.78 123.44,172.98 123.44,171.13 118.55,166.24 118.55,164.28 v1(118.04,163.77) 117.25,162.98 117.25,162.56 115.49,160.8 115.06,160.8 v6(114.55,161.31)
  BOTTOM w0.133: U7600.L3 127.34,175.47 v6(127.34,176.26) ; U7000.V48 115.1,159.79 114.55,160.34 v6(114.55,161.31)
FBA_CMD4: length 22.6
  BOTTOM w0.133: U7000.V49 115.1,160.79 114.96,160.93 114.96,162.58 115.81,163.43 118.51,163.43 118.85,163.77 v1(119.23,163.77) 119.72,163.77 125.2,169.25 125.2,175.31 125.77,175.87 U7600.K5
FBA_CMD5: length 26.5
  BOTTOM w0.133: U7000.V47 114.73,159.07 114.73,159.65 114.15,160.24 114.15,162.5 115.49,163.84 118.21,163.84 119.71,165.35 v1(120.27,165.35) 120.73,165.35 124.77,169.38 124.77,175.56 125.47,176.27 126.54,176.27 U7600.K4
FBA_CMD6: length 24.3
  TOP w0.133: v6(112.52,161) 112.52,161.49 112.4,161.61 112.4,163.18 116.36,167.15 117.94,167.15 v1(118.57,167.78) 121.32,170.52 121.32,172.12 121.34,172.14 121.34,172.79 121.98,173.43 122.33,173.43 122.33,173.43 122.65,173.43 122.66,173.43 122.72,173.43 123.43,174.14 123.43,174.85 125.56,176.98 v6(125.58,176.98)
  BOTTOM w0.133: v6(125.58,176.98) 125.89,176.67 U7600.J5 ; v6(112.52,161) 112.52,160.48 U7000.AA49
FBA_CMD7: length 27.6
  TOP w0.133: v6(112.34,159.87) 112.13,160.08 112.13,161.32 111.94,161.51 111.94,163.38 116.15,167.6 117.57,167.6 119.89,169.92 v1(119.89,170.4) 120.21,170.72 120.21,171.46 120.52,171.77 120.52,174.03 120.8,174.3 122.73,174.3 123.03,174.6 123.03,175.01 125.44,177.42 126.18,177.42 v6(126.54,177.06)
  BOTTOM w0.133: v6(126.54,177.06) U7600.J4 ; U7000.AA48 112.35,159.85 112.35,159.86 v6(112.34,159.87)
FBA_CMD8: length 27.6
  TOP w0.133: v6(111.48,159.88) 111.89,160.29 111.89,161.1 111.48,161.51 111.48,163.49 116.57,168.58 116.57,169.32 117.17,169.92 v1(117.82,169.92) 118.52,169.92 118.82,170.22 118.82,173.07 119.21,173.45 119.54,173.45 119.95,173.86 119.95,174.33 120.75,175.13 122.58,175.13 125.31,177.86 v6(125.74,177.86)
  BOTTOM w0.133: v6(111.48,159.88) 111.1,159.5 U7000.AC48 ; U7600.H5 126.13,177.47 v6(125.74,177.86)
FBA_CMD9: length 28.3
  TOP w0.133: v6(111.44,160.89) 110.87,161.45 110.87,163.45 115.5,168.08 v1(115.5,168.49) 115.5,168.91 117.81,171.21 117.81,173.95 118.14,174.28 119.34,174.28 120.58,175.53 122.28,175.53 125.17,178.42 125.76,178.42 126.32,177.87 v6(126.54,177.87)
  BOTTOM w0.133: U7600.H4 v6(126.54,177.87) ; U7000.AC49 111.44,160.63 v6(111.44,160.89)
FBA_CMD10: length 26.4
  TOP w0.133: v6(111.51,158.29) 110.95,158.85 110.95,159.89 110.24,160.6 110.24,163.39 113.73,166.88 113.73,167.76 117.25,171.27 v1(117.25,172.61) 117.25,173.99 118.35,175.09 119,175.09 119.08,175.01 119.5,175.01 119.8,175.31 119.8,175.72 119.61,175.91 119.61,176.28 119.8,176.47 119.8,177.7 119.96,177.87 v6(120.14,177.87)
  BOTTOM w0.133: U7600.G12 120.35,178.09 120.35,178.08 v6(120.14,177.87) ; U7000.AC47 v6(111.51,158.29)
FBA_CMD11: length 27.2
  BOTTOM w0.133: U7000.AD49 110.3,161.52 113.8,165.02 v1(115.9,165.02) 116.61,165.73 118.77,165.73 119.51,166.46 120.72,166.46 123.89,169.63 123.89,176.43 122.76,177.56 122.22,177.56 U7600.H10
FBA_CMD12: length 29.9
  BOTTOM w0.133: U7600.H11 121.78,177.92 123.06,177.92 124.33,176.66 124.33,169.51 120.85,166.03 119.71,166.03 117.96,164.28 v1(113.94,164.28) 113.63,164.28 110.74,161.4 110.74,159.94 U7000.AD48
FBA_CMD13: length 28.6
  BOTTOM w0.133: U7600.K11 121.68,176.22 123.14,176.22 123.45,175.91 123.45,169.76 120.86,167.18 v1(119.84,167.18) 119.58,167.18 118.8,166.39 116.38,166.39 115.85,165.85 113.94,165.85 109.94,161.85 109.94,159.06 U7000.AD47
FBA_CMD14: length 26.9
  BOTTOM w0.133: U7000.AF47 109.09,159.09 109.09,161.61 113.77,166.29 115.71,166.29 116.41,166.98 118.63,166.98 119.99,168.34 v1(121.13,168.34) 123.01,170.22 123.01,175.56 122.7,175.87 U7600.K10
FBA_CMD15: length 24.2
  TOP w0.133: v6(108.3,159.1) 108.97,159.77 108.97,160.45 109.48,160.96 v1(109.48,162.02) 109.48,163.31 113.07,166.9 113.07,167.79 116.69,171.41 116.69,174.09 118.09,175.49 119.17,175.49 119.24,175.41 v6(119.33,175.41)
  BOTTOM w0.133: U7000.AF48 v6(108.3,159.1) ; U7600.L12 120.18,174.73 119.59,174.73 119.33,174.98 v6(119.33,175.41)
FBA_CMD16: length 25.5
  BOTTOM w0.133: U7601.L3 106.46,177.92 104.42,177.92 104.11,177.61 102.56,177.61 102.26,177.3 102.26,172.28 101.89,171.91 101.89,170.27 99.88,168.26 98.45,168.26 96.14,165.96 v1(96.14,165.55) 96.14,163.84 95.81,163.51 95.81,160.39 U7000.BB49
FBA_CMD17: length 23.2
  BOTTOM w0.133: U7601.J3 106.43,176.29 104.52,176.29 103.35,175.12 103.35,172.11 102.79,171.55 102.79,170 99.59,166.8 v1(99.59,166.59) 99.59,165.67 R7101.1 98.6,164.1 98.1,163.59 97.46,163.59 96.7,162.83 96.7,160.92 97.06,160.56 97.06,160.04 96.7,159.69 U7000.BA48
FBA_CMD18: length 24.1
  BOTTOM w0.133: U7601.J2 105.63,177.05 104.11,177.05 103.96,177.21 102.83,177.21 102.66,177.04 102.66,172.12 102.29,171.75 102.29,170.11 100,167.82 98.64,167.82 97.1,166.28 R7105.2 97.06,165.55 96.54,165.03 96.54,163.59 v1(96.53,163.58) 96.24,163.29 96.24,160.76 U7000.BA49
FBA_CMD19: length 20.2
  BOTTOM w0.133: U7000.AW49 98.63,160.63 98.63,163.34 99.46,164.16 99.46,164.57 v1(99.66,164.77) 100.13,165.24 100.13,166.77 103.3,169.94 103.3,171.37 103.78,171.85 103.78,174.77 104.46,175.44 106.44,175.44 U7601.G3
FBA_CMD20: length 23.5
  TOP w0.133: v6(108.84,175.5) 109.27,175.5 109.91,174.87 109.91,167.27 v1(105.25,162.61) 103.08,160.44 102.01,160.44 101.45,159.88 v6(99.49,159.88)
  BOTTOM w0.133: v6(99.49,159.88) 99.44,159.83 99.43,159.83 U7000.AV48 ; v6(108.84,175.5) 108.64,175.7 108.59,175.7 108.42,175.87 U7601.H5
FBA_CMD21: length 21.4
  BOTTOM w0.133: U7000.AV49 99.1,162.82 v1(99.24,162.95) 99.24,163.38 100.53,164.67 100.53,166.6 103.81,169.89 103.81,171.19 104.18,171.56 104.18,174.29 104.53,174.64 107.87,174.64 108.03,174.8 108.03,175.45 U7601.H4
FBA_CMD22: length 21.2
  BOTTOM w0.133: U7000.AN48 103.1,159.7 103.54,160.14 103.54,162.05 105.92,164.43 105.92,164.62 105.6,164.94 105.6,165.13 v1(105.87,165.4) 106.05,165.4 106.37,165.07 106.57,165.07 106.76,165.26 106.76,167.76 108.76,169.77 108.76,170.73 109.24,171.2 109.24,175.85 U7601.J5
FBA_CMD23: length 20.3
  TOP w0.133: v6(108,176.29) 108,175.78 108.71,175.06 109,175.06 109.42,174.64 109.42,167.73 v1(103.64,161.94) v6(102.59,160.9)
  BOTTOM w0.133: U7000.AN49 102.85,160.56 102.85,160.64 v6(102.59,160.9) ; v6(108,176.29) 107.62,176.67 U7601.J4
FBA_CMD24: length 23
  BOTTOM w0.133: U7000.AM47 103.5,159.1 103.5,159.69 103.74,159.93 104.12,159.93 104.26,160.07 104.26,161.89 104.8,162.43 105.05,162.43 108.23,165.6 v1(108.23,166.01) 108.23,168.04 109.56,169.37 109.56,170.44 110.08,170.96 110.08,176.27 108.88,177.47 U7601.K5
FBA_CMD25: length 20.7
  BOTTOM w0.133: U7601.K4 108.01,177.07 108.6,177.07 109.63,176.04 109.63,171.05 109.16,170.59 109.16,169.56 107.44,167.84 v1(107.44,167.66) 107.44,165.38 103.9,161.84 U7000.AM49
FBA_CMD26: length 25.1
  BOTTOM w0.133: U7000.AM48 104.11,159.5 104.48,159.88 104.48,161.79 104.9,162.2 105.4,162.2 108.89,165.7 108.89,167.28 v1(109.19,167.58) 109.19,168.39 109.96,169.16 109.96,170.28 110.59,170.9 110.59,177.51 111.19,178.11 112.05,178.11 112.28,177.88 113.62,177.88 U7601.L12
FBA_CMD27: length 23
  TOP w0.133: v6(111.91,177.47) 110.63,177.47 110.03,176.88 110.03,175.76 110.31,175.48 110.31,167 106.7,163.4 106.7,162.77 107.26,162.22 107.26,161.58 106.7,161.02 v1(106.7,160.25) v6(106.7,159.1)
  BOTTOM w0.133: v6(111.91,177.47) U7601.K10 ; v6(106.7,159.1) 106.68,159.08 U7000.AJ47
FBA_CMD28: length 21.4
  BOTTOM w0.133: U7000.AJ49 106.3,161.1 106.17,161.23 106.05,161.23 105.92,161.36 105.92,161.74 106.05,161.87 106.17,161.87 106.3,162 106.3,162.54 108.98,165.22 109.5,165.22 v1(109.99,165.71) 110.36,166.08 110.36,170.03 111.07,170.74 111.07,176.4 111.74,177.07 112.81,177.07 U7601.K11
FBA_CMD29: length 21.3
  BOTTOM w0.133: U7000.AJ48 106.3,159.72 106.73,160.14 106.73,162.41 108.43,164.1 v1(109.07,164.1) 110.01,164.1 110.76,164.86 110.76,169.93 111.48,170.65 111.48,175.61 112.12,176.24 112.85,176.24 U7601.H11
FBA_CMD30: length 21.6
  TOP w0.133: v6(108.31,159.89) 107.84,160.35 107.84,163.69 110.93,166.77 110.93,171.32 111.06,171.45 111.41,171.45 111.59,171.63 111.59,171.87 111.48,171.98 111.06,171.98 110.92,172.12 110.92,172.4 111.06,172.53 111.47,172.53 111.61,172.66 111.61,173.04 111.47,173.17 111.06,173.17 110.92,173.3 110.92,173.7 111.12,173.9 v1(111.46,173.9) 112.1,173.9 112.39,174.19 112.39,174.9 112.78,175.29 v6(112.78,175.51)
  BOTTOM w0.133: v6(108.31,159.89) 108.31,159.86 108.08,159.63 108.03,159.63 U7000.AG48 ; U7601.H10 112.78,175.51 v6(112.78,175.51)
FBA_CMD31: length 21.3
  TOP w0.133: v6(113.61,174.67) 113.34,174.67 113.22,174.55 113.22,171.31 113.51,171.02 113.51,169.42 113.08,168.99 111.68,168.99 111.55,168.86 111.55,168.36 111.68,168.23 112.03,168.23 112.16,168.1 112.16,167.84 112.03,167.71 111.7,167.71 111.56,167.58 111.56,167.29 111.7,167.15 111.94,167.15 112.07,167.03 112.07,166.73 111.94,166.6 111.49,166.6 111.25,166.36 111.25,166.2 110.24,165.19 110.24,165 110.3,164.94 110.3,164.75 110.11,164.56 109.92,164.56 109.87,164.62 109.68,164.62 v1(109.51,164.45) 109.31,164.25 109.31,164.06 109.35,164.02 109.35,163.83 109.16,163.64 108.98,163.64 108.93,163.69 108.74,163.69 108.36,163.3 108.36,162.81 108.51,162.66 108.51,162.16 108.36,162.01 v6(108.36,160.85)
  BOTTOM w0.133: v6(113.61,174.67) 113.9,174.67 114.01,174.79 U7601.G12 ; v6(108.36,160.85) 108.18,160.67 108.18,160.58 U7000.AG49
FBA_D0: length 31.5
  IN1 w0.095: v6(114.69,155.1) 114.69,155.93 115.35,156.59 115.35,159.27 118.62,162.54 118.68,162.54 119.94,163.81 119.94,164.29 122.91,167.25 123.75,167.25 125.15,168.65 125.15,169.38 126.03,170.26 126.76,170.26 126.93,170.43 126.93,178 127.17,178.24 127.64,178.24 v6(128.06,178.67)
  BOTTOM w0.133: v6(114.69,155.1) 114.96,155.37 114.97,155.37 U7000.V43 ; U7600.F2 128.36,178.9 128.29,178.9 v6(128.06,178.67)
FBA_D1: length 42.6
  IN1 w0.095: v6(128.91,183.45) 129.61,182.75 130.21,182.75 131.84,181.12 131.84,175.05 131.74,174.95 131.74,169.36 128.38,166 127.7,166 126.25,164.55 125.11,164.55 124.14,163.58 123.56,163.58 120.66,160.68 118.95,160.68 118.13,159.86 118.13,155.86 117.48,155.22 117.48,154.15 117.26,153.92 116.68,153.92 v6(116.31,154.29)
  BOTTOM w0.133: U7600.A2 128.91,183.45 v6(128.91,183.45) ; v6(116.31,154.29) 115.5,154.29 U7000.V41
FBA_D2: length 30.2
  IN1 w0.095: v6(126.56,178.7) 126.12,178.26 126.12,174.49 126.13,174.48 126.13,173.7 126.13,173.69 126.13,170.76 124.87,169.5 124.87,168.77 123.63,167.53 122.79,167.53 119.66,164.4 119.66,163.93 115.11,159.38 115.11,157.27 114.93,157.09 114.56,157.09 114.3,156.83 114.3,156.42 v6(114,156.12)
  BOTTOM w0.133: v6(114,156.12) 114.53,156.12 114.71,156.3 U7000.V44 ; U7600.F4 v6(126.56,178.7)
FBA_D3: length 32
  IN1 w0.095: v6(115.49,155.09) 115.18,155.39 115.18,156.15 115.54,156.5 115.54,159.2 118.31,161.97 118.51,161.97 120.35,163.81 120.35,164.18 123.13,166.96 123.92,166.96 127.26,170.3 127.46,170.3 127.73,170.57 127.73,176.91 128.52,177.7 128.52,179.07 v6(128.93,179.48)
  BOTTOM w0.133: U7000.V42 v6(115.49,155.09) ; U7600.E2 v6(128.93,179.48)
FBA_D4: length 34.1
  IN1 w0.095: v6(127.31,179.49) 127.7,179.89 129.05,179.89 129.3,179.63 129.3,178.72 128.96,178.38 128.96,177.12 128.53,176.69 128.53,170.22 127.97,169.66 127.97,169.28 127.16,168.47 125.94,168.47 123.93,166.46 123.04,166.46 120.64,164.06 120.64,163.69 118.73,161.78 118.49,161.78 115.75,159.05 115.75,156.09 v6(115.56,155.9)
  BOTTOM w0.133: v6(127.31,179.49) 127.31,179.5 U7600.E4 ; v6(115.56,155.9) 115.78,155.68 115.78,155.63 U7000.U43
FBA_D5: length 38.4
  IN1 w0.095: v6(127.36,182.7) 127.36,182.39 128.13,181.61 129.1,181.61 129.37,181.34 130.35,181.34 130.98,180.71 130.98,175.4 130.88,175.31 130.88,169.71 128.04,166.87 126.22,166.87 124.17,164.82 123.59,164.82 120,161.23 118.72,161.23 117.53,160.04 117.53,157.36 117.28,157.11 116.7,157.11 v6(116.32,156.72)
  BOTTOM w0.133: v6(116.32,156.72) 116.13,156.53 116.13,156.53 U7000.U44 ; U7600.B4 v6(127.36,182.7)
FBA_D6: length 43.9
  IN1 w0.095: v6(127.39,183.53) 127.85,183.07 128.43,183.07 128.55,182.95 128.55,182.46 128.78,182.23 129.49,182.23 129.69,182.43 130.07,182.43 131.55,180.95 131.55,175.17 131.45,175.07 131.45,169.48 128.26,166.28 127.58,166.28 126.13,164.84 124.99,164.84 124.33,164.18 123.76,164.18 120.44,160.86 118.87,160.86 117.93,159.93 117.93,155.93 117.46,155.46 116.98,155.46 116.7,155.17 116.7,154.96 116.42,154.69 116.17,154.69 115.9,154.42 115.9,153.9 v6(116.36,153.45)
  BOTTOM w0.133: v6(116.36,153.45) U7000.U41 ; U7600.A4 v6(127.39,183.53)
FBA_D7: length 39.4
  IN1 w0.095: v6(128.17,182.64) 128.17,182.13 128.4,181.9 129.31,181.9 129.59,181.63 130.47,181.63 131.26,180.83 131.26,175.28 131.17,175.19 131.17,169.59 128.15,166.57 126.32,166.57 124.21,164.46 123.64,164.46 120.22,161.05 118.79,161.05 117.71,159.96 117.71,157.01 116.73,156.02 116.73,155.53 v6(116.28,155.08)
  BOTTOM w0.133: v6(116.28,155.08) 115.9,154.7 U7000.U42 ; U7600.B2 128.19,182.61 128.19,182.62 v6(128.17,182.64)
FBA_D8: length 29.5
  IN1 w0.095: v6(121.72,180.25) 122.3,179.67 122.3,179.03 122.53,178.81 122.76,178.81 123.27,178.29 123.27,171.25 122.5,170.48 122.5,170.05 122.35,169.9 121.62,169.9 117.62,165.9 117.14,165.9 114.33,163.09 113.54,163.09 112.9,162.45 112.9,158.46 v6(113.06,158.31)
  BOTTOM w0.133: U7600.E11 121.69,180.23 121.69,180.23 v6(121.72,180.25) ; U7000.AA46 112.7,158.13 112.88,158.31 v6(113.06,158.31)
FBA_D9: length 29.9
  IN1 w0.095: v6(120.12,179.46) 120.24,179.34 120.24,178.46 120.42,178.27 120.9,178.27 121.48,177.7 121.48,175.84 120.51,174.87 120.51,174.41 119.73,173.63 119.73,169.68 117.34,167.28 116.84,167.28 113.82,164.27 113.03,164.27 110.56,161.8 110.56,157.94 111.01,157.49 v6(111.51,157.49)
  BOTTOM w0.133: v6(111.51,157.49) 111.11,157.9 U7000.AC46 ; U7600.F13 v6(120.12,179.46)
FBA_D10: length 32.4
  IN1 w0.095: v6(112.29,156.68) 112.18,156.8 112.18,158.29 111.79,158.68 111.26,158.68 110.93,159.01 110.93,161.36 113.27,163.7 114.1,163.7 116.88,166.47 117.39,166.47 120.37,169.45 120.37,170.83 120.57,171.03 121,171.03 121.34,171.37 121.34,172.77 122.1,173.52 122.1,178 121.99,178.1 121.99,178.54 121.39,179.14 121.39,179.58 121.05,179.92 120.68,179.92 120.33,180.28 v6(120.13,180.28)
  BOTTOM w0.133: v6(112.29,156.68) 112.29,156.69 U7000.AA45 ; U7600.E13 v6(120.13,180.28)
FBA_D11: length 27.8
  IN1 w0.095: v6(121.77,179.47) 121.77,179.16 122.28,178.65 122.28,178.22 122.98,177.51 122.98,171.37 122.2,170.58 122.2,170.46 121.92,170.18 121.5,170.18 117.51,166.18 117,166.18 114.19,163.37 113.4,163.37 111.9,161.87 111.9,159.57 v6(112.32,159.15)
  BOTTOM w0.133: U7600.F11 121.51,179.25 121.55,179.25 v6(121.77,179.47) ; v6(112.32,159.15) 112.52,158.94 112.52,158.88 U7000.AA47
FBA_D12: length 34.3
  IN1 w0.095: v6(113.89,158.29) 113.89,158.64 113.57,158.96 113.57,159.28 114.83,160.54 115.48,160.54 117.29,162.36 117.29,162.67 118.87,164.25 118.87,164.78 122.41,168.32 123.3,168.32 124.08,169.1 124.08,169.83 124.85,170.6 124.85,180.22 123.24,181.83 122.56,181.83 122.14,182.24 122.14,182.71 121.85,183.01 121.29,183.01 v6(120.93,182.64)
  BOTTOM w0.133: v6(120.93,182.64) 121.16,182.87 121.16,182.9 U7600.A11 ; v6(113.89,158.29) U7000.Y46
FBA_D13: length 30.9
  IN1 w0.095: v6(121.69,182.63) 121.69,182.28 122.45,181.52 123.14,181.52 124.56,180.1 124.56,170.72 123.79,169.95 123.79,169.21 123.19,168.61 122.26,168.61 118.5,164.85 118.5,164.29 117,162.79 117,162.33 115.47,160.8 113.63,160.8 v6(113.5,160.92)
  BOTTOM w0.133: U7600.B11 121.45,182.39 121.46,182.39 v6(121.69,182.63) ; U7000.Y49 v6(113.5,160.92)
FBA_D14: length 37.3
  IN1 w0.095: v6(119.3,182.69) 119.9,183.29 121.97,183.29 122.55,182.71 122.89,182.71 125.13,180.47 125.13,170.48 124.37,169.71 124.37,168.98 123.42,168.04 122.58,168.04 119.16,164.61 119.16,164.13 117.47,162.45 117.47,162.12 114.32,158.96 114.32,157.36 113.88,156.92 v6(113.88,156.73)
  BOTTOM w0.133: v6(113.88,156.73) 113.51,157.1 U7000.Y45 ; v6(119.3,182.69) 119.51,182.89 119.55,182.89 U7600.A13
FBA_D15: length 33.5
  IN1 w0.095: v6(119.35,181.81) 119.35,181.81 119.85,182.3 120.5,182.3 120.57,182.23 121.07,182.23 122.06,181.24 123.02,181.24 124.28,179.98 124.28,170.84 123.51,170.07 123.51,169.33 123.07,168.89 122.14,168.89 118.13,164.88 118.13,164.38 117.05,163.31 115.97,163.31 114.58,161.92 113.95,161.92 v6(113.51,161.48)
  BOTTOM w0.133: v6(119.35,181.81) 119.54,182 119.54,182.08 U7600.B13 ; U7000.Y48 113.9,159.9 113.9,161.1 v6(113.51,161.48)
FBA_D16: length 24.6
  IN2 w0.146: v6(119.4,173.87) 118.97,173.45 118.05,173.45 116.87,172.26 116.87,170.65 114.1,167.88 112.37,167.88 107.36,162.88 107.36,162.01 106.76,161.41 106.76,160.01 106.3,159.55 106.3,157.93 v6(106.71,157.52)
  BOTTOM w0.133: v6(119.4,173.87) 119.6,174.08 119.6,174.14 U7600.M13 ; v6(106.71,157.52) 106.51,157.72 106.49,157.72 U7000.AJ46
FBA_D17: length 20.5
  IN2 w0.146: v6(119.3,170.7) 119.3,169.56 117.93,168.19 116.89,168.19 115.24,166.54 112.89,166.54 108.56,162.22 108.56,161.62 107.9,160.96 107.9,158.69 v6(108.31,158.28)
  BOTTOM w0.133: U7000.AG47 108.14,158.46 108.14,158.45 v6(108.31,158.28) ; v6(119.3,170.7) 119.3,170.7 U7600.U13
FBA_D18: length 23.6
  IN2 w0.146: v6(108.3,157.5) 108.3,157.62 108.72,158.04 108.72,160.36 108.81,160.45 108.81,161.85 113.07,166.11 115.42,166.11 117.05,167.73 118.19,167.73 119.74,169.29 119.74,171.84 119.34,172.24 v6(119.34,173.03)
  BOTTOM w0.133: U7000.AG46 v6(108.3,157.5) ; U7600.N13 119.63,173.37 119.63,173.32 v6(119.34,173.03)
FBA_D19: length 23.3
  IN2 w0.146: v6(107.53,156.67) 107.53,161.06 108.12,161.66 108.12,162.4 112.7,166.98 115.06,166.98 116.85,168.77 117.45,168.77 117.78,169.11 117.78,171.13 118.11,171.46 v6(119.25,171.46)
  BOTTOM w0.133: U7600.T13 119.47,171.34 119.38,171.34 v6(119.25,171.46) ; U7000.AG45 107.74,156.94 107.74,156.87 v6(107.53,156.67)
FBA_D20: length 26.9
  IN2 w0.089: 109.32,158.26 109.32,157.96 109.05,157.69 109.05,157.24 108.67,156.86 108.67,156.33 v6(109.07,155.93)
  IN2 w0.146: 109.32,158.26 109.32,158.92 109.91,159.5 109.91,160.22 109.57,160.56 109.57,161.04 113.53,165 115.88,165 117.51,166.63 118.64,166.63 120.85,168.83 120.85,169.33 121.3,169.78 121.3,171.25 121.29,171.26 121.29,171.62 121.3,171.63 121.72,172.05 v6(121.72,173.88)
  BOTTOM w0.133: v6(109.07,155.93) 108.7,156.3 U7000.AF44 ; v6(121.72,173.88) 121.52,173.68 121.52,173.66 U7600.N11
FBA_D21: length 24.1
  IN2 w0.089: v6(109.04,156.71) 109.28,156.95 109.28,157.48 109.96,158.16
  IN2 w0.146: 109.96,158.16 110.59,158.79 110.59,161.18 111.25,161.84 111.94,161.84 113.77,163.67 117.36,163.67 118.32,164.63 118.32,165 122.4,169.08 122.4,170.77 v6(121.73,171.44)
  BOTTOM w0.133: U7600.T11 121.52,171.26 121.55,171.26 v6(121.73,171.44) ; U7000.AF45 108.82,156.99 108.82,156.93 v6(109.04,156.71)
FBA_D22: length 21.1
  IN2 w0.146: v6(109.77,158.64) 110.15,159.03 110.15,160.55 109.97,160.73 109.97,160.98 111.13,162.14 111.48,162.14 113.46,164.12 117.19,164.12 117.88,164.81 117.88,165.2 121.74,169.06 v6(121.74,170.68)
  BOTTOM w0.133: v6(121.74,170.68) 121.74,170.68 U7600.U11 ; v6(109.77,158.64) 109.77,158.43 U7000.AD46
FBA_D23: length 27.4
  IN2 w0.146: v6(121.71,174.72) 122.2,174.23 122.2,173.65 122.38,173.47 122.82,173.47 123.13,173.17 123.13,169.16 118.89,164.93 118.89,164.58 117.54,163.24 114.05,163.24 112.27,161.46 111.3,161.46 110.95,161.1 110.95,158.59 v6(109.85,157.49)
  BOTTOM w0.133: v6(109.85,157.49) 110.06,157.28 110.12,157.28 U7000.AD45 ; v6(121.71,174.72) 121.53,174.53 121.53,174.47 U7600.M11
FBA_D24: length 29.4
  IN4 w0.095: v6(109.83,156.61) 110.27,157.06 110.27,157.21 110.54,157.47 110.54,158.34 111.06,158.85 111.06,162.74 112.24,163.92 118.05,163.92 123.86,169.72 123.86,172.3 125,173.44 126.13,173.44 v6(126.52,173.83)
  BOTTOM w0.133: U7000.AD44 109.99,156.61 v6(109.83,156.61) ; v6(126.52,173.83) 126.75,174.06 126.75,174.09 U7600.M4
FBA_D25: length 29.5
  IN4 w0.095: v6(126.54,173.09) 125.37,173.09 124.26,171.98 124.26,169.54 118.24,163.52 112.42,163.52 111.91,163.01 111.91,158.84 111.76,158.69 111.38,158.69 110.85,158.15 110.85,157.37 110.55,157.08 110.55,156.53 v6(109.92,155.89)
  BOTTOM w0.133: U7600.N4 126.55,173.09 v6(126.54,173.09) ; v6(109.92,155.89) U7000.AD43
FBA_D26: length 33.6
  IN4 w0.095: v6(109.91,155.1) 109.45,155.56 109.45,157.63 110.24,158.42 110.24,158.58 110.64,158.98 110.64,162.91 111.94,164.2 117.75,164.2 123.37,169.82 123.37,172.63 124.98,174.24 127.79,174.24 v6(128.14,173.89)
  BOTTOM w0.133: U7000.AD42 110.3,154.71 v6(109.91,155.1) ; U7600.M2 v6(128.14,173.89)
FBA_D27: length 30.9
  IN4 w0.095: v6(111.48,155.08) 111.36,155.08 110.83,155.61 110.83,156.96 111.14,157.27 111.14,157.69 111.33,157.88 111.91,157.88 112.24,158.21 112.24,158.54 112.9,159.19 112.9,162.19 113.82,163.12 118.42,163.12 124.66,169.35 124.66,171.8 125.57,172.71 127.77,172.71 v6(128.14,173.09)
  BOTTOM w0.133: U7000.AC42 v6(111.48,155.08) ; U7600.N2 v6(128.14,173.09)
FBA_D28: length 23.1
  IN4 w0.095: v6(126.06,169.69) 126.13,169.62 126.13,168.84 119.21,161.92 117.8,161.92 115.39,159.5 115.39,157.5 114.99,157.09 114.4,157.09 114.38,157.12 113.26,157.12 112.45,156.31 112.44,156.31 v6(112.17,156.03)
  BOTTOM w0.133: U7000.AA44 112.44,156.3 112.17,156.02 v6(112.17,156.03) ; v6(126.06,169.69) 126.24,169.87 126.53,169.87 U7600.U4
FBA_D29: length 26.8
  IN4 w0.095: v6(126.51,171.49) 126.13,171.87 125.61,171.87 125.06,171.33 125.06,169.18 118.59,162.72 117.44,162.72 115.57,160.85 115.07,160.85 112.68,158.46 112.68,158.11 111.68,157.12 111.38,157.12 111.12,156.85 111.12,155.95 111.42,155.64 111.68,155.64 v6(112.14,155.18)
  BOTTOM w0.133: U7000.AA43 112.38,155.18 v6(112.14,155.18) ; U7600.T4 v6(126.51,171.49)
FBA_D30: length 26.9
  IN4 w0.095: v6(113.15,155.11) 114.09,155.11 114.48,155.49 117.35,155.49 117.63,155.77 117.63,160.27 118.44,161.08 119.61,161.08 127.35,168.82 128.5,168.82 128.94,169.27 v6(128.94,170.69)
  BOTTOM w0.133: v6(128.94,170.69) U7600.U2 ; U7000.AA42 112.91,154.91 112.95,154.91 v6(113.15,155.11)
FBA_D31: length 28.5
  IN4 w0.095: v6(128.96,171.48) 128.56,171.08 128.56,170.54 127.7,169.68 126.64,169.68 126.42,169.46 126.42,168.52 119.37,161.48 117.93,161.48 115.9,159.45 115.9,156.86 115.11,156.08 114.48,156.08 113.93,155.52 112.96,155.52 112.78,155.34 112.78,154.8 v6(112.3,154.32)
  BOTTOM w0.133: U7600.T2 128.89,171.43 128.9,171.43 v6(128.96,171.48) ; v6(112.3,154.32) 112.3,153.5 U7000.AA40
FBA_D32: length 17.7
  IN1 w0.095: v6(108.04,169.84) 108.04,169.39 105.5,166.85 104.88,166.85 104.17,167.56 104.11,167.56 103.74,167.92 102.71,167.92 102.24,167.45 102.24,165.57 100.51,163.84 100.51,162.56 100.38,162.44 100.38,161.85 v6(100.68,161.56)
  BOTTOM w0.133: U7000.AT48 100.7,159.75 100.3,160.15 100.3,161.19 v6(100.68,161.56) ; U7601.A4 108.02,169.86 108.02,169.86 v6(108.04,169.84)
FBA_D33: length 23.5
  IN1 w0.095: v6(108.01,173.88) 107.57,173.44 107.06,173.44 106.77,173.15 106.77,168.93 105.96,168.12 104.38,168.12 104,168.5 102.36,168.5 100.98,167.11 100.98,165.2 99.84,164.07 99.84,161.36 100.3,160.9 v6(100.3,158.3)
  BOTTOM w0.133: U7000.AT46 100.8,158 100.8,158.2 100.7,158.3 v6(100.3,158.3) ; U7601.F4 v6(108.01,173.88)
FBA_D34: length 19.4
  IN1 w0.095: v6(108.03,173.06) 107.52,172.55 107.52,172.07 107.59,172 107.59,169.35 106.08,167.84 104.24,167.84 103.86,168.21 102.59,168.21 101.88,167.5 101.88,165.62 100.19,163.93 100.19,161.44 v6(100.7,160.92)
  BOTTOM w0.133: v6(100.7,160.92) U7000.AT49 ; v6(108.03,173.06) 108.03,173.06 U7601.E4
FBA_D35: length 17.9
  IN1 w0.095: v6(100.76,162.19) 101.02,162.45 101.02,163.93 103.27,166.19 105.24,166.19 108.51,169.46 108.51,170.18 v6(108.03,170.66)
  BOTTOM w0.133: v6(100.76,162.19) 100.36,162.19 100.01,161.85 100.01,159.98 100.34,159.65 100.34,159.33 100.7,158.97 U7000.AT47 ; U7601.B4 v6(108.03,170.66)
FBA_D36: length 20.3
  IN1 w0.095: v6(97.23,161.71) 96.88,162.06 96.88,165.94 101.42,170.48 102.83,170.48 104.32,171.97 104.85,171.97 105.18,172.3 105.18,172.63 v6(105.61,173.07)
  BOTTOM w0.133: U7601.E2 v6(105.61,173.07) ; U7000.AW47 97.93,159.08 97.93,159.61 97.92,159.61 97.67,159.87 97.67,161.27 v6(97.23,161.71)
FBA_D37: length 17.7
  IN1 w0.095: v6(105.54,170.68) 104.32,170.68 103.84,170.2 101.54,170.2 97.26,165.92 v6(97.26,162.3)
  BOTTOM w0.133: U7000.AW48 98.3,159.73 97.94,160.1 97.94,161.62 v6(97.26,162.3) ; v6(105.54,170.68) 105.77,170.9 105.84,170.9 U7601.B2
FBA_D38: length 20.7
  IN1 w0.095: v6(97.23,161.13) 96.59,161.77 96.59,166.06 101.3,170.77 101.74,170.77 104.3,173.32 104.3,173.32 104.52,173.54 104.54,173.57 105.31,173.57 v6(105.62,173.88)
  BOTTOM w0.133: U7000.BA47 97.07,159.07 97.07,159.59 97.28,159.81 97.28,161.08 v6(97.23,161.13) ; U7601.F2 v6(105.62,173.88)
FBA_D39: length 18.2
  IN1 w0.095: v6(97.87,158.31) 98.55,158.99 98.55,164.68 99.49,165.62 99.49,167.61 101.67,169.79 104.68,169.79 104.77,169.88 v6(105.53,169.88)
  BOTTOM w0.133: U7000.AW46 98.16,158.04 98.14,158.04 v6(97.87,158.31) ; U7601.A2 105.82,170.08 105.74,170.08 v6(105.53,169.88)
FBA_D40: length 22.7
  IN1 w0.095: v6(101.88,158.28) 101.44,158.28 101.4,158.32 101.3,158.42 101.3,158.6 101.49,158.79 101.67,158.79 101.78,158.68 102.17,158.68 102.36,158.86 102.36,159.5 103.31,160.45 103.31,162.53 104.72,163.94 106.08,163.94 111.14,169 111.14,169.53 111.26,169.66 111.79,169.66 111.86,169.74 111.86,169.89 111.66,170.09 111.26,170.09 111.05,170.31 111.05,170.86 111.13,170.93 111.34,170.93 111.4,170.86 112.62,170.86 v6(112.84,170.65)
  BOTTOM w0.133: U7601.A11 113.21,170.27 v6(112.84,170.65) ; U7000.AR46 v6(101.88,158.28)
FBA_D41: length 24.7
  IN1 w0.095: v6(114.4,170.66) 114.05,171.01 113.67,171.01 113.51,170.86 113.51,170.25 112.47,169.2 112.17,169.2 106.1,163.13 104.8,163.13 103.71,162.03 103.71,160.19 103.14,159.62 103.14,156.4 103.01,156.28 102,156.28 101.87,156.4 101.87,156.67 v6(102.7,157.5)
  BOTTOM w0.133: v6(102.7,157.5) U7000.AN45 ; U7601.A13 114.81,170.27 114.64,170.45 114.62,170.45 v6(114.4,170.66)
FBA_D42: length 21
  IN1 w0.095: v6(112.8,174.72) 112.8,174.41 112.65,174.26 112.34,174.26 110.13,172.05 110.13,169.32 105.68,164.87 104.19,164.87 103.7,164.38 103.3,164.38 103.04,164.12 103.04,163.72 102.33,163.01 102.33,161.44 101.78,160.89 v6(101.78,160.88)
  BOTTOM w0.133: U7601.F11 113.07,174.42 113.07,174.45 v6(112.8,174.72) ; v6(101.78,160.88) 101.5,160.6 U7000.AR49
FBA_D43: length 21.5
  IN1 w0.095: v6(112.75,171.48) 112.74,171.48 112.41,171.15 111.63,171.15 111.38,171.4 111.38,171.77 111.25,171.9 110.88,171.9 110.75,171.77 110.75,169.13 105.85,164.23 104.54,164.23 103.04,162.73 103.04,160.78 102.69,160.44 102.18,160.44 101.92,160.17 101.92,159.9 101.68,159.65 101.68,159.34 v6(101.92,159.1)
  BOTTOM w0.133: v6(101.92,159.1) 101.69,159.32 101.68,159.32 U7000.AR48 ; v6(112.75,171.48) 112.8,171.48 U7601.B11
FBA_D44: length 24.2
  IN1 w0.095: v6(112.81,173.88) 112.37,173.88 110.46,171.98 110.46,169.25 105.8,164.58 104.49,164.58 102.74,162.83 102.74,161.59 102.16,161.01 102.16,160.7 101.1,159.64 v6(101.1,156.7)
  BOTTOM w0.133: U7601.E11 113.21,173.48 v6(112.81,173.88) ; v6(101.1,156.7) U7000.AT45
FBA_D45: length 24.3
  IN1 w0.089: v6(101.9,155.9) 102.07,156.07 103.25,156.07 103.34,156.16 103.34,159.55
  IN1 w0.095: v6(114.42,171.46) 114.83,171.05 114.83,170.47 114.22,169.86 113.56,169.86 112.58,168.88 112.37,168.88 106.25,162.75 104.78,162.75 103.89,161.86 103.89,160.1 103.34,159.55
  BOTTOM w0.133: U7000.AR44 v6(101.9,155.9) ; v6(114.42,171.46) 114.42,171.46 U7601.B13
FBA_D46: length 30.2
  IN1 w0.089: 103.88,159.25 103.88,154.73 103.43,154.27 v6(102.73,154.27)
  IN1 w0.095: v6(114.45,174.64) 114.8,174.29 115.32,174.29 115.93,173.68 115.93,173.24 116.55,172.62 116.55,170.36 112.36,166.17 111.92,166.17 107.64,161.89 105.72,161.89 105.17,161.35 104.99,161.35 104.65,161.01 104.65,160.01 103.88,159.25
  BOTTOM w0.133: v6(102.73,154.27) U7000.AN41 ; U7601.F13 v6(114.45,174.64)
FBA_D47: length 28.8
  IN1 w0.089: 103.7,159.33 103.7,155.3 103.51,155.1 v6(102.7,155.1)
  IN1 w0.095: v6(114.44,173.84) 114.81,173.47 115.35,173.47 115.65,173.17 115.65,173.04 116.25,172.44 116.25,170.47 112.24,166.46 111.57,166.46 107.33,162.21 104.94,162.21 104.26,161.54 104.26,159.89 103.7,159.33
  BOTTOM w0.133: v6(114.44,173.84) 114.48,173.8 114.48,173.8 U7601.E13 ; v6(102.7,155.1) U7000.AN42
FBA_D48: length 36.7
  IN4 w0.095: v6(115.22,182.67) 116.32,182.67 116.56,182.43 116.56,181.78 117.08,181.26 117.08,172.58 116.81,172.31 116.81,170.19 115.65,169.03 115.65,167.63 115.04,167.03 114.05,167.03 110.14,163.12 110.14,159.55 109.39,158.8 109.39,158.02 109.12,157.75 109.12,157.32 108.67,156.87 108.67,153.1 v6(108.28,152.72)
  BOTTOM w0.133: U7000.AG40 107.9,153.1 v6(108.28,152.72) ; U7601.U13 v6(115.22,182.67)
FBA_D49: length 30.5
  IN4 w0.089: v6(107.52,155.12) 107.91,155.51 107.91,157.06 107.71,157.26 107.71,157.97
  IN4 w0.095: v6(114.42,180.26) 115.59,179.09 115.59,177.95 115.62,177.92 115.62,174.62 115.85,174.39 115.85,170.58 107.9,162.63 107.9,158.16 107.71,157.97
  BOTTOM w0.133: U7000.AG43 v6(107.52,155.12) ; U7601.N13 114.42,180.27 v6(114.42,180.26)
FBA_D50: length 34.9
  IN4 w0.089: 109.13,162.64 109.13,158.17 108.81,157.85 108.81,157.47 108.39,157.05 108.39,154.39 v6(107.5,153.5)
  IN4 w0.095: 109.13,162.64 113.8,167.31 114.87,167.31 115.29,167.73 115.29,169.08 116.47,170.25 116.47,172.36 116.8,172.7 116.8,180.8 116.51,181.09 115.99,181.09 v6(115.21,181.86)
  BOTTOM w0.133: v6(115.21,181.86) 115.21,181.87 U7601.T13 ; U7000.AG41 v6(107.5,153.5)
FBA_D51: length 29.5
  IN4 w0.089: 107.04,162.83 107.04,159.28 107.11,159.2 107.11,158.16 107.32,157.95 107.32,157.28 106.86,156.82 106.86,156.53 106.36,156.04 106.36,155.44 v6(106.71,155.1)
  IN4 w0.095: v6(112.81,179.47) 112.38,179.03 111.83,179.03 111.21,178.42 111.21,167.72 110.6,167.11 110.6,166.97 110.77,166.8 110.77,166.67 110.48,166.38 110.35,166.38 110.18,166.55 110.04,166.55 107.04,163.54 107.04,162.83
  BOTTOM w0.133: U7601.N11 v6(112.81,179.47) ; v6(106.71,155.1) U7000.AJ43
FBA_D52: length 32.5
  IN4 w0.089: v6(106.68,153.48) 107.12,153.92 107.12,156.78 107.5,157.17 107.5,161.89
  IN4 w0.095: v6(112.8,178.66) 112.8,178.4 112.65,178.25 112.13,178.25 112.01,178.13 112.01,177.96 112.13,177.84 112.9,177.84 113.03,177.71 113.03,177.54 112.44,176.95 112.44,175.95 112.32,175.83 111.61,175.83 111.5,175.73 111.5,166.89 110.32,165.71 110.19,165.71 109.98,165.92 109.84,165.92 109.55,165.63 109.55,165.49 109.76,165.28 109.76,165.15 109.52,164.91 109.39,164.91 109.16,165.13 109.03,165.13 108.74,164.84 108.74,164.7 108.96,164.48 108.96,164.35 107.5,162.89 107.5,161.89
  BOTTOM w0.133: U7601.M11 113.21,178.84 113.04,178.66 v6(112.8,178.66) ; U7000.AJ40 v6(106.68,153.48)
FBA_D53: length 36.4
  IN4 w0.089: 107.05,157.31 106.63,156.89 106.63,156.55 106.07,156 106.07,154 106.27,153.8 106.27,153.37 106.05,153.15 104.93,153.15 104.61,153.48 v6(104.4,153.48)
  IN4 w0.095: v6(114.42,179.46) 113.99,179.9 111.95,179.9 110.93,178.87 110.93,168.01 106.52,163.6 106.52,159.7 106.33,159.5 106.33,158.23 106.6,157.95 106.81,157.95 107.09,157.67 107.09,157.34 107.05,157.31
  BOTTOM w0.133: U7601.M13 v6(114.42,179.46) ; U7000.AK40 105.26,153.1 105.23,153.13 104.95,153.13 104.61,153.48 v6(104.4,153.48)
FBA_D54: length 33.7
  IN4 w0.095: v6(113.59,182.68) 111.68,182.68 109.93,180.94 109.93,179.74 109.64,179.45 109.64,169.17 104.95,164.48 104.95,162.78 104.66,162.48 104.66,159.72 104.7,159.68 104.7,155.5 v6(105.09,155.11)
  BOTTOM w0.133: U7000.AK42 v6(105.09,155.11) ; U7601.U11 113.59,182.69 v6(113.59,182.68)
FBA_D55: length 34.1
  IN4 w0.095: v6(113.6,181.91) 113.28,181.91 113.25,181.88 111.51,181.88 110.72,181.09 110.72,180.13 109.93,179.33 109.93,168.62 105.51,164.21 105.51,153.96 v6(105.11,153.56)
  BOTTOM w0.133: U7000.AK41 105.35,153.75 105.3,153.75 v6(105.11,153.56) ; v6(113.6,181.91) 113.35,182.16 113.32,182.16 U7601.T11
FBA_D56: length 29
  IN2 w0.089: v6(105.14,157.52) 105.14,157.53 105.74,158.13 105.74,159.81 105.79,159.86
  IN2 w0.146: 105.79,159.86 106.1,160.16 106.1,161.86 106.37,162.14 106.37,163.29 110.41,167.33 110.41,178.87 109.31,179.98 109.31,181.15 108.88,181.57 108.31,181.57 v6(108,181.88)
  BOTTOM w0.133: v6(105.14,157.52) 105.3,157.36 105.3,157.3 U7000.AK45 ; v6(108,181.88) 108,181.88 U7601.T4
FBA_D57: length 28.3
  IN2 w0.089: v6(105.11,155.89) 104.73,156.27 104.73,157.7 104.99,157.96 105.22,157.96 105.54,158.28 105.54,160.14
  IN2 w0.146: 105.54,160.14 105.79,160.39 105.79,161.99 105.93,162.13 105.93,163.47 109.8,167.34 109.8,178.46 v6(108.8,179.47)
  BOTTOM w0.133: U7601.N4 107.62,179.87 108.03,179.47 v6(108.8,179.47) ; U7000.AK43 v6(105.11,155.89)
FBA_D58: length 22.9
  IN2 w0.146: v6(105.04,160.87) 104.31,161.59 104.31,164.36 106.74,166.79 106.74,179.31 106.38,179.67 v6(106.38,180.24)
  BOTTOM w0.133: U7000.AK48 105.5,159.79 105.04,160.26 v6(105.04,160.87) ; U7601.N2 v6(106.38,180.24)
FBA_D59: length 21.4
  IN2 w0.146: v6(105.06,161.81) 105.49,162.24 105.49,163.75 109.32,167.58 109.32,177.36 v6(108,178.68)
  BOTTOM w0.133: U7000.AK49 105.5,161.36 v6(105.06,161.81) ; v6(108,178.68) 108.01,178.68 U7601.M4
FBA_D60: length 26.4
  IN2 w0.146: v6(104.27,157.53) 103.84,157.96 103.84,161.05 103.43,161.45 103.43,164.76 103.94,165.26 103.94,170.17 104.5,170.73 104.72,170.73 105.21,171.21 105.21,174.39 105.36,174.54 105.7,174.54 105.84,174.68 105.84,175.05 105.7,175.19 105.36,175.19 105.21,175.34 105.21,175.7 105.36,175.85 105.7,175.85 105.84,175.99 105.84,176.35 105.7,176.5 105.36,176.5 105.21,176.65 105.21,177.01 105.36,177.15 105.7,177.15 105.84,177.3 105.84,177.66 105.7,177.81 105.36,177.81 105.21,177.95 105.21,178.27 v6(105.65,178.7)
  BOTTOM w0.133: U7601.M2 v6(105.65,178.7) ; U7000.AM45 104.04,157.24 104.04,157.3 v6(104.27,157.53)
FBA_D61: length 28.7
  IN2 w0.146: v6(104.3,156.7) 103.51,157.5 103.51,160.97 102.97,161.51 102.97,164.43 102.46,164.94 102.46,167.7 103.18,168.42 103.18,168.83 103.18,168.83 103.18,175.03 104.17,176.01 104.17,181.03 104.69,181.55 105.29,181.55 v6(105.62,181.88)
  BOTTOM w0.133: U7000.AM44 103.9,156.3 v6(104.3,156.7) ; U7601.T2 v6(105.62,181.88)
FBA_D62: length 31.2
  IN2 w0.089: v6(105.1,156.71) 105.51,157.12 105.51,157.6 105.99,158.08 105.99,158.43
  IN2 w0.146: v6(108,182.68) 108.53,182.16 109.17,182.16 109.81,181.52 109.81,180.16 111,178.97 111,167.3 106.81,163.11 106.81,162.02 106.43,161.64 106.43,160.09 105.99,159.65 105.99,158.43
  BOTTOM w0.133: U7000.AK44 105.35,156.45 105.35,156.46 105.11,156.71 v6(105.1,156.71) ; U7601.U4 v6(108,182.68)
FBA_D63: length 30.7
  IN2 w0.146: v6(104.29,155.89) 103.15,157.02 103.15,160.97 102.53,161.59 102.53,162.8 102.02,163.3 102.02,167.15 102.02,167.88 102.74,168.6 102.74,176.95 103.53,177.74 103.53,181.31 104.33,182.11 105.05,182.11 v6(105.61,182.67)
  BOTTOM w0.133: U7601.U2 106.01,183.07 v6(105.61,182.67) ; U7000.AM43 v6(104.29,155.89)
FBA_DEBUG0: length 5.9
  TOP w0.089: 114.48,162.83 114.48,162.4 v1(114.53,162.35) 114.31,162.13 v6(113.54,162.13)
  TOP w0.102: R7108.1 114.48,162.83
  BOTTOM w0.102: v6(113.54,162.13) 113.06,161.65 113.06,159.15 U7000.Y47
FBA_DEBUG1: length 6.3
  BOTTOM w0.102: R7109.1 101.4,163.9 v1(100.94,163.44) 101.16,163.22 101.16,159.04 U7000.AR47
FBA_DQM0: length 35.7
  IN1 w0.095: v6(115.47,153.51) 115.47,154.43 115.87,154.83 115.87,155.67 115.94,155.74 115.94,156.05 115.94,156.05 115.94,158.98 118.56,161.6 118.95,161.6 123.18,165.83 123.7,165.83 125.75,167.88 126.45,167.88 126.76,168.19 127.27,168.19 128.02,168.93 128.6,168.93 129.36,169.69 129.36,178.37 129.59,178.6 129.59,179.75 129.04,180.3 v6(128.9,180.3)
  BOTTOM w0.133: U7000.U40 115.67,153.33 115.64,153.33 v6(115.47,153.51) ; U7600.D2 v6(128.9,180.3)
FBA_DQM1: length 33.4
  IN1 w0.095: v6(120.13,181.07) 119.76,180.7 119.76,180.12 120.04,179.84 120.27,179.84 120.52,179.59 120.52,179.16 120.62,179.06 121.06,179.06 121.7,178.42 121.7,177.98 121.79,177.9 121.79,175.64 121.32,175.17 121.32,174.57 121.02,174.27 120.79,174.27 120.55,174.03 120.55,171.74 120.04,171.23 120.04,169.53 117.41,166.89 116.88,166.89 113.97,163.98 113.15,163.98 110.74,161.58 110.74,158.17 111.03,157.88 111.66,157.88 111.89,157.65 111.89,157.09 v6(111.5,156.7)
  BOTTOM w0.133: U7000.AC45 v6(111.5,156.7) ; U7600.D13 119.73,180.67 v6(120.13,181.07)
FBA_DQM2: length 25.1
  IN2 w0.146: v6(107.49,155.95) 107.06,156.38 107.06,157.27 107.16,157.37 107.16,161.2 107.8,161.84 107.8,162.7 112.52,167.42 114.85,167.42 116.84,169.41 116.84,169.97 117.33,170.45 117.33,171.8 117.96,172.43 v6(118.36,172.43)
  BOTTOM w0.133: v6(107.49,155.95) 107.69,156.14 107.74,156.14 U7000.AG44 ; v6(118.36,172.43) 118.52,172.28 119.34,172.28 U7600.P13
FBA_DQM3: length 30.7
  IN4 w0.095: v6(128.92,172.28) 129.33,171.87 129.33,169.18 128.51,168.35 128.12,168.35 125.78,166.02 125.26,166.02 119.92,160.68 118.83,160.68 118.29,160.14 118.29,154.04 118.16,153.92 113.43,153.92 v6(113.07,154.27)
  BOTTOM w0.133: U7600.P2 v6(128.92,172.28) ; U7000.AA41 v6(113.07,154.27)
FBA_DQM4: length 22
  IN1 w0.095: v6(99.5,157.5) 99.88,157.88 99.88,160.79 99.56,161.11 99.56,164.19 100.64,165.27 100.64,167.18 102.24,168.79 104.13,168.79 104.49,168.42 105.86,168.42 106.46,169.03 106.46,171.45 v6(105.63,172.28)
  BOTTOM w0.133: U7000.AV45 99.1,157.1 v6(99.5,157.5) ; U7601.D2 v6(105.63,172.28)
FBA_DQM5: length 23.2
  IN1 w0.095: v6(114.4,173.09) 113.97,172.66 113.31,172.66 113.22,172.56 113.22,170.44 112.26,169.49 112.03,169.49 106.13,163.59 104.83,163.59 103.52,162.27 103.52,160.38 102.66,159.52 102.66,158.89 102.29,158.51 102.29,157.89 v6(101.9,157.5)
  BOTTOM w0.133: U7000.AR45 101.5,157.1 v6(101.9,157.5) ; U7601.D13 114.81,172.68 v6(114.4,173.09)
FBA_DQM6: length 32.5
  IN4 w0.089: 108.73,161.59 108.73,158.18 108.43,157.88 108.15,157.88 107.93,157.66 107.93,157.3 108.15,157.07 108.15,154.95 v6(107.52,154.32)
  IN4 w0.095: 108.73,161.59 108.73,162.97 116.18,170.42 116.18,173.65 116.51,173.98 116.51,177.49 115.88,178.12 115.88,179.28 115.21,179.96 v6(115.21,181.06)
  BOTTOM w0.133: U7601.P13 v6(115.21,181.06) ; v6(107.52,154.32) 107.9,154.7 U7000.AG42
FBA_DQM7: length 26.8
  IN2 w0.146: v6(105.65,180.31) 105.65,179.49 106.3,178.84 106.3,168.83 106.15,168.69 105.28,168.69 105.16,168.56 105.16,168.16 105.28,168.03 106.15,168.03 106.3,167.89 106.3,166.97 103.87,164.54 103.87,161.6 104.52,160.95 104.52,160.52 104.68,160.36 104.68,158.68 v6(104.29,158.29)
  BOTTOM w0.133: U7601.P2 v6(105.65,180.31) ; v6(104.29,158.29) U7000.AM46
FBA_DQS_WP0: length 33.7
  IN1 w0.095: v6(116.32,157.52) 116.27,157.58 116.27,159.04 118.64,161.42 119.47,161.42 123.38,165.32 123.96,165.32 126.01,167.38 127.22,167.38 128.11,168.26 128.73,168.26 130.38,169.92 130.38,178.76 130.48,178.85 130.48,180.5 130.14,180.84 129.16,180.84 v6(128.89,181.11)
  BOTTOM w0.133: v6(116.32,157.52) 115.9,157.11 U7000.U45 ; U7600.C2 v6(128.89,181.11)
FBA_DQS_WP1: length 36
  IN1 w0.095: v6(113.17,155.9) 113.5,156.23 113.5,158.62 113.25,158.87 113.25,160.41 113.09,160.57 113.09,162.22 113.38,162.51 114.46,162.51 116.29,164.34 117.38,164.34 117.63,164.59 117.63,165.19 121.83,169.39 122.8,169.39 123.01,169.6 123.01,170.27 123.77,171.04 123.77,179.77 122.81,180.74 121.85,180.74 121.17,181.42 120.52,181.42 v6(120.14,181.8)
  BOTTOM w0.133: v6(113.17,155.9) 113.26,155.81 113.26,155.74 U7000.Y43 ; v6(120.14,181.8) 119.93,181.6 119.86,181.6 U7600.C13
FBA_DQS_WP2: length 25.5
  IN2 w0.089: v6(109.05,155.09) 108.41,155.73 108.41,156.92 108.77,157.28 108.77,157.71 109.03,157.97 109.03,158.26
  IN2 w0.146: 109.03,158.26 109.06,158.28 109.06,161.31 113.3,165.55 115.65,165.55 117.28,167.18 118.42,167.18 120.29,169.06 120.29,172.07 v6(120.11,172.25)
  BOTTOM w0.133: v6(109.05,155.09) 108.9,154.94 108.9,154.9 U7000.AF42 ; v6(120.11,172.25) U7600.R13
FBA_DQS_WP3: length 27.1
  IN4 w0.095: v6(111.57,156.03) 111.57,156.19 111.89,156.51 111.89,156.85 112.92,157.88 114.63,157.88 114.94,158.18 114.94,159.66 117.59,162.32 118.9,162.32 125.56,168.97 125.56,169.9 125.83,170.17 126.06,170.17 126.12,170.23 126.12,170.47 126.05,170.54 125.69,170.54 125.63,170.6 125.63,170.83 125.88,171.09 127.74,171.09 v6(128.15,171.49)
  BOTTOM w0.133: U7000.AC44 111.3,156.3 v6(111.57,156.03) ; U7600.R2 v6(128.15,171.49)
FBA_DQS_WP4: length 19.3
  IN1 w0.095: v6(105.63,171.49) 105.96,171.16 105.96,169.29 105.6,168.93 104.69,168.93 104.33,169.29 102.03,169.29 100.13,167.39 100.13,165.47 99.05,164.39 99.05,159.53 v6(99.49,159.09)
  BOTTOM w0.133: U7000.AV47 99.49,159.09 v6(99.49,159.09) ; U7601.C2 v6(105.63,171.49)
FBA_DQS_WP5: length 26.8
  IN1 w0.089: 103.52,159.43 103.52,156.04 103.16,155.68 v6(102.56,155.68)
  IN1 w0.095: v6(114.4,172.28) 114.72,172.59 115.38,172.59 115.75,172.23 115.75,170.68 112.2,167.13 111.49,167.13 106.83,162.48 104.88,162.48 104.08,161.67 104.08,159.98 103.52,159.43
  BOTTOM w0.133: U7601.C13 114.81,171.87 v6(114.4,172.28) ; U7000.AN43 102.92,155.68 v6(102.56,155.68)
FBA_DQS_WP6: length 35.4
  IN4 w0.095: v6(114.42,181.01) 114.04,181.39 113.48,181.39 113.1,181.02 111.48,181.02 111.23,180.77 111.23,179.89 110.43,179.08 110.43,168.42 106.02,164.01 106.02,157.96 106.33,157.64 106.33,156.51 105.79,155.97 105.79,153.63 v6(105.89,153.53)
  BOTTOM w0.133: U7000.AJ42 105.89,154.29 v6(105.89,153.53) ; U7601.R13 114.61,181.27 114.61,181.19 v6(114.42,181.01)
