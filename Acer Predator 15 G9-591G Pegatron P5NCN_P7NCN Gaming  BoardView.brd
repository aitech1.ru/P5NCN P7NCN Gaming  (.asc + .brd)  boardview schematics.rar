# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_PWRBTN#: length 306.6
  TOP w0.102: v2(117.98,44.09) 117.98,40.76 115.62,38.4 115.62,37.2 116.71,36.12 v2(116.71,35.59) 116.71,35.33 117.15,34.89 118.09,34.89 119.35,33.63 119.35,32.08 120.43,31.01 120.95,31.01 121.52,30.44 U3001.87 ; v2(176.8,57.5) 177.32,58.02 177.32,58.73 177.78,59.2 179.58,59.2 179.76,59.38 179.76,59.83 180.56,60.63 181.01,60.63 181.5,61.12 v1(181.5,62.78) 181.5,64.42 C2400.1 v2(181.92,65.41) R2447.2
  IN1 w0.102: v2(181.92,65.41) 181.51,65 181.51,61.58 181.58,61.51 181.58,60.45 180.96,59.83 180.96,43.35 180.55,42.94 180.22,42.94 179.86,42.59 178.18,42.59 177.5,41.9 172.16,41.9 171.43,41.17 160.5,41.17 160.16,41.52 158.8,41.52 157.26,39.98 146.45,39.98 145.62,40.81 137.01,40.81 134.58,43.24 133.69,43.24 133.39,43.54 118.53,43.54 v2(117.98,44.09)
  IN3 w0.102: v2(42.75,37.18) 38.79,37.18 37.16,38.8 37.16,44.13 34.6,46.7 34.6,53.59 32.92,55.27 32.92,55.96 28.78,60.11 28.78,61.18 28.57,61.39 28.57,63.17 29.14,63.74 29.14,66.67 27.23,68.58 27.23,80.22 20.61,86.83 12.7,86.83 11.76,87.77 v2(10.97,87.77)
  IN4 w0.102: v2(116.71,35.59) 116.29,35.18 107.03,35.18 105.87,36.34 43.59,36.34 v2(42.75,37.18)
  BOTTOM w0.089: v2(176.8,57.5) 177.08,57.22 U2000.AT13
  BOTTOM w0.102: R4415.2 8.03,119.26 8.37,118.92 8.37,117.22 6.73,115.59 6.15,115.59 5.99,115.44 5.99,110.71 9.14,107.56 11.43,107.56 14.17,104.82 14.17,91.45 12.13,89.41 12.13,88.61 11.3,87.77 v2(10.97,87.77)
PM_RSMRST#: length 307.3
  TOP w0.102: v2(183.77,67.85) 183.77,68.52 184.49,69.23 184.51,69.23 R2488.2 ; v2(131.98,37.35) 131.55,37.78 131.12,37.78 130.99,37.65 130.09,37.65 R3066.2 129.32,37.23 129.25,37.3 127.83,37.3 127.69,37.15 U3001.112 ; v1(133.4,44.75) 133.81,44.34 v2(133.81,44.09)
  IN1 w0.102: v2(183.77,67.85) 183.15,67.85 180.87,65.58 180.87,65.24 181.31,64.81 181.31,61.49 181.37,61.42 181.37,60.53 180.76,59.92 180.76,44.01 180.52,43.77 179.9,43.77 179.54,43.41 178.72,43.41 177.43,42.12 172.1,42.12 171.35,41.37 160.59,41.37 160.24,41.72 158.41,41.72 158.04,41.34 155.64,41.34 155.11,41.88 153.88,41.88 152.39,40.38 147.84,40.38 146.3,41.93 145.54,41.93 142.09,45.37 139.8,45.37 138.03,43.6 134.29,43.6 v2(133.81,44.09)
  IN2 w0.102: v2(5.92,86.3) 6.68,85.54 6.68,81.02 5.23,79.57 5.23,67.82 9.46,63.59 10.19,63.59 10.52,63.26 11.82,63.26 12.58,62.5 19.12,62.5 19.63,61.99 21.87,61.99 24.1,59.76 24.1,57.87 27.84,54.14 27.84,50.01 38.18,39.67 38.18,38.88 40.95,36.11 48.47,36.11 49.35,36.99 97.31,36.99 98.06,36.25 106.74,36.25 107.27,35.72 109.97,35.72 110.74,36.49 117.15,36.49 117.15,36.49 122.92,36.49 124.54,38.11 131.22,38.11 v2(131.98,37.35)
  BOTTOM w0.102: v2(131.98,37.35) 131.98,38.55 133.35,39.93 133.35,43.63 v2(133.81,44.09) ; R4406.2 7.95,117.12 6.62,115.79 6.06,115.79 5.79,115.52 5.79,110.63 9.06,107.36 11.34,107.36 13.67,105.03 13.67,100.68 13.23,100.25 9.47,100.25 9.19,100.53 5.96,100.53 5.09,99.65 5.09,94.88 6.81,93.16 6.81,89.46 6.34,88.99 6.05,88.99 5.03,87.97 5.03,86.96 5.69,86.3 v2(5.92,86.3)
PM_SUSB#: length 270.8
  TOP w0.102: v2(229.02,49.79) 229.62,49.2 230.45,49.2 230.94,48.71 230.94,48.28 230.51,47.85 R1153.2 ; U3001.18 118.32,46.29 118.11,46.5 118.11,47.28 R3062.2 118.84,47.17 v2(118.84,46.55) ; R2438.2 175.59,68.24 175.59,68.82 v2(175.18,69.23) ; R3074.1 111.79,22.34 v1(100,22.34) 90.29,22.34 86.11,26.53 86.11,34.63 88.27,36.78 89.29,36.78 92.33,39.82 92.33,41.4 91.35,42.38 v2(91.35,47.6) ; v2(116.14,49.37) 116.14,49.82 R0749.1
  IN1 w0.102: v2(187.3,71.87) 187,71.87 186.57,72.29 183.88,72.29 183.29,71.7 180.95,71.7 179.66,70.4 177.84,70.4 177.12,69.69 175.64,69.69 v2(175.18,69.23) ; v2(190.59,64.91) 191,65.32 192.03,65.32 192.28,65.07 192.28,62.28 194.67,59.89 194.67,52.61 196.47,50.81 196.47,45.87 197.69,44.65 197.69,42.07 201.05,38.71 201.05,36.84 202.62,35.27 202.62,34.88 203.55,33.95 204.6,33.95 206.73,31.82 208.59,31.82 v2(209.96,30.45)
  IN2 w0.102: v2(91.35,47.6) 92.45,46.49 100.89,46.49 102.13,45.26 112.83,45.26 113.63,46.05 115.05,46.05 116.21,47.21 117.9,47.21 118.56,46.55 v2(118.84,46.55) 119.27,46.12 122.8,46.12 124.02,47.34 132.97,47.34 133.58,47.95 140.05,47.95 143.32,51.22 143.32,53.58 144.39,54.65 145.43,54.65 146.98,56.2 148.74,56.2 149.66,57.12 149.66,57.49 152.63,60.46 154.71,60.46 157.33,63.09 157.33,63.91 158.82,65.4 167.94,65.4 169.92,67.37 173.33,67.37 v2(175.18,69.23) ; v2(229.02,49.79) 228.41,49.18 227.39,49.18 226.6,48.39 223.6,48.39 220.7,45.49 220.7,38.92 219.94,38.16 219.94,37.11 218.05,35.21 216.12,35.21 215.21,34.31 215.21,33.16 215.54,32.83 215.54,31.74 214.9,31.1 213.28,31.1 212.63,30.45 v2(209.96,30.45)
  BOTTOM w0.102: v2(190.59,64.91) 191.19,65.5 U2403.2 191.19,67.32 190.93,67.58 190.3,67.58 189.74,67.02 189.74,66.77 189.61,66.64 R2491.1 188.98,66.64 188.86,66.76 188.86,67.79 189.02,67.95 189.02,68.8 188.05,69.78 188.05,71.42 187.6,71.87 v2(187.3,71.87) ; v2(116.14,49.37) 116.55,49.79 117.72,49.79 118,49.5 118,47.86 118.84,47.02 v2(118.84,46.55)
PM_SUSC#: length 260.3
  TOP w0.102: R3075.1 109.8,22.78 v1(91.87,22.78) 90.14,22.78 86.31,26.61 86.31,34.25 v2(87.3,35.25) ; U3001.21 117.12,47.27 R3063.2 116.25,48.14 116.25,48.68 115.96,48.97 114.66,48.97 113.63,50 109.38,50 107.9,48.53 107.55,48.53 99.31,40.29 99.31,36.08 v2(100.16,35.23)
  IN1 w0.102: v2(87.3,35.25) 100.14,35.25 100.13,35.23 v2(100.16,35.23) 100.16,35.03 101.23,33.95 105.38,33.95 109.64,29.69 114.68,29.69 116.75,27.61 134.28,27.61 135.07,28.4 157,28.4 157.77,27.63 175.99,27.63 178.85,24.77 192.75,24.77 193.35,25.36 193.35,26.51 v2(191.67,28.19) 191.67,28.59 192.35,29.28 192.35,40.84 194.06,42.55 194.06,43.52 195.15,44.62 195.15,46.65 195.05,46.75 195.05,48.89 195.17,49.02 195.17,50.97 193.8,52.34 193.8,55.79 192.56,57.04 192.46,57.04 v2(191.95,57.55)
  IN2 w0.102: v2(191.67,28.19) 192.6,27.26 195.73,27.26 196.61,28.15 198.34,28.15 198.81,28.61 198.81,29.43 199.06,29.68 199.82,29.68 200.2,29.3 201.47,29.3 202.26,30.09 203.28,30.09 204.95,31.77 206.19,31.77 207.67,33.24 209.07,33.24 209.95,34.13 211.15,34.13 212.24,35.23 212.24,39.62 212.85,40.23 214.92,40.23 215.26,40.56 215.26,42.8 215.92,43.47 216.37,43.47 217.3,44.4 217.3,47.25 v2(218.21,48.16)
  BOTTOM w0.102: v2(191.95,57.55) 191.82,57.67 R2439.2 ; v2(218.21,48.16) 218.42,47.96 219.99,47.96 220.6,48.57 R3164.1
PM_SYNC: length 254.5
  TOP w0.102: v1(170.08,70.58) 170.44,70.94 v2(170.44,71.34)
  IN1 w0.102: v2(170.44,71.34) 170.01,70.91 169.66,70.91 168.42,69.66 157.42,69.66 157.14,69.39 155.34,69.39 155.17,69.55 153.64,69.55 151.73,67.64 148.85,67.64 146.37,65.16 143.96,65.16 143.25,64.45 142.87,64.45 142.63,64.69 141.04,64.69 140.82,64.48 140.04,64.48 139.53,64.99 138.52,64.99 136.23,67.29 130.29,67.29 124.06,61.05 121.71,61.05 121.32,60.67 111.49,60.67 111.23,60.92 108.87,60.92 107.2,59.26 107.2,59.14 106.52,58.46 98.59,58.46 98.16,58.03 55.63,58.03 48.13,65.54 34.58,65.54 33.67,66.45 33.67,67.52 28.51,72.67 28.51,76.91 20.12,85.31 18.9,85.31 17.66,86.55 15.74,86.55 13.43,88.85 11.05,88.85 9.11,90.8 9.11,97.5 9.4,97.79 9.4,101.3 9.11,101.59 9.11,125.1 11.07,127.07 11.87,127.07 18.92,134.12 18.92,136.98 20.9,138.95 20.95,138.95 21.47,139.47 21.47,147.91 22.41,148.85 23.46,148.85 v6(23.86,149.25)
  BOTTOM w0.102: v6(23.86,149.25) 24.19,148.93 U0300.BM34 ; v2(170.44,71.34) 170.49,71.29 R2228.2
PM_SYNC_R: length 13.2
  BOTTOM w0.089: U2000.AJ4 173.6,61.59 173.6,62 173.66,62.05 173.66,63.62 172.82,64.46 172.71,64.46 172.71,64.46 172.26,64.46 172.06,64.66 172.06,65.02 171.78,65.3 171.27,65.3 170.8,65.77 170.8,66.63
  BOTTOM w0.102: 170.8,66.63 170.8,68.84 170.73,68.91 170.73,69.57 R2228.1 170.02,70.28 170.02,71.51 v1(170.61,72.1)
PROC_AUDIO_CLK: length 229.3
  IN2 w0.114: v6(58.64,144.76) 58.64,144.86 58.09,145.41 58.09,146.27 57.26,147.11 57.26,149.6 61.25,153.59 70.58,153.59 71.29,152.88 72.4,152.88 78.66,146.62 78.66,122.65 82.05,119.27 82.05,107.02 103.19,85.89 103.19,77.63 108.44,72.38 108.44,67.72 108.82,67.34 108.82,63.75 112.65,59.92 120.4,59.92 120.88,59.44 126.89,59.44 127.54,58.79 130.56,58.79 132.41,60.65 135.39,60.65 136.16,61.41 136.16,63.4 136.37,63.61 136.37,64.97 136.75,65.36 136.75,66.29 138.75,68.29 138.75,69.79 140.94,71.98 149.58,71.98 150.26,72.65 153.37,72.65 156.22,75.51 158.49,75.51 160.96,77.97 167.01,77.97 167.84,78.81 167.84,79.37 168.38,79.91 169.26,79.91 170.32,80.98 175.37,80.98 175.9,80.45 176.37,80.45 v2(176.78,80.86)
  BOTTOM w0.114: v6(58.64,144.76) 58.64,144.69 U0300.G27 ; R2311.1 174.23,67.78 174.23,71.59 173.74,72.07 173.14,72.07 172.56,72.66 172.06,72.66 171.22,73.49 171.22,75.8 175.78,80.36 176.28,80.36 v2(176.78,80.86) 177.11,81.19 v1(177.11,81.51)
PROC_AUDIO_SDI: length 231
  TOP w0.114: v6(58.64,143.19) 58.37,143.19 v1(58.01,142.82)
  IN2 w0.114: v6(58.64,143.19) 58.12,143.71 58.12,144.82 56.56,146.38 56.56,147.02 56.86,147.33 56.86,149.72 61.19,154.05 71.75,154.05 79.05,146.76 79.05,122.81 82.42,119.44 82.42,107.18 103.57,86.02 103.57,77.76 109.19,72.15 109.19,63.9 112.81,60.28 120.56,60.28 121.03,59.81 127.19,59.81 127.71,59.29 130.54,59.29 132.26,61.01 135.24,61.01 135.79,61.57 135.79,63.56 136,63.76 136,65.13 136.37,65.5 136.37,66.43 138.35,68.41 138.35,69.94 139.96,71.55 139.98,71.55 140.78,72.35 149.35,72.35 150.09,73.09 153.28,73.09 156.13,75.93 158.39,75.93 160.81,78.35 166.83,78.35 167.41,78.94 167.41,79.62 168.07,80.28 169.1,80.28 170.24,81.41 175.63,81.41 v2(176.17,80.87)
  BOTTOM w0.114: v2(176.17,80.87) 175.77,80.87 170.86,75.95 170.86,73.34 171.9,72.29 172.41,72.29 172.99,71.7 173.59,71.7 173.86,71.44 173.86,67.8 R2307.1 ; U0300.G25 58.31,142.86 v6(58.64,143.19)
PROC_AUDIO_SDO: length 201.3
  TOP w0.114: v2(90.86,110.76) 90.45,110.35 83.42,110.35 80.22,113.55 80.22,116.18 77.23,119.17 72.92,119.17 71.81,120.27 70.01,120.27 67.38,122.9 63.41,122.9 58.73,127.59 58.73,133.09 58.24,133.57 58.24,134.31 57.54,135.01 57.54,143.85 R0302.2 ; v2(161.14,72.54) 162.65,74.06 v1(164.36,74.06) 164.65,74.35 172.01,74.35 172.83,75.17 v2(172.83,76.65)
  IN4 w0.076: v2(90.86,110.76) 92.3,109.32 94.18,109.32 94.79,108.7 94.79,105.21 108.01,91.99 108.01,85 109.56,83.44 112.07,83.44 113.85,81.67 113.85,79 116.16,76.69 118.59,76.69 119.2,77.3 120.55,77.3 124.87,72.99 124.87,63.82 126.27,62.41 132.34,62.41 133.63,63.7 134.34,63.7 135.2,64.57 137.89,64.57 138.77,63.69 140.92,63.69 141.4,63.21 145.5,63.21 145.77,63.49 145.77,64.41 145.03,65.15 145.03,65.74 145.43,66.14 146.02,66.14 147.51,67.63 148.99,67.63 150.62,69.26 152.04,69.26 155.27,72.48 161.08,72.48 v2(161.14,72.54)
  BOTTOM w0.089: 175.13,66.54 175.13,65.23 175.69,64.67 175.69,62.53 U2000.AN2
  BOTTOM w0.114: 175.13,66.54 174.96,66.72 174.96,67.76 174.59,68.12 174.59,71.74 174.39,71.94 173.89,72.44 173.3,72.44 172.71,73.02 172.21,73.02 171.59,73.64 171.59,75.41 v2(172.83,76.65)
PROCHOT#: length 394.6
  IN1 w0.076: v2(16.13,150.26) 15.52,149.65 15.52,147.92 12.91,145.31 11.08,145.31 10.82,145.05 9.29,145.05 ; 9.29,145.05 9.29,143.42 6.91,141.04 v2(6.91,140.43) ; 9.29,145.05 9.07,145.28 9.07,146.14 8.26,146.96 8.26,152.02 v2(7.84,152.44)
  IN2 w0.114: v2(113.16,32.2) 114.69,30.67 122.08,30.67 122.55,31.14 132.94,31.14 133.38,30.7 145.92,30.7 146.14,30.92 162.18,30.92 162.87,30.23 163.93,30.23 166.35,27.81 169.55,27.81 169.99,27.37 182.99,27.37 183.51,26.85 195.9,26.85 196.78,27.73 198.63,27.73 199.62,28.72 204.87,28.72 208.25,32.1 208.51,32.1 210.12,33.72 211.32,33.72 215.7,38.1 215.7,42.66 215.98,42.95 216.43,42.95 217.93,44.45 217.93,44.79 218.62,45.48 218.62,47.62 220.34,49.34 v2(220.34,54.28) ; v2(97,52.82) 97.66,52.16 103.36,52.16 108.23,47.3 v2(108.23,46.77)
  IN4 w0.076: v2(6.91,140.43) 6.85,140.43 5.34,138.92 5.34,129.71 6.13,128.93 6.13,126.66 7.72,125.07 7.72,124.66 10.27,122.1 10.27,91.01 11.14,90.14 15.82,90.14 26.89,79.07 26.89,70.63 28.88,68.63 28.88,62.5 29.46,61.92 29.46,61.09 29.49,60.96 29.49,60.7 33.03,57.16 49.13,57.16 50.52,55.78 50.52,52.92 51.22,52.22 96.39,52.22 v2(97,52.82) ; v2(12.47,183.56) 12.67,183.35 12.67,180.63 9.2,177.15 9.2,174.71 7,172.51 7,170.19 5.31,168.5 5.31,166.39 7.84,163.86 v2(7.84,152.44)
  BOTTOM w0.114: v2(113.16,32.2) 112.4,32.2 108.1,36.49 108.1,42.28 108.38,42.56 108.38,44.29 108.23,44.44 v2(108.23,46.77) ; v2(16.13,150.26) 16.36,150.48 R80150.2 17.02,150.74 R0727.1 16.31,151.4 R0706.1 ; v2(12.47,183.56) 12.47,183.29 R8003.2 ; v2(7.84,152.44) 8.08,152.68 v1(8.08,154.07) 7.82,153.81 Q0702.3 ; v2(220.34,54.28) 219.64,54.28 218.82,53.46 R8822.2
PROCHOT#_R: length 7.9
  BOTTOM w0.076: U0300.BR30 22.07,146.5 21.77,146.8 19.97,146.8 v1(18.62,148.15) 18.62,149.94 18.21,150.35
  BOTTOM w0.114: 18.21,150.35 18.21,150.35 18.21,151.08 R0727.2
PROG1: length 7.8
  BOTTOM w0.102: v1(8.36,185.28) 7.96,184.87 7.92,184.87 R8028.1 6.73,183.68 6.73,182.83 7.17,182.39 7.17,181.39 7.56,180.99 8.58,180.99 8.82,180.75 9.04,180.75 9.47,180.33 U8000.40
PROG2: length 6.1
  BOTTOM w0.102: U8000.39 9.07,180.33 8.84,180.55 8.73,180.55 8.49,180.79 7.42,180.79 6.73,181.48 v1(6.73,182.21) 6.53,182.42 R8041.1
PROG3: length 6.9
  BOTTOM w0.102: R8046.1 4.88,184.12 v1(4.88,182.71) 5.27,182.33 5.79,182.33 6.24,181.87 6.24,181.68 7.34,180.59 8.41,180.59 8.66,180.33 U8000.38
PROG4: length 8
  BOTTOM w0.102: U8000.37 8.27,180.26 8.14,180.38 7.25,180.38 6.04,181.6 6.04,181.73 5.66,182.11 4.81,182.11 4.24,182.67 4.24,182.95 v1(3.3,183.89) 3.78,184.37 R8087.1
PROG5: length 10.7
  BOTTOM w0.102: R8085.1 3.02,184.78 2.72,184.48 2.06,184.48 v1(1.52,183.94) 2.46,183 3.63,183 4.72,181.9 5.58,181.9 5.82,181.66 5.82,181.47 6.19,181.11 6.19,180.19 6.66,179.71 6.67,179.71 6.91,179.47 6.91,179.47 7,179.38 U8000.36
PSI: length 5.4
  TOP w0.102: R8902.2 181.26,82.67 v1(181.08,82.84) 180.73,82.49 180.73,82.19 R8903.1 179.89,82.05 179.89,83.07 179.39,83.56 U8900.4
PSYS: length 7.4
  BOTTOM w0.102: v1(11.81,184.29) 11.88,184.37 C8010.2 R8021.2 14.06,183.95 14.06,183.27 14.09,183.24 14.09,181.5 13.85,181.25 13.85,180.39 13.55,180.09 13.55,179.59 U8000.1
PU_HDA_MODE: length 10.5
  TOP w0.102: R2125.2 165.15,37.02 165.15,37.13 165.96,37.93 v1(166.53,37.93) 166.89,37.93 168.83,39.88 168.83,43.3 v2(169.39,43.85)
  BOTTOM w0.089: U2000.AB41 169.94,43.23 169.4,43.78 169.4,43.84 v2(169.39,43.85)
PV: length 4
  TOP w0.203: v1(121.96,66.76) 122.1,66.9 122.1,67.89 R8739.1 120.63,69.35 U8702.10
PWM1_A: length 46.2
  TOP w0.102: v2(45.01,175.53) 45.01,175.71 v1(45.58,176.29)
  TOP w0.203: U8001.1 44.73,175.12 45.01,175.4 v2(45.01,175.53)
  IN1 w0.254: v2(45.01,175.53) 45.01,175.07 44,174.06 33.85,174.06 32.92,174.99 32.92,175.94 32.47,176.39 27.34,176.39 25.23,174.28 23.23,174.28 22.85,174.67 18.39,174.67 17.89,175.17 14.6,175.17 13.65,174.22 10.45,174.22 9.87,173.63 6.95,173.63 6.8,173.78 v2(6.8,174.18)
  BOTTOM w0.203: v2(6.8,174.18) 7.15,174.53 7.15,174.8 7.33,174.98 U8000.25
PWM1_B: length 13.2
  TOP w0.254: v2(10.54,167.15) 10.54,167.1 10.44,166.99 U8006.1
  IN4 w0.254: v2(10.54,167.15) 10.59,167.2 10.59,167.91 14.02,171.34 v2(14.02,173.5)
  BOTTOM w0.102: v2(10.54,167.15) 10.82,166.87 11.81,166.87 11.85,166.9 v1(13.03,166.9)
  BOTTOM w0.222: U8000.12 13.7,174.98
  BOTTOM w0.254: 13.7,174.98 14.02,174.66 v2(14.02,173.5)
PWM2_A: length 35
  TOP w0.102: v2(34.06,175.53) 34.06,175.76 33.89,175.94 33.3,175.94 v1(32.94,176.29)
  TOP w0.203: v2(34.06,175.53) 34.06,175.31 33.81,175.05 U8002.1
  IN1 w0.254: v2(6.67,174.8) 7.07,174.8 8.22,175.95 13.09,175.95 15.16,178.02 16.56,178.02 17.16,177.43 17.16,176.92 17.92,176.16 26.1,176.16 27.05,177.1 33.35,177.1 34.06,176.4 34.06,175.53 v2(34.06,175.53)
  BOTTOM w0.203: U8000.26 7.17,175.38 7.04,175.25 7.04,175.17 v2(6.67,174.8)
PWM2_B: length 14.2
  TOP w0.102: v2(13.39,173.5) 13.39,173.65 13.84,174.1 v1(13.83,174.1)
  TOP w0.254: U8004.1 22.88,171.8 23.22,172.13 23.22,172.26 v2(23.2,172.26)
  IN1 w0.254: v2(23.2,172.26) 23.2,172.19 22.5,171.49 15.19,171.49 v2(14.69,171.99)
  IN3 w0.254: v2(13.39,173.5) 13.39,173.06 14.45,171.99 v2(14.69,171.99)
  BOTTOM w0.222: 12.8,173.93 12.66,174.07 U8000.13
  BOTTOM w0.254: v2(13.39,173.5) 12.95,173.93 12.8,173.93
PWM3_A: length 70.6
  TOP w0.203: U8003.1 67.71,171.17 66.28,172.6 65.37,172.6 64.81,172.03 57.73,172.03 56.92,172.84 55.79,172.84 54.98,172.03 53.51,172.03 53.35,172.19 v2(53.35,172.43)
  IN1 w0.254: v2(53.35,172.43) 53.35,173.07 52.5,173.92 49.13,173.92 46.6,176.45 34.77,176.45 33.76,177.46 26.9,177.46 25.98,176.55 18.03,176.55 17.51,177.07 17.51,177.57 16.71,178.38 15.02,178.38 12.95,176.3 8.07,176.3 7.26,175.5 v2(6.63,175.5)
  BOTTOM w0.102: v2(53.35,172.43) 53.52,172.27 v1(53.52,171.72)
  BOTTOM w0.203: U8000.27 6.91,175.78 v2(6.63,175.5)
PWM_C: length 83.1
  TOP w0.102: v1(7.16,179.16) 6.64,179.16 v2(6.5,179.31)
  IN1 w0.254: v2(6.5,179.31) 6.51,179.31 7.21,178.6 14.08,178.6 14.79,179.31 18.82,179.31 20.7,177.44 25.87,177.44 26.6,178.17 34.56,178.17 35.35,177.38 72.28,177.38 v2(74.42,179.52)
  BOTTOM w0.203: U8005.3 70.4,171.64 72.44,173.67 72.44,174.72 73.87,176.15 73.87,178.97 v2(74.42,179.52) ; v2(6.5,179.31) 6.83,178.98 U8000.35
PWR_LED: length 253.7
  TOP w0.102: v2(113.67,40.86) 114.17,40.36 115.92,40.36 116.33,40.77 116.33,44.09 115.92,44.5 U3001.24
  IN2 w0.102: v2(113.67,40.86) 112.79,41.73 101.76,41.73 99.63,43.87 90.98,43.87 90.48,43.36 69.76,43.36 69.04,44.09 67.83,44.09 67.1,44.82 57.81,44.82 57.09,44.11 49.15,44.11 47.55,45.71 45.38,45.71 44.91,46.19 44.91,46.73 41.26,50.39 36.95,50.39 35.44,51.89 35.44,53.32 28.8,59.96 28.8,62.06 28.73,62.13 28.73,67.72 25.63,70.83 25.63,74.13 26.06,74.56 26.06,81.51 18.03,89.54 18.03,112.76 12.45,118.35 12.45,124.81 12.93,125.29 12.93,132.1 12.05,132.98 12.05,136.61 13.69,138.25 13.69,140.91 14.07,141.29 14.07,143.18 13.75,143.5 13.75,145.38 14.73,146.36 14.73,147.25 15.16,147.68 15.16,148.1 15.41,148.35 15.41,151.3 21.48,157.37 21.48,164.2 22.81,165.53 22.81,166.37 20.52,168.66 20.52,172.39 26.19,178.06 31.65,178.06 32.03,178.43 34.23,178.43 35.93,180.13 36.09,180.13 37.01,181.04 v2(37.01,181.09)
  BOTTOM w0.102: v2(37.01,181.09) 37.01,180.79 36.63,180.41 36.63,179.26 37.75,178.14 CON5602.17 ; v1(113.27,40.24) 113.27,40.47 v2(113.67,40.86)
PWR_LED_IO: length 34.9
  TOP w0.114: CON402.17 187.2,175.66 v1(187.76,175.1) 187.85,175.1 v2(188.42,174.53) 188.42,172.34 185.56,169.49 174.57,169.49 173.5,170.56 PCON700.4 ; PQ700.1 197.34,174.76 197.04,175.07 PD701.1 v2(196.44,175.85)
  IN1 w0.102: v2(188.42,174.53) 189.74,175.85 v2(196.44,175.85)
PWR_LED_LED: length 13.2
  TOP w0.114: v1(174.22,156.72) 174.38,156.88 LQ800.1 178.82,156.88 178.94,157.01 LC800.1 179.83,157.01 180.01,157.19 180.01,157.42 181.72,159.13 184.81,159.13 185.05,158.89 CON1.5
PWRBTN#: length 272
  TOP w0.102: v2(125.64,42.18) 125.81,42.35 U3001.125 128.11,42.35 128.47,42.71 R3053.2 ; v2(32.06,182.46) 32.08,182.48 JP5601.1
  IN1 w0.102: v2(32.06,182.46) 32.19,182.33 36.51,182.33 v2(37.01,181.83)
  IN2 w0.102: v2(125.64,42.18) 125.64,42.25 125.19,42.7 120.42,42.7 118.01,40.3 113.65,40.3 112.61,41.34 101.86,41.34 99.54,43.66 91.07,43.66 90.56,43.16 69.68,43.16 68.95,43.88 67.75,43.88 67.01,44.62 57.89,44.62 57.18,43.9 49.03,43.9 47.42,45.51 45.3,45.51 44.7,46.1 44.7,46.65 41.17,50.18 36.87,50.18 35.24,51.81 35.24,53.24 28.6,59.88 28.6,61.98 28.53,62.05 28.53,65.96 25.42,69.06 25.42,74.21 25.86,74.64 25.86,81.42 17.83,89.46 17.83,112.68 12.24,118.26 12.24,124.89 12.73,125.37 12.73,132.01 11.85,132.89 11.85,136.69 12.83,137.68 12.83,141.12 13.24,141.53 13.26,141.53 13.87,142.13 13.87,143.1 13.55,143.42 13.55,145.47 14.53,146.44 14.53,147.33 14.96,147.76 14.96,148.19 15.21,148.44 15.21,151.39 21.26,157.44 21.26,167.48 19.5,169.24 19.5,172.38 20.74,173.63 21.39,173.63 26.03,178.26 31.56,178.26 31.94,178.64 34.15,178.64 35.89,180.38 36.06,180.38 36.58,180.9 36.58,181.4 v2(37.01,181.83)
  BOTTOM w0.102: v1(125.03,42.87) 125.03,42.8 v2(125.64,42.18) ; CON5602.16 37.25,178.22 36.4,179.07 36.4,180.48 36.6,180.69 36.6,181.27 37.01,181.68 v2(37.01,181.83)
PWRBTN#_IO: length 12.7
  TOP w0.114: CON402.16 187.7,176.05 188.86,174.89 188.86,172.13 v1(188.86,170.77) 188.04,169.96 PD700.1 v2(188.04,167.2)
  BOTTOM w0.114: PSW1700.4 v2(188.04,167.2)
R303_D8: length 5.9
  BOTTOM w0.508: D2801.2 225.4,59.22 226.89,57.73 226.89,57.23 v1(227.89,56.23) R2811.2
R_DMIC-CLK: length 4.7
  TOP w0.203: R3611.2 24.41,66.39 24.61,66.59 24.7,66.59 v1(25.12,67.01) 24.96,67.17 23.96,67.17 23.08,68.05 22.85,68.05 22.79,68.11 U3600.3
R_DMIC-DATA: length 3.8
  TOP w0.203: U3600.2 22.78,67.71 23.42,67.07 v1(23.42,66.67) 23.42,66.15 24.38,65.18 R3610.2
RCIN#: length 90.9
  TOP w0.102: v2(190.04,60.85) 190.04,61.19 v1(189.76,61.47) 189.06,61.47 R2218.1 ; U3001.4 123.92,43.39 124.94,42.37 v2(124.94,42.18)
  IN1 w0.102: v2(190.04,60.85) 189.59,61.31 187.96,61.31 183.26,56.61 183.26,54.28 182.85,53.86 182.85,49.66 181.78,48.59 181.78,47 182.58,46.2 182.58,42.83 179.89,40.14 179.36,40.14 178.35,41.14 172.48,41.14 170.37,39.03 159.76,39.03 159.17,38.45 146.91,38.45 145.3,40.05 136.37,40.05 135.18,41.24 133.09,41.24 132.48,41.85 130.69,41.85 130.61,41.78 125.34,41.78 v2(124.94,42.18)
RL_XTAL1: length 10.1
  TOP w0.114: Y3300.1 238.64,95.38 238.03,96 235.91,96 235.13,95.22 v1(235.13,94.71) 234.95,94.53 C3324.1 234.02,94.62 231.71,94.62 231.05,93.96 U3300.7
RL_XTAL2: length 7.9
  TOP w0.102: 233.66,95.73 233.12,95.19 233.07,95.19
  TOP w0.114: U3300.8 230.97,94.36 231.8,95.19 v1(232.84,95.19) 233.07,95.19 ; Y3300.3 236.1,97.33 235.21,96.45 234.38,96.45 C3325.1 233.66,95.73
ROM_S0: length 15.9
  TOP w0.102: v6(97.1,123.9) v1(96.19,124.81) 95.39,124.81 94.64,125.57 86.54,125.57 R7305.2 R7313.1 85.65,124.65 85.65,124.22 85.27,123.84 U7401.2
  BOTTOM w0.102: U7000.BA4 v6(97.1,123.9)
ROM_SCLK: length 28.6
  TOP w0.102: v6(97.08,122.32) 97.06,122.35 97.06,122.35 94.3,125.11 90.37,125.11 88.95,123.69 88.95,122.3 88.44,121.79 88.04,121.79 87.35,121.1 R7306.1 R7314.1 81.33,121.6 81,121.93 76.64,121.93 v1(76.28,122.29) 76.2,122.37 R7403.1
  BOTTOM w0.102: U7000.BA2 97.06,122.35 v6(97.08,122.32)
ROM_SI: length 24.6
  TOP w0.102: v6(97.12,125.59) 95.09,125.59 94.87,125.81 90.28,125.81 89.46,126.64 v1(89.46,127.17) 88.87,127.17 87.83,128.21 86.56,128.21 R7312.2 R7304.2 83.56,127.78 82.67,126.89 76.71,126.89 R7402.1
  BOTTOM w0.102: v6(97.12,125.59) 96.7,125.17 U7000.BA5
RPD_G1: length 9
  TOP w0.076: U1201.K9 244.23,52.94 244.67,52.94
  TOP w0.102: R1202.2 250.68,50.26 249.69,51.25 v1(249.69,52.65) 248.76,52.65 248.14,53.26 244.99,53.26 244.81,53.08 244.81,53.08 244.67,52.94
RPD_G2: length 9.2
  TOP w0.076: 244.73,53.58 244.59,53.45 244.24,53.45 U1201.K10
  TOP w0.102: R1204.2 250.7,52.24 v1(251.38,52.93) 251.02,53.29 248.7,53.29 248.24,53.74 244.89,53.74 244.73,53.58
RST#: length 10.6
  TOP w0.102: U3300.2 230.69,91.96 231.36,91.29 233.72,91.29 234.1,90.91 234.1,89.44 235.38,88.15 R3308.1 236.14,87.19 236.15,87.19 v1(236.35,87.19) 236.65,87.19 R3307.2
RST#_DP: length 4.9
  TOP w0.254: R1407.2 206.67,44.15 C1412.1 208.04,44.15 v1(208.48,44.59) 209.12,44.59 210.02,43.7 U1401.35
RST#_DP2: length 4.5
  TOP w0.102: U4601.35 243.42,110.26 242.97,110.71 242.88,110.71 v1(242.44,111.14) 241.89,111.69 C4613.2 240.42,111.69 R4621.2
RST#_HDMI: length 7.7
  TOP w0.102: v1(207.04,60.75) 207.33,61.05 208.33,61.05 208.89,60.49 R1302.2 209.33,60.78 209.93,60.78 211.13,59.57 C1303.1 211.13,58.58 210.91,58.35 U1301.35
RSVD19: length 3.2
  TOP w0.102: R1004.1 25.32,140.38 24.93,139.98 v1(24.51,139.98) v6(24.51,140.59)
  BOTTOM w0.102: v6(24.51,140.59) 24.84,140.27 U0300.BL22
RSVD28: length 3.3
  TOP w0.102: v1(22.56,140.61) 22.95,140.21 23.48,140.21 23.86,140.59 v6(23.86,140.59) 23.86,140.59 24.24,140.97 24.24,141.23 R1005.2
  BOTTOM w0.102: U0300.BM22 24.19,140.26 v6(23.86,140.59)
RSVD30: length 2.2
  TOP w0.102: v1(23.83,135.93) 23.76,135.87 v6(23.21,135.87) 22.67,135.87 R1010.2
  BOTTOM w0.102: U0300.BN16 23.21,135.8 v6(23.21,135.87)
RSVD34: length 5
  TOP w0.102: v6(23.22,136.65) 22.75,136.65 R1009.1 21.95,137.46 20.26,137.46 19.75,137.97 v1(19.75,138.47)
  BOTTOM w0.102: U0300.BP17 23.22,136.59 v6(23.22,136.65)
RSVD_TP0: length 1.6
  TOP w0.102: T0708.1 25.24,133.99 v6(25.24,133.44)
  BOTTOM w0.102: v6(25.24,133.44) 25.68,133.44 25.86,133.26 U0300.BJ13
RSVD_TP1: length 2.9
  TOP w0.102: v6(26.72,134.23) 27.14,134.65 27.62,134.65 28.12,134.15 T0707.1
  BOTTOM w0.102: v6(26.72,134.23) 26.43,133.94 U0300.BJ14
RSVD_TP2: length 3.1
  TOP w0.102: v6(26.7,136.67) 25.77,137.59 T0717.1
  BOTTOM w0.102: v6(26.7,136.67) 26.7,136.03 U0300.BJ16
RSVD_TP3: length 1.3
  TOP w0.102: v6(26.68,141.77) 26.31,141.41 T0724.1
  BOTTOM w0.102: U0300.BJ24 v6(26.68,141.77)
RSVD_TP4: length 4.6
  TOP w0.102: v6(26.15,148.78) 25.74,149.19 25.74,149.92 25.04,150.61 24.55,150.61 T0734.1
  BOTTOM w0.102: v6(26.15,148.78) 25.83,148.46 U0300.BJ33
RSVD_TP5: length 1.9
  TOP w0.102: T0732.1 26.15,150.32 v6(26.15,149.43)
  BOTTOM w0.102: U0300.BJ34 25.85,149.21 25.92,149.21 v6(26.15,149.43)
RSVD_TP6: length 2.2
  TOP w0.102: v6(26.67,135.37) 26.32,135.37 T0719.1
  BOTTOM w0.102: v6(26.67,135.37) 26.42,135.12 25.85,135.12 U0300.BK16
RSVD_TP7: length 4.3
  TOP w0.102: v6(27.23,142.56) 27.23,141.39 T0722.1
  BOTTOM w0.102: U0300.BK24 25.87,142.15 26.82,142.15 v6(27.23,142.56)
RSVD_TP8: length 1.3
  TOP w0.102: v6(25.36,148.78) 24.74,148.78 T0714.1
  BOTTOM w0.102: U0300.BL33 25.29,148.78 v6(25.36,148.78)
RSVD_TP9: length 1.9
  TOP w0.102: T0703.1 23.01,149.32 v6(23.86,148.47)
  BOTTOM w0.102: v6(23.86,148.47) 23.86,148.4 U0300.BM33
RSVD_TP10: length 5.9
  TOP w0.102: T0709.1 20.47,123.72 v6(20.47,124.6)
  BOTTOM w0.102: v6(20.47,124.6) 20.67,124.4 21.47,124.4 U0300.BR1
RSVD_TP11: length 4.7
  TOP w0.102: v6(21.11,125.21) 21.11,123.88 20.37,123.14 T0710.1
  BOTTOM w0.102: v6(21.11,125.21) 21.35,125.21 21.59,125.44 U0300.BT2
RSVD_TP12: length 8.2
  BOTTOM w0.102: T0702.1 67.31,124.78 63.86,124.78 63.37,124.3 60.67,124.3 60.22,124.74 U0300.D1
RSVD_TP13: length 7.2
  BOTTOM w0.102: T0704.1 65.12,123.61 64.9,123.84 60.44,123.84 59.44,124.84 U0300.E1
RSVD_TP14: length 17.6
  BOTTOM w0.102: U0300.E2 59.74,125.36 59.78,125.32 59.78,124.91 60.59,124.11 65.03,124.11 65.47,124.55 66.69,124.55 67.7,123.54 69.85,123.54 71.09,122.3 71.09,120.28 T0706.1
RSVD_TP15: length 7.5
  BOTTOM w0.102: T0705.1 65.55,125.08 63.78,125.08 63.27,124.57 60.86,124.57 60.57,124.86 60.57,125.38 60.02,125.92 60.02,126.11 U0300.E3
RSVD_TP36: length 2.8
  TOP w0.102: T0730.1 20.7,135.42 v6(20.7,135.88)
  BOTTOM w0.102: U0300.BR17 22.23,136.26 21.85,135.88 v6(20.7,135.88)
RSVD_TP40: length 1.7
  TOP w0.102: T0729.1 20.41,136.48 v6(20.73,136.48)
  BOTTOM w0.102: U0300.BT17 20.94,136.26 v6(20.73,136.48)
RTCRST#: length 51.1
  TOP w0.102: v1(219.63,57.75) 219.63,57.3 v2(219.89,57.04)
  IN4 w0.102: v2(219.89,57.04) 219.66,57.28 218.85,57.28 217.58,56 216.79,56 215.85,55.05 207.13,55.05 v2(205.28,53.2)
  BOTTOM w0.089: 184.71,61.16 184.06,61.16 183.2,60.3 183.2,59.99 182.78,59.56 182.78,58.68 182.31,58.21 181.76,58.21 181.71,58.17 181.22,58.17 181.19,58.14 180.69,58.14 U2000.BC10
  BOTTOM w0.102: 184.71,61.16 186.9,61.16 187.42,61.67 188.71,61.67 188.77,61.74 194.22,61.74 196.11,59.84 200.37,59.84 203.12,57.09 203.12,54.03 203.46,53.69 204.8,53.69 v2(205.28,53.2) ; v2(219.89,57.04) 219.63,56.79 C2828.1 R2812.2
RTCX1_NO_IO: length 11.9
  BOTTOM w0.089: 184.71,63.26 184.63,63.26 184.33,62.96 184.33,62.7 183.82,62.2 183.82,61.42 182.8,60.4 182.8,60.09 182.42,59.7 182.42,58.82 182.16,58.57 181.55,58.57 181.53,58.55 181.27,58.55 181.17,58.64 180.57,58.64 U2000.BC9
  BOTTOM w0.114: v1(187.78,64.84) 187.38,64.43 187.38,64.36 R2525.1 186.73,63.98 186.56,63.8 186.56,63.32 186.45,63.21 C2500.1 185.78,63.21 185.73,63.26 R2523.1 184.71,63.26
RTCX2_NO_IO: length 10.2
  BOTTOM w0.089: 184.71,62.02 184.11,61.42 184.07,61.42 182.98,60.33 182.98,60.02 182.6,59.63 182.6,58.75 182.24,58.39 181.66,58.39 181.63,58.36 181.07,58.36 U2000.BD10
  BOTTOM w0.114: 184.71,62.02 R2523.2 185.55,62.4 185.6,62.45 C2501.1 186.88,62.45 v1(187.11,62.22) 187.34,62.45 188.02,62.45 188.03,62.43 Y2500.4
RTD3_CIO_PWR_EN: length 4.7
  TOP w0.102: R1130.1 244.58,42.65 v1(245.04,42.19) 245.29,41.94 245.29,39.08 245.21,39 U1101.F1
RTD3_USB_PWR_EN: length 1.5
  TOP w0.102: U1101.D4 246.35,37.65 v4(246.02,37.32)
  BOTTOM w0.102: R1134.1 246.28,37.58 v4(246.02,37.32)
RTN_A: length 5.7
  TOP w0.152: v2(10.66,173.12) 9.75,174.03 8.43,174.03 v1(7.8,174.67) 7.65,174.82 R8005.2
  BOTTOM w0.152: U8000.18 v2(10.66,173.12)
RTN_B: length 3
  BOTTOM w0.203: U8000.6 14.22,177.38 v1(14.56,177.04) 15.03,177.52 R8027.2
S3: length 6.9
  TOP w0.102: U8300.7 136.68,61.59 136.73,61.64 137.64,61.64 C8319.1 137.67,61.41 137.89,61.18 139.29,61.18 v1(139.55,61.43) 139.75,61.43 140.34,60.85 R8305.2 141.29,60.85 141.55,60.59 D8300.1
S5: length 11.1
  TOP w0.102: D8301.1 141.01,65.42 140.41,66.01 R8307.2 140.07,66.94 139.93,66.8 139.93,63.85 v1(139.5,63.42) 139.12,63.04 137.87,63.04 137.67,62.83 C8322.1 137.67,62.43 137.23,61.99 U8300.8
SATA_DEVSLP0: length 139.5
  TOP w0.102: R5106.1 57,26.75 57.13,26.88 57.13,28.73 56.87,28.98 56.87,29.32 57.59,30.04 59.69,30.04 v1(60.53,30.88) 60.73,31.08 v2(60.73,39.44)
  IN1 w0.102: v2(60.73,39.44) 60.91,39.62 68.57,39.62 69.09,39.1 78.32,39.1 78.69,39.47 95.74,39.47 96.14,39.87 111.07,39.87 111.42,39.52 113.35,37.59 115.22,37.59 116.27,36.54 119.85,36.54 119.92,36.62 127.4,36.62 127.69,36.34 170.99,36.34 v2(172.64,34.69)
  BOTTOM w0.089: 172.02,37.73 171.95,37.81 171.95,40.78 172.08,40.92 172.08,41.32 172.06,41.34 172.06,42.22 U2000.AG42
  BOTTOM w0.102: 172.02,37.73 172.02,37.73 172.02,37.39 R2157.2 172.22,36.35 172.22,35.11 v2(172.64,34.69)
SATA_LED#: length 14.7
  BOTTOM w0.102: v1(40.6,174.77) 41.25,175.43 CON5602.24 41.25,180.26 42.32,181.33 44.43,181.33 44.48,181.37 47.5,181.37 48.01,180.87 R5603.2 47.8,180.28 D5601.3
SATA_LED#_IO: length 19
  TOP w0.114: v1(171.41,170.01) 172,170.6 PCON700.7 v2(172,172.96) ; v2(183.31,179.04) 183.7,178.65 CON402.24
  IN1 w0.102: v2(172,172.96) 172,173.8 176.39,178.19 176.46,178.19 176.49,178.21 182.49,178.21 v2(183.31,179.04)
SATA_LED#_LED: length 10.1
  TOP w0.114: CON1.2 186.55,158.33 186.79,158.57 188.32,158.57 189.18,157.71 v1(189.61,157.71) 189.95,158.05 LQ803.2 191.83,158.05 192.05,157.83 192.05,157.15 192.25,156.94 LC803.1
SATA_LED_LED: length 5.3
  TOP w0.102: LQ803.5 193.96,158.05 194.09,157.92 LR804.2 194.62,158.21 194.13,158.7
  TOP w0.114: 194.13,158.7 LQ803.6 ; v1(196.39,157.1) 196.01,157.48 194.77,157.48 194.62,157.63 LR804.2
SATA_ODD_DA#: length 161.3
  TOP w0.102: v2(43.38,37.18) 43.38,36.62 43.03,36.26 42.24,36.26 39.09,33.11 32.88,33.11 30.95,31.18 v1(30.35,31.18) 29.41,31.18 28.25,30.02 28.25,29.05 27.86,28.67 25.63,28.67 25.45,28.85 R5109.2 ; v2(162.23,34.69) 161.82,35.09 161.82,35.5 R2209.2 161.81,36.32 161.81,37.75 162.49,38.43 164.97,38.43 166.93,40.38 166.93,42.84 166.73,43.05 166.73,43.48 v2(167.11,43.87)
  IN1 w0.102: v2(162.23,34.69) 161.24,34.69 160.2,35.73 130.74,35.73 130.11,35.1 130.11,33.96 129.87,33.72 129.3,33.72 128.36,34.66 116.44,34.66 114.58,36.52 112.94,36.52 110.71,38.75 96.5,38.75 96.17,38.43 79.13,38.43 77.27,36.57 44.35,36.57 43.74,37.18 v2(43.38,37.18)
  BOTTOM w0.102: U2000.U41 167.66,43.4 167.19,43.87 v2(167.11,43.87)
SATA_ODD_PRSNT#_CON: length 5
  TOP w0.102: R5108.2 24.38,31.34 v1(24.08,31.64) 24.08,32.2 24.82,32.94 25.6,32.94 25.96,32.59 U5102.2
SATA_RXN1: length 144.6
  TOP w0.114: v2(48.95,26.09) 48.8,26.24 C5122.1
  IN4 w0.089: v2(162.1,44.46) 162.38,44.74 162.84,44.74 163.12,44.47 163.12,43.2 163.6,42.71 163.6,39.87 160.02,36.28 160.02,35.2 159.07,34.26 154.94,34.26 154.69,34.5 144.52,34.5 143.94,33.93 141,33.93 140.4,34.52 136.08,34.52 135.08,35.52 126.04,35.52 125.17,36.39 119.78,36.39 119.66,36.27 111.05,36.27 110.61,35.83 107.3,35.83 106.14,36.99 47.79,36.99 47.04,37.74 46.33,37.74 46.26,37.67 45.85,37.67 v2(45.46,37.28)
  BOTTOM w0.114: v2(48.95,26.09) 49.08,26.23 49.08,26.51 47.55,28.03 46.59,28.03 45.67,28.96 45.67,37.07 v2(45.46,37.28) ; v2(162.1,44.46) 161.69,44.46 U2000.D39
SATA_RXN2: length 141.9
  IN4 w0.089: v2(43.98,39.68) 44.16,39.5 44.16,39.25 44.5,38.91 57.15,38.91 58.48,37.58 99.65,37.58 99.66,37.57 100.14,37.57 100.15,37.58 110.72,37.58 111.56,36.74 119.47,36.74 119.59,36.87 125.61,36.87 126.39,36.09 135.18,36.09 136.27,34.99 146.58,34.99 147.34,35.76 158.09,35.76 160.55,38.22 161.26,38.22 163.13,40.09 163.13,42.42 162.22,43.33 162.22,43.64 v2(162.48,43.91)
  BOTTOM w0.114: v2(43.98,39.68) 44.14,39.84 44.14,44.25 44.81,44.92 44.81,47.17 44.33,47.64 42.49,47.64 ; 42.49,47.64 41.35,47.64 41.21,47.5 41.21,46.8 C5102.1 ; 42.49,47.64 v1(42.49,47.42) ; v2(162.48,43.91) 162.03,43.45 U2000.F41
SATA_RXN2_C: length 16.6
  BOTTOM w0.114: CON5100.16 42.15,30.65 42.54,31.03 42.54,32.74 42.21,33.07 42.21,40.82 41.43,41.6 41.43,45.28 C5102.2
SATA_RXN3: length 146.5
  TOP w0.114: 29.13,35.81 31.09,35.81 31.94,36.66 34.71,36.66 34.78,36.73 34.78,36.87 v2(34.55,37.09) ; 29.13,35.81 28.65,35.81 27.8,36.66 27.08,36.66 27,36.74 27,37 C5142.1 ; 29.13,35.81 v1(29.13,36.04)
  IN4 w0.089: v2(161.8,41.98) 162.02,42.21 162.16,42.21 162.31,42.06 162.31,40.59 160.83,39.12 160.29,39.12 157.76,36.59 146.94,36.59 146.16,35.82 136.62,35.82 135.53,36.91 127.29,36.91 126.02,38.18 118.99,38.18 118.79,38.38 115.71,38.38 115.12,37.79 111.7,37.79 111.04,38.45 100.96,38.45 100.65,38.76 58.61,38.76 56.89,40.48 43.23,40.48 40.74,37.99 35.13,37.99 34.77,37.63 34.77,37.3 v2(34.55,37.09)
  BOTTOM w0.089: U2000.D43 161.27,42 161.35,42.08 161.7,42.08 v2(161.8,41.98)
SATA_RXN3_C: length 8.5
  TOP w0.114: C5142.2 25.42,36.74 24.89,36.74 24.79,36.84 24.79,37.66 24.61,37.84 ; 24.61,37.84 24.5,37.95 23.48,37.95 23.19,37.66 23.19,35.78 22.74,35.33 22.2,34.79 21.84,34.79 CON5101.S5 ; 24.61,37.84 v1(24.77,38.01)
SATA_RXN4_C: length 18.4
  TOP w0.114: C5122.2 49.05,27.89 49.05,29.28 v2(48.79,29.53)
  BOTTOM w0.114: v2(48.79,29.53) 49.15,29.89 49.15,30.04 49.33,30.22 49.33,30.23 51.19,32.09 51.19,40.81 49.89,42.1 48.91,42.1 48.83,42.01 48.83,41.91 48.75,41.83 47.89,41.83 CON5103.43
SATA_RXP1: length 144.5
  TOP w0.114: v2(49.56,26.09) 49.61,26.15 C5121.1
  IN4 w0.089: v2(46.11,37.27) 46.4,37.56 46.97,37.56 47.71,36.81 106.07,36.81 107.23,35.65 110.68,35.65 111.12,36.1 119.74,36.1 119.85,36.21 125.1,36.21 125.96,35.35 135,35.35 136,34.35 140.33,34.35 140.93,33.75 144.02,33.75 144.59,34.33 154.62,34.33 154.86,34.08 159.15,34.08 160.2,35.13 160.2,36.21 163.78,39.79 163.78,42.79 163.3,43.27 163.3,44.54 162.92,44.92 162.2,44.92 162.1,45.02 v2(162.1,45.23)
  BOTTOM w0.114: U2000.E37 161.92,44.87 162.1,45.05 v2(162.1,45.23) ; v2(46.11,37.27) 45.91,37.06 45.91,29.05 46.69,28.27 47.65,28.27 49.32,26.6 49.32,26.33 v2(49.56,26.09)
SATA_RXP2: length 142
  IN4 w0.089: v2(161.85,43.91) 162.04,43.71 162.04,43.26 162.95,42.35 162.95,40.16 161.19,38.39 160.48,38.39 158.02,35.93 147.27,35.93 146.51,35.17 136.35,35.17 135.25,36.26 126.46,36.26 125.68,37.04 119.51,37.04 119.39,36.92 111.63,36.92 110.8,37.76 100.08,37.76 100.06,37.74 99.73,37.74 99.72,37.76 58.55,37.76 57.23,39.08 44.58,39.08 44.34,39.32 44.34,39.43 v2(44.6,39.68)
  BOTTOM w0.114: 40.98,47.27 40.98,46.58 C5103.1 ; 40.98,47.27 v1(40.75,47.27) ; 40.98,47.27 40.98,47.6 41.26,47.88 44.43,47.88 45.04,47.26 45.04,44.82 44.37,44.15 44.37,39.9 v2(44.6,39.68) ; U2000.E41 161.52,43.57 v2(161.85,43.91)
SATA_RXP2_C: length 16.5
  BOTTOM w0.114: C5103.2 41.01,45.25 41.08,45.25 41.2,45.13 41.2,41.5 41.97,40.73 41.97,32.97 42.3,32.64 42.3,31.13 42.05,30.88 41.93,30.88 41.87,30.95 41.87,31.08 41.81,31.15 CON5100.15
SATA_RXP3: length 146.5
  TOP w0.114: v2(35.18,37.09) 35.01,36.92 35.01,36.63 34.81,36.43 32.04,36.43 31.19,35.58 30.79,35.58 ; 30.79,35.58 v1(30.79,35.35) ; 30.79,35.58 28.55,35.58 27.7,36.43 26.99,36.43 C5143.1
  IN4 w0.089: v2(161.85,42.69) 162.15,42.38 162.23,42.38 162.48,42.13 162.48,40.52 160.9,38.94 160.36,38.94 157.83,36.42 147.01,36.42 146.24,35.64 136.55,35.64 135.46,36.73 127.22,36.73 125.95,38 118.92,38 118.71,38.2 115.78,38.2 115.19,37.61 111.63,37.61 110.97,38.27 100.89,38.27 100.57,38.58 58.54,38.58 56.82,40.3 43.31,40.3 40.82,37.81 35.2,37.81 34.94,37.55 34.94,37.32 v2(35.18,37.09)
  BOTTOM w0.089: v2(161.85,42.69) 161.82,42.69 U2000.E42
SATA_RXP3_C: length 8.5
  TOP w0.114: 24.99,36.51 24.79,36.51 24.56,36.74 24.56,37.56 24.4,37.71 23.58,37.71 23.43,37.56 23.43,35.68 23.31,35.56 22.3,34.56 21.96,34.56 CON5101.S6 ; 24.99,36.51 v1(24.99,36.28) ; 24.99,36.51 25.61,36.51 C5143.2
SATA_RXP4_C: length 18.7
  TOP w0.114: v1(49.5,28.54) 49.28,28.54 ; 49.28,28.54 49.28,27.97 C5121.2 ; 49.28,28.54 49.28,29.38 49.28,29.38 v2(49.43,29.53)
  BOTTOM w0.114: v2(49.43,29.53) 49.43,29.99 49.56,30.12 49.56,30.13 51.42,31.99 51.42,40.9 49.99,42.33 48.81,42.33 48.8,42.35 CON5103.41
SATA_SSD_LED#: length 2.9
  BOTTOM w0.102: v1(47.04,175.23) 47.3,175.23 47.73,175.66 R5126.1 47.7,176.93 D5601.2
SATA_TXN1: length 144.1
  TOP w0.114: v2(47.7,26.09) 47.49,26.31 47.49,26.43 C5123.1
  IN4 w0.089: v2(156.21,43.37) 156.42,43.16 156.42,43.05 155.81,42.44 149.74,42.44 148.72,41.42 147.7,41.42 147.01,42.11 145.29,42.11 144.02,40.83 140.03,40.83 137.29,43.57 130.52,43.57 129.54,44.56 129.43,44.67 123.78,44.67 123.64,44.67 122.56,43.59 119.58,43.59 119.57,43.59 115.04,43.59 114.62,44.01 113.44,44.01 113,43.57 112.27,43.57 112.03,43.81 99.99,43.81 98.53,45.28 73.52,45.28 72.81,44.56 67.72,44.56 67.33,44.95 58.87,44.95 57.71,43.78 45.87,43.78 45.69,43.96 45.69,44.05 45.89,44.25 45.93,44.25 v2(46.17,44.49)
  BOTTOM w0.114: 156.58,44.01 156.58,44.31 157.14,44.87 159.58,44.87 159.89,44.56 160.21,44.56 U2000.B38 ; 156.58,44.01 156.58,43.75 v2(156.21,43.37) ; 156.58,44.01 v1(156.34,44.01) ; v2(47.7,26.09) 47.23,26.57 47.23,26.66 46.61,27.27 46.28,27.27 45.18,28.38 45.18,36.1 44.95,36.33 44.95,37.92 45.97,38.95 45.97,42.36 45.77,42.56 45.77,44.09 v2(46.17,44.49)
SATA_TXN2: length 131.3
  IN4 w0.089: v2(43.44,42.77) 43.36,42.86 43.36,43.07 43.56,43.27 44.43,43.27 45.21,42.49 57.58,42.49 59.03,43.94 67,43.94 67.64,43.3 72.97,43.3 74.09,44.42 98.2,44.42 100.05,42.58 114.02,42.58 114.17,42.72 114.2,42.76 122.91,42.76 123.56,43.42 128.93,43.42 129.73,42.61 137.08,42.61 139.7,40 144.62,40 144.85,40.23 149,40.23 149.58,40.81 156.08,40.81 157.21,41.94 157.21,42.57 157.55,42.92 158.47,42.92 158.7,43.14 158.7,43.56 v2(158.8,43.67)
  BOTTOM w0.114: v2(43.44,42.77) 43.44,44.27 44.23,45.06 44.23,46.66 43.76,47.13 42.99,47.13 42.76,46.91 42.76,46.61 C5101.1 ; v2(158.8,43.67) 158.59,43.89 158.59,44.04 158.73,44.19 159.08,44.19 159.46,43.8 160.06,43.8 160.27,44.01 U2000.B39
SATA_TXN2_C: length 19.1
  BOTTOM w0.114: C5101.2 42.82,45.17 42.82,45.02 42.02,44.22 42.02,42.09 42.71,41.4 42.71,39.32 43.85,38.19 43.85,35.92 44.21,35.56 44.21,31.92 41.84,29.55 41.77,29.55 41.67,29.65 CON5100.18
SATA_TXN3: length 141.9
  TOP w0.114: 30.94,37.76 31.12,37.94 34.62,37.94 34.86,38.17 34.86,38.4 v2(35.13,38.67) ; 30.94,37.76 28.68,37.76 27.98,38.46 26.99,38.46 C5141.1 ; 30.94,37.76 v1(30.94,37.53)
  IN4 w0.089: v2(35.13,38.67) 35.06,38.67 34.85,38.88 34.85,39.13 35.76,40.05 40.89,40.05 42.67,41.83 58.08,41.83 58.84,42.59 73.53,42.59 74.7,43.75 96.47,43.75 98.38,41.85 111.54,41.85 111.61,41.93 114.35,41.93 114.54,42.11 123.29,42.11 123.91,42.74 126.63,42.74 127.44,41.93 133.23,41.93 134.02,41.14 137.37,41.14 139.17,39.34 144.93,39.34 145.15,39.55 149.39,39.55 149.96,40.12 156.34,40.12 158.08,41.86 158.08,42.11 v2(158.37,42.39)
  BOTTOM w0.089: U2000.A41 159.63,43.16 159.34,43.16 159.24,43.06 158.41,43.06 158.16,42.81 158.16,42.61 v2(158.37,42.39)
SATA_TXN3_C: length 9.5
  TOP w0.114: CON5101.S3 21.91,38.32 22.63,38.32 24.17,39.86 ; v1(24.33,39.69) 24.17,39.86 ; 24.17,39.86 24.46,40.15 24.46,40.94 24.61,41.09 25.11,41.09 25.27,40.94 25.27,39.74 24.86,39.33 24.86,38.91 25.15,38.62 25.53,38.62 C5141.2
SATA_TXN4_C: length 17.8
  TOP w0.114: v1(47.83,28.54) 47.59,28.54 ; 47.59,28.54 47.59,27.88 C5123.2 ; 47.59,28.54 47.59,29.37 v2(47.75,29.53)
  BOTTOM w0.114: v2(47.75,29.53) 47.75,30.3 48.31,30.85 49.25,30.85 50.69,32.29 50.69,40.15 49.99,40.85 47.88,40.85 CON5103.47
SATA_TXP1: length 144
  TOP w0.114: C5124.1 47.25,26.55 47.25,26.25 v2(47.09,26.09)
  IN4 w0.089: v2(156.82,43.37) 156.59,43.15 156.59,42.97 155.88,42.26 149.81,42.26 148.8,41.24 147.63,41.24 146.94,41.93 145.37,41.93 144.09,40.65 139.96,40.65 137.22,43.4 130.45,43.4 129.36,44.49 123.71,44.49 122.63,43.41 119.5,43.41 114.97,43.41 114.54,43.83 113.51,43.83 113.07,43.4 112.19,43.4 111.96,43.63 99.92,43.63 98.45,45.1 73.6,45.1 72.88,44.38 67.65,44.38 67.26,44.77 58.95,44.77 57.78,43.6 45.8,43.6 45.52,43.88 45.52,44.45 v2(45.56,44.49)
  BOTTOM w0.114: v2(45.56,44.49) 45.56,44.21 45.54,44.19 45.54,42.46 45.74,42.26 45.74,39.05 44.71,38.02 44.71,36.23 44.94,36 44.94,28.28 46.18,27.04 46.51,27.04 46.99,26.56 46.99,26.2 v2(47.09,26.09) ; v2(156.82,43.37) 156.82,43.38 156.82,44.21 157.24,44.64 159.48,44.64 159.79,44.33 160.48,44.33 U2000.C38
SATA_TXP2: length 130.9
  IN4 w0.089: v2(158.17,43.69) 158.17,43.42 158.22,43.38 158.47,43.38 158.52,43.32 158.52,43.22 158.4,43.1 157.48,43.1 157.03,42.64 157.03,42.01 156.01,40.99 149.51,40.99 148.92,40.4 144.77,40.4 144.54,40.18 139.77,40.18 137.16,42.79 129.81,42.79 129,43.59 123.63,43.59 123.49,43.59 122.83,42.94 114.13,42.94 113.99,42.8 113.94,42.75 100.12,42.75 98.28,44.6 74.02,44.6 72.9,43.48 67.71,43.48 67.07,44.12 58.96,44.12 57.51,42.66 45.29,42.66 44.5,43.45 43.49,43.45 v2(42.81,42.77)
  BOTTOM w0.114: C5100.1 43,46.75 43,46.81 43.09,46.9 43.67,46.9 44,46.57 44,45.15 43.21,44.36 43.21,43.17 v2(42.81,42.77) ; U2000.A39 159.53,44.06 159.18,44.42 158.63,44.42 158.35,44.14 158.35,43.87 v2(158.17,43.69)
SATA_TXP2_C: length 19.5
  BOTTOM w0.114: C5100.2 43.06,45.16 43.06,44.92 42.26,44.13 42.26,42.19 42.95,41.5 42.95,39.42 44.08,38.28 44.08,36.02 44.45,35.66 44.45,31.82 41.93,29.31 41.82,29.31 41.65,29.15 CON5100.19
SATA_TXP3: length 141.8
  TOP w0.114: 29.29,38 28.77,38 28.08,38.7 27.15,38.7 27.06,38.78 27.06,38.97 C5140.1 ; 29.29,38 v1(29.29,38.23) ; 29.29,38 29.46,38.17 34.52,38.17 34.62,38.27 34.62,38.55 v2(34.51,38.67)
  IN4 w0.089: v2(157.73,42.39) 157.91,42.22 157.91,41.94 156.27,40.3 149.88,40.3 149.32,39.73 145.08,39.73 144.86,39.51 139.25,39.51 137.44,41.32 134.09,41.32 133.3,42.11 127.51,42.11 126.71,42.91 123.99,42.91 123.84,42.91 123.22,42.29 114.46,42.29 114.28,42.11 111.54,42.11 111.46,42.03 98.45,42.03 96.55,43.93 96.4,43.93 96.4,43.93 74.62,43.93 73.46,42.77 58.77,42.77 58,42 42.6,42 40.82,40.23 35.69,40.23 34.67,39.21 34.67,38.83 v2(34.51,38.67)
  BOTTOM w0.089: v2(157.73,42.39) 157.97,42.63 157.97,42.89 158.33,43.25 159.16,43.25 159.26,43.35 159.65,43.35 159.79,43.5 U2000.A40
SATA_TXP3_C: length 9.5
  TOP w0.114: v1(25.73,40.81) 25.5,40.81 ; 25.5,40.81 25.5,41.03 25.21,41.32 24.52,41.32 24.23,41.03 24.23,40.25 22.53,38.55 21.89,38.55 CON5101.S2 ; 25.5,40.81 25.5,39.64 25.1,39.24 25.1,39.01 25.25,38.86 25.51,38.86 C5140.2
SATA_TXP4_C: length 17.6
  TOP w0.114: C5124.2 47.31,27.93 47.31,27.93 47.36,27.99 47.36,29.32 v2(47.14,29.53)
  BOTTOM w0.114: CON5103.49 47.88,40.35 48.82,40.35 48.88,40.41 48.88,40.56 48.94,40.62 49.89,40.62 50.45,40.05 50.45,32.39 49.15,31.09 48.21,31.09 47.52,30.39 47.52,29.91 v2(47.14,29.53)
SBU1: length 35.8
  TOP w0.102: v2(263.18,26.69) 263.75,26.69 263.86,26.8 CON1201.A8 ; R1219.2 250.1,48.95 250.57,48.95 v2(251.05,48.47)
  IN4 w0.102: v2(256.08,30.57) 255.96,30.7 255.96,35.05 253.45,37.55 253.45,46.78 252.08,48.15 251.37,48.15 v2(251.05,48.47) ; v2(263.18,26.69) 262.55,26.69 260.44,28.8 259.77,28.8 v2(259.26,28.29)
  BOTTOM w0.102: v2(256.08,30.57) 255.7,30.19 255.7,29.3 256.17,28.83 U1207.2 258.74,28.83 v1(258.78,28.8) 259.26,28.31 v2(259.26,28.29)
SBU2: length 49.9
  TOP w0.102: v1(257.96,27.4) 257.96,28.14 258.14,28.31 v2(258.14,28.39) ; R1220.2 249.46,48.7 250.45,48.7 250.64,48.51 250.64,48.29 251.06,47.87 251.38,47.87 v2(251.52,47.73)
  IN1 w0.102: v2(258.14,28.39) 258.14,28.31 260.26,30.43 260.26,32.59 260.98,33.31 266.68,33.31 269.16,30.83 269.16,26.45 arc(269.12,26.21) 268.98,26.01 268.22,25.25 CON1201.B8
  IN4 w0.102: v2(251.52,47.73) 252.19,47.73 253.23,46.68 253.23,37.47 255.58,35.12 255.58,30.7 v2(255.45,30.57)
  BOTTOM w0.102: v2(255.45,30.57) 255.45,29.05 256.06,28.43 U1207.8 258.1,28.43 v2(258.14,28.39)
SCLK: length 6.1
  BOTTOM w0.102: v1(10.31,185.23) 11.36,184.17 11.36,183.33 11.45,183.25 11.45,182.61 11.95,182.11 R8012.1 11.47,181.61 U8000.45
SDA: length 2.8
  TOP w0.102: v2(10.31,181.14) 9.73,180.56 v1(9.64,180.56)
  BOTTOM w0.102: R8014.1 10.31,181.54 v2(10.31,181.14) 10.31,180.91 10.66,180.55 U8000.43
SDATA_IN_R: length 8.5
  TOP w0.114: R3613.2 28.75,69.31 28.27,69.79 v1(27.89,69.79) 27.89,70.25 27.17,70.97 23.97,70.97 23.09,70.09 22.66,70.09 22.65,70.11 U3600.8
SLP_S5#: length 78
  TOP w0.102: R2440.2 186.61,64.15 185.74,65.03 183.91,65.03 183.67,65.26 183.67,66.3 184.47,67.1 184.47,67.8 185.29,68.62 185.84,68.62 186.36,69.15 186.36,70.55 186.06,70.86 185.67,70.86 185.37,71.16 185.37,71.43 185.1,71.7 185.1,72.11 184.24,72.97 183.57,72.97 183.44,73.09 183.44,73.86 183.59,74.01 185.34,74.01 185.73,73.63 186.89,73.63 v1(187.22,73.96) 187.85,74.59 187.93,74.59 v2(188.4,75.07) ; Q5301.1 235.19,84.48 234.49,83.79 v2(234.49,83.41)
  IN1 w0.102: v2(188.4,75.07) 188.79,75.46 212.24,75.46 215.95,79.16 221.16,79.16 222.28,78.04 233.78,78.04 234.75,79.01 234.75,82.64 234.49,82.9 v2(234.49,83.41)
SLP_WLAN#: length 79
  TOP w0.102: v2(185.61,69.03) 184.9,69.03 v1(184.28,68.42) 184.26,68.4 184.26,67.18 183.45,66.37 183.45,65.12 183.46,65.12 183.76,64.82 184.33,64.82 184.49,64.66 184.49,64.1 184.07,63.68 R2441.2 ; Q5302.1 234.81,81.05 234.24,81.63 v2(234.24,82.39)
  IN1 w0.102: v2(185.61,69.03) 185.61,69.04 185.98,69.42 188.75,69.42 189.15,69.82 189.93,69.82 190.81,68.94 194.47,68.94 194.73,68.68 194.88,68.68 198.69,64.86 v2(199.49,64.86)
  IN4 w0.102: v2(234.24,82.39) 233.99,82.39 233.46,81.87 224.83,81.87 224.15,81.19 222.73,81.19 219.7,78.16 215.81,78.16 215.33,77.68 213.88,77.68 213.36,77.16 213.36,66.89 213.79,66.46 213.79,64.34 213.23,63.77 201.55,63.77 200.46,64.86 v2(199.49,64.86)
SM_RCOMP0: length 11.9
  BOTTOM w0.152: R0504.2 67.18,122.62 67.57,122.23 68.98,122.23 v1(69.16,122.04)
  BOTTOM w0.254: U0300.G1 58.63,125.03 60.13,123.54 64.57,123.54 65.43,122.67 R0504.2
SM_RCOMP1: length 13.5
  BOTTOM w0.254: R0506.2 66.09,120.89 65.37,121.61 61.06,121.61 60.61,121.16 v1(58.65,121.16) 58.38,121.43 58.38,122.34 58.65,122.61 58.65,123.69 57.77,124.57 U0300.H1
SM_RCOMP2: length 18.2
  BOTTOM w0.254: U0300.J2 57.35,125.61 57.35,124.31 58.17,123.47 58.17,122.91 57.75,122.49 57.75,121.08 58.38,120.45 60.41,120.45 61.21,121.25 65.23,121.25 66.47,120 R0507.1 67.18,118.26 v1(67.68,117.76)
SMB0_CLK: length 135.3
  TOP w0.114: SR8802.1 213.85,27.05 v1(212.19,27.05) 208.99,27.05 208.54,27.5 v2(208.54,27.67) ; v2(132.96,34) 132.49,34 132.15,34.34 132.15,35.05 R3071.2 131.41,35.79 130.77,35.79 R3032.2
  IN2 w0.114: v2(208.54,27.67) 208.13,28.09 208.13,28.48 208.64,29 211.69,29 213.43,30.74 215.28,30.74 216.26,31.71 v2(216.69,31.71)
  IN4 w0.076: v2(208.54,27.67) 208.08,28.13 208.08,28.91 207.05,29.94 206.55,29.94 206.35,29.74 205.55,29.74 202.81,32.48 201.98,32.48 201.68,32.18 199.63,32.18 199.19,32.62 196.94,32.62 194.64,30.32 191.75,30.32 190.9,29.47 175.77,29.47 175.19,28.89 171.78,28.89 171.09,29.58 169.45,29.58 169.22,29.81 166.33,29.81 165.86,29.34 161.3,29.34 158.78,31.87 147.63,31.87 147.15,32.35 146.58,32.35 145.74,31.51 136.63,31.51 134.84,33.3 133.66,33.3 v2(132.96,34)
  BOTTOM w0.114: R6003.2 236.35,25.99 236.28,26.07 D6002.1 235.2,26.38 231.26,26.38 229.69,24.81 229.69,23.59 D6005.3 229.31,22.29 227.98,20.96 221.6,20.96 217.89,24.67 217.89,29.99 216.94,30.93 216.94,31.46 v2(216.69,31.71)
SMB0_DAT: length 134.7
  TOP w0.114: R3033.2 131.24,36.39 131.3,36.34 R3070.2 132.29,35.87 133.44,35.87 v1(133.78,35.53) 133.57,35.31 v2(133.57,34) ; v2(208.54,28.31) 209.32,27.53 214.01,27.53 SR8801.1
  IN2 w0.114: v2(217.58,31.03) 217.58,31.03 216.92,30.37 213.58,30.37 211.83,28.62 208.84,28.62 v2(208.54,28.31)
  IN4 w0.076: v2(208.54,28.31) 208.54,28.91 207.18,30.27 206.24,30.27 206.16,30.18 205.62,30.18 202.93,32.86 201.85,32.86 201.54,32.54 199.82,32.54 199.42,32.95 196.79,32.95 194.49,30.65 191.61,30.65 190.76,29.8 175.64,29.8 175.05,29.22 171.92,29.22 171.23,29.91 169.63,29.91 169.39,30.14 166.19,30.14 165.72,29.67 163.13,29.67 162,30.8 161.41,30.8 159.37,32.84 150.31,32.84 149.66,32.2 147.77,32.2 147.28,32.68 146.44,32.68 145.6,31.84 136.76,31.84 134.98,33.63 133.94,33.63 v2(133.57,34)
  BOTTOM w0.114: v2(217.58,31.03) 217.58,31.03 218.28,30.33 218.28,24.88 221.68,21.48 227.9,21.48 228.41,21.98 228.41,23.64 229.31,24.55 D6006.3 229.64,26.84 235.14,26.84 D6003.1 236.11,27.21 236.15,27.26 R6004.2
SMB1_CLK: length 601.3
  TOP w0.114: R3138.2 146.53,26.56 147.61,27.64 147.61,32.08 148.26,32.73 v2(148.26,32.92) ; v2(43.23,109.21) 43,108.98 43,108.32 43.17,108.15 43.17,104.18 v1(42.93,103.93) 43.17,103.68 43.17,102.14 30.05,89.02 30.05,76.9 29.07,75.93 29.07,72.63 30.65,71.05 30.65,64.68 28.88,62.91 28.88,60.78 32.79,56.87 32.79,55.33 33.36,54.76 48.81,54.76 51.77,51.8 72.34,51.8 83.6,40.55 v2(91.31,40.55) ; v2(134.24,38.06) 133.83,37.65 133.08,37.65 132.18,38.55 130.98,38.55 R3034.1 ; Q1202.2 218.62,63.74 215.43,63.74 v2(214.41,62.72) ; v2(23.14,96.89) 21.28,95.03 20,95.03 14.61,89.64 6.42,89.64 v2(6.4,89.63) ; R5803.1 245.87,125.34 248.34,122.88 249.1,122.88 249.7,122.28 v2(249.7,121.76) ; U5000.8 176.6,76.89 177.52,75.96 R5001.2 177.93,76.27 178.62,76.96 180.05,76.96 181.46,78.37 181.46,79.03 182,79.57 182,80.01 183.21,81.22 v2(183.21,82.05)
  IN1 w0.076: v2(91.31,40.55) 92.09,41.33 96.39,41.33 96.97,40.75 111.43,40.75 111.61,40.57 112.44,40.57 113.38,39.63 114.84,39.63 115.43,39.03 133.27,39.03 v2(134.24,38.06)
  IN2 w0.114: v2(214.41,62.72) 214.25,62.72 210.42,66.54 210.42,73.74 202.79,81.38 190.19,81.38 189.6,81.97 185.81,81.97 185.73,82.05 v2(183.21,82.05) ; v2(43.23,109.21) 41.64,109.21 41.1,108.67 36.27,108.67 33.45,105.86 28.51,105.86 22,99.34 22,97.38 22.48,96.89 v2(23.14,96.89)
  IN3 w0.114: v2(249.7,121.76) 249.51,121.57 244.51,121.57 232.55,109.61 232.55,101.99 233.45,101.09 233.45,99.13 235.18,97.4 235.18,95.57 235.11,95.5 235.11,93.19 236.7,91.6 236.7,88.01 234.8,86.1 223.08,86.1 221.08,84.1 221.08,83.17 221.55,82.71 221.55,80.24 218.76,77.45 218.76,76.95 215.7,73.89 215.19,73.89 214.51,73.22 214.51,66.45 214.99,65.97 214.99,64.59 213.9,63.5 213.9,62.95 214.13,62.72 v2(214.41,62.72) 215,62.13 215,58.62 216.42,57.2 216.42,50.62 216.2,50.4 216.2,49.43 217.01,48.62 218.42,48.62 218.75,48.29 218.75,41.73 218.1,41.08 218.1,39.35 218.51,38.94 218.51,38.24 218.11,37.84 218.11,37.16 217.56,36.6 210.5,36.6 209.96,36.06 209.96,35.64 206.65,32.34 206.65,32.27 v2(205.74,31.35)
  IN4 w0.076: v2(134.16,34.64) 134.9,34.64 136.71,32.84 137.04,32.5 139.81,32.5 140.57,33.27 144.81,33.27 145.24,33.7 147.49,33.7 v2(148.26,32.92) 148.95,33.62 159.57,33.62 161.72,31.46 163.5,31.46 163.68,31.29 163.68,31.27 164.61,30.33 165.45,30.33 166.06,30.94 169.74,30.94 170.02,30.66 190.56,30.66 191.21,31.31 194.22,31.31 196.52,33.62 199.97,33.62 200.36,33.22 201.14,33.22 201.83,33.91 205.09,33.91 205.92,33.09 205.92,31.53 v2(205.74,31.35)
  BOTTOM w0.114: v2(6.4,89.63) 5.79,89.63 4.67,88.51 4.67,84.27 5.84,83.1 5.84,82.28 5.05,81.5 5.05,80.44 3.25,78.64 3.25,64.69 4.78,63.16 6.01,63.16 6.33,63.47 6.33,67.58 6.99,68.25 CON6700.14 ; 65.86,111.42 45.75,111.42 43.54,109.21 v2(43.23,109.21) ; 65.86,111.42 70.33,111.42 71.1,110.64 71.34,110.41 78.35,110.41 80.94,113 80.94,115.45 81.29,115.8 81.29,117.67 81.46,117.84 Q7401.3 ; 65.86,111.42 v1(65.86,111.68) ; v2(134.24,38.06) 134.24,34.71 v2(134.16,34.64)
