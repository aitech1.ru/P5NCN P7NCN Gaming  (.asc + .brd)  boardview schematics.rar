# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_D55: length 32.5
  TOP w0.133: v6(149.25,145.95) U7801.M11 149.64,144.67 v1(149.4,144.43)
  IN4 w0.095: v6(149.25,145.95) 149.65,145.54 149.65,143.42 149.43,143.19 149.09,143.19 148.7,142.8 147.15,142.8 146.25,141.91 139.36,141.91 134.97,137.52 128.58,137.52 127.73,136.67 126.69,136.67 v6(125.88,137.48)
  BOTTOM w0.133: U7801.M11 v6(149.25,145.95) ; U7000.E20 v6(125.88,137.48)
FBC_D56: length 39.1
  TOP w0.133: v1(154.79,151.76) 154.79,151.52 v6(154.03,150.76)
  IN1 w0.095: v6(154.03,150.76) 154.03,149.89 151.99,147.85 150.63,147.85 150.34,147.56 147.27,147.56 146.83,147.13 141.11,147.13 136.02,142.04 134.29,142.04 132.44,140.19 132.44,139.52 131.78,138.86 130,138.86 128.56,137.42 128.01,137.42 127.47,136.87 125.58,136.87 125.35,137.1 124.71,137.1 v6(124.31,137.5)
  BOTTOM w0.133: v6(154.03,150.76) U7801.U4 ; U7000.G20 v6(124.31,137.5)
FBC_D57: length 39.7
  TOP w0.133: v6(153.26,152.37) 153.85,152.95 v1(153.85,153.51)
  IN1 w0.095: v6(153.26,152.37) 152.84,151.94 152.84,150.64 152.47,150.27 152.31,150.27 152.12,150.08 152.12,149.73 151.06,148.66 150.55,148.66 150.02,148.13 147.03,148.13 146.59,147.7 140.67,147.7 135.65,142.68 134.13,142.68 131.87,140.43 131.87,139.85 131.49,139.46 129.92,139.46 128.35,137.89 123.89,137.89 v6(123.48,137.48)
  BOTTOM w0.133: U7000.H20 v6(123.48,137.48) ; U7801.U2 v6(153.26,152.37)
FBC_D58: length 37.3
  TOP w0.133: v1(154.2,150.11) 153.97,150.11 v6(153.32,150.76)
  IN1 w0.095: v6(125.08,137.48) 125.35,137.48 125.73,137.1 127.43,137.1 128.04,137.71 128.43,137.71 129.9,139.18 131.66,139.18 132.16,139.67 132.16,140.31 134.24,142.39 135.77,142.39 140.79,147.41 146.71,147.41 147.15,147.85 150.2,147.85 150.57,148.22 151.71,148.22 152.93,149.44 152.93,150.19 153.32,150.58 v6(153.32,150.76)
  BOTTOM w0.133: U7000.F20 v6(125.08,137.48) ; U7801.T4 152.98,151.02 153.06,151.02 v6(153.32,150.76)
FBC_D59: length 35.9
  TOP w0.133: v1(150.01,151.71) v6(150.01,152.32)
  IN1 w0.095: v6(150.01,152.32) 149.89,152.2 149.89,151.21 149.24,150.56 147.57,150.56 147.09,150.07 146.74,150.07 145.94,149.27 139.94,149.27 136.44,145.77 135.77,145.77 134.72,144.72 134.72,144.49 134.49,144.25 133.43,144.25 131.12,141.94 128.16,141.94 127.97,141.74 127.97,141.27 126.63,139.94 124.35,139.94 v6(122.71,138.29)
  BOTTOM w0.133: U7801.N2 v6(150.01,152.32) ; v6(122.71,138.29) U7000.H21
FBC_D60: length 34.2
  TOP w0.133: v6(150.83,150.71) 150.5,150.39 v1(150.06,150.39)
  IN1 w0.095: v6(150.83,150.71) 150.83,149.67 150.59,149.43 150.09,149.43 149.36,148.71 146.79,148.71 146.36,148.27 140.36,148.27 135.34,143.25 133.84,143.25 131.51,140.92 130.24,140.92 129.98,140.66 128.4,140.66 127.25,139.51 124.8,139.51 v6(124.29,139)
  BOTTOM w0.133: U7801.N4 150.44,151.15 150.65,150.94 150.65,150.89 v6(150.83,150.71) ; v6(124.29,139) 124.53,139.23 124.53,139.33 U7000.F23
FBC_D61: length 38.9
  TOP w0.133: v1(152.07,153.66) 152.07,152.7 v6(152.43,152.34)
  IN1 w0.095: v6(152.43,152.34) 152.04,151.95 152.04,151.44 151.79,151.19 151.47,151.19 151.23,150.95 151.23,149.68 150.65,149.09 150.27,149.09 149.6,148.42 146.91,148.42 146.48,147.98 140.55,147.98 135.53,142.96 134.01,142.96 131.63,140.59 130.39,140.59 130.11,140.3 128.52,140.3 127.93,139.71 127.93,138.92 127.71,138.7 124.56,138.7 v6(124.27,138.4)
  BOTTOM w0.133: U7000.G23 123.74,139.34 123.74,138.93 v6(124.27,138.4) ; U7801.T2 v6(152.43,152.34)
FBC_D62: length 33.7
  TOP w0.133: v1(148.44,150.92) 148.59,150.92 v6(149.23,151.55)
  IN1 w0.095: v6(149.23,151.55) 148.8,151.13 145.44,151.13 144.66,150.35 140.37,150.35 140.01,149.99 139.13,149.99 135.87,146.73 134.68,146.73 130.59,142.63 129.06,142.63 128.85,142.84 126.89,142.84 126.43,142.38 125.19,142.38 124.7,141.89 124.7,141.31 124.49,141.09 123.9,141.09 v6(123.51,140.7)
  BOTTOM w0.133: v6(149.23,151.55) 149.43,151.35 149.45,151.35 U7801.M4 ; U7000.H23 123.51,139.91 v6(123.51,140.7)
FBC_D63: length 38.5
  TOP w0.133: v6(149.21,152.31) 149.66,152.76 149.66,153.36 149.28,153.74 v1(148.87,153.74)
  IN1 w0.095: v6(121.88,140.67) 122.43,140.12 125,140.12 125.45,140.57 125.45,141.33 125.47,141.35 125.47,141.66 125.47,141.66 125.74,141.93 127.71,141.93 128.08,142.3 130.98,142.3 134.79,146.1 136.33,146.1 139.79,149.56 145.5,149.56 146.3,150.36 146.97,150.36 147.45,150.84 149.09,150.84 149.6,151.35 149.6,151.92 v6(149.21,152.31)
  BOTTOM w0.133: U7801.M2 v6(149.21,152.31) ; U7000.K23 121.88,139.88 v6(121.88,140.67)
FBC_DEBUG0: length 7.9
  TOP w0.102: v1(131.85,126.45) 131.85,125.93 v2(131.95,125.82) 132.28,125.49 R7120.1
  BOTTOM w0.102: U7000.C9 127.53,127.87 130.36,127.87 131.95,126.28 v2(131.95,125.82)
FBC_DEBUG1: length 6.5
  BOTTOM w0.102: R7121.1 132.31,142.38 132.03,142.11 v1(131.85,142.11) 131.27,142.11 129.83,140.66 127.46,140.66 U7000.C24
FBC_DQM0: length 30.3
  TOP w0.133: v1(125.9,124.81) v6(125.9,125.5)
  IN4 w0.095: v6(125.9,125.5) 125.92,125.5 126.31,125.11 127.8,125.11 128.35,124.57 128.66,124.57 130.08,123.15 138.3,123.15 139.52,121.93 145.7,121.93 146.43,121.2 148.44,121.2 149.02,120.63 149.33,120.63 149.63,120.33 149.63,119.17 150.23,118.56 v6(150.85,118.56)
  BOTTOM w0.133: U7000.E6 v6(125.9,125.5) ; U7800.D2 v6(150.85,118.56)
FBC_DQM1: length 35.9
  TOP w0.133: v6(151.68,127.37) 152.24,126.81 v1(152.24,126.23)
  IN1 w0.095: v6(151.68,127.37) 152.36,126.69 152.36,124.12 150.63,122.39 145.89,122.39 145.09,123.19 137.34,123.19 132.96,127.57 130.89,127.57 130.41,128.05 126.54,128.05 v6(125.9,128.69)
  BOTTOM w0.133: U7000.E9 125.5,128.3 v6(125.9,128.69) ; v6(151.68,127.37) 151.49,127.19 151.46,127.19 U7800.D13
FBC_DQM2: length 26.6
  TOP w0.133: v1(123.24,135.17) 123.24,134.84 v6(122.7,134.3)
  IN4 w0.095: v6(143.61,127.34) 142.82,128.13 142.82,128.57 141.06,130.33 132.55,130.33 130.23,132.65 124.29,132.65 123.84,133.1 123.84,133.67 123.59,133.92 123.09,133.92 v6(122.7,134.3)
  BOTTOM w0.133: U7000.H17 v6(122.7,134.3) ; U7800.P13 v6(143.61,127.34)
FBC_DQM3: length 27
  TOP w0.133: v6(126.7,131.1) v1(127.48,131.1)
  IN2 w0.146: v6(126.7,131.1) 126.94,131.1 127.77,130.28 128.43,130.28 128.75,129.95 129.14,129.95 129.61,129.48 129.61,129.48 129.83,129.25 132.08,129.25 135.2,126.13 135.2,124.32 136.07,123.46 136.07,121.12 139.88,117.31 142.14,117.31 142.44,117.61 142.44,118.12 v6(142.88,118.56)
  BOTTOM w0.133: v6(142.88,118.56) 143.12,118.31 143.12,118.29 U7800.P2 ; v6(126.7,131.1) 126.3,130.7 U7000.D12
FBC_DQM4: length 29.6
  TOP w0.133: v1(122.53,142.33) 121.95,142.33 v6(121.92,142.31)
  IN4 w0.095: v6(121.92,142.31) 122.34,142.72 122.86,142.72 123.12,142.98 123.12,143.28 123.31,143.48 123.62,143.48 123.85,143.71 123.85,144.2 124.38,144.73 128.11,144.73 128.42,144.42 130.59,144.42 139.67,153.5 143.01,153.5 143.26,153.25 143.26,152.8 v6(143.66,152.39)
  BOTTOM w0.133: v6(143.66,152.39) 143.45,152.6 143.39,152.6 U7801.D2 ; v6(121.92,142.31) 121.68,142.55 121.66,142.55 U7000.K27
FBC_DQM5: length 23.5
  TOP w0.133: v1(143.59,144.57) 143.59,143.61 v6(143.61,143.58)
  IN2 w0.089: 129.06,137.89 129.06,137.89 125.51,137.89 v6(125.11,138.29)
  IN2 w0.146: 129.06,137.89 129.41,138.25 136.51,138.25 140.16,141.91 142.06,141.91 142.5,142.35 142.5,143.05 143.03,143.58 v6(143.61,143.58)
  BOTTOM w0.133: v6(125.11,138.29) 125.5,137.9 U7000.E21 ; U7801.D13 v6(143.61,143.58)
FBC_DQM6: length 34.9
  TOP w0.133: v6(151.64,143.56) 152.01,143.18 152.16,143.18 v1(152.43,142.92)
  IN4 w0.095: v6(151.64,143.56) 151.99,143.2 151.99,142.31 150.37,140.68 150.37,140.38 149.24,139.25 139.24,139.25 135.53,135.54 128.99,135.54 128.88,135.43 127.51,135.43 127.15,135.07 125.01,135.07 v6(124.24,134.3)
  BOTTOM w0.133: v6(151.64,143.56) 151.25,143.95 U7801.P13 ; v6(124.24,134.3) 124.44,134.5 124.5,134.5 U7000.F17
FBC_DQM7: length 37
  TOP w0.133: v6(122.72,140.74) 123.11,140.35 v1(123.11,140.18)
  IN1 w0.095: v6(122.72,140.74) 123.09,141.12 123.09,141.97 123.81,142.69 126.16,142.69 126.61,143.14 128.94,143.14 129.27,142.82 130.37,142.82 134.63,147.08 135.81,147.08 139,150.28 139.88,150.28 140.75,151.16 144.7,151.16 144.81,151.27 144.81,151.83 145.48,152.5 148.14,152.5 148.36,152.72 150.55,152.72 v6(150.85,152.41)
  BOTTOM w0.133: U7801.P2 151.09,152.59 151.03,152.59 v6(150.85,152.41) ; v6(122.72,140.74) 122.72,139.91 122.3,139.49 U7000.J23
FBC_DQS_WP0: length 31.2
  TOP w0.133: v1(151.99,117.95) 151.99,118.22 v6(151.66,118.56)
  IN4 w0.095: v6(126.7,125.5) 126.71,125.5 127.2,126 127.71,126 128.35,125.36 128.89,125.36 129.9,124.35 138.21,124.35 139.84,122.72 146.03,122.72 146.76,121.99 150.13,121.99 150.95,121.17 150.95,120.9 151.23,120.62 151.23,118.98 v6(151.66,118.56)
  BOTTOM w0.133: U7000.D6 v6(126.7,125.5) ; U7800.C2 v6(151.66,118.56)
FBC_DQS_WP1: length 33
  TOP w0.133: v1(124.3,130.2) v6(124.3,129.5)
  IN1 w0.095: v6(124.3,129.5) 124.91,130.11 133.69,130.11 137.65,126.15 146.2,126.15 146.44,125.92 146.44,125.45 146.66,125.22 147.82,125.22 148.35,125.76 148.35,126.32 149.13,127.09 150.32,127.09 150.37,127.04 151.16,127.04 v6(151.61,126.58)
  BOTTOM w0.133: U7800.C13 151.82,126.75 151.78,126.75 v6(151.61,126.58) ; U7000.F11 v6(124.3,129.5)
FBC_DQS_WP2: length 24.5
  TOP w0.133: v6(123.46,133.48) 123.36,133.48 v1(122.66,132.78)
  IN4 w0.095: v6(142.82,127.35) 142.06,128.11 142.06,128.43 140.66,129.83 132.26,129.83 129.63,132.47 124.02,132.47 123.46,133.03 v6(123.46,133.48)
  BOTTOM w0.133: U7800.R13 v6(142.82,127.35) ; U7000.H15 123.46,133.46 v6(123.46,133.48)
FBC_DQS_WP3: length 25.7
  TOP w0.133: v6(126.71,131.9) 127.1,132.3 v1(127.1,132.86)
  IN2 w0.089: v6(126.71,131.9) 126.97,131.9 127.76,131.11
  IN2 w0.146: 127.76,131.11 128.72,131.11 128.73,131.1 129.66,131.1 130.01,130.76 130.01,130.6 130.36,130.24 132.51,130.24 136.22,126.53 136.22,124.73 137.21,123.74 137.21,121.66 140.1,118.77 140.56,118.77 140.77,118.99 141.63,118.99 v6(142.06,118.56)
  BOTTOM w0.133: v6(126.71,131.9) 127.1,132.3 U7000.C14 ; U7800.R2 v6(142.06,118.56)
FBC_DQS_WP4: length 22.3
  TOP w0.133: v1(126.7,143.43) 126.37,143.1 v6(125.9,143.1)
  IN4 w0.095: v6(125.9,143.1) 126.4,143.6 129.77,143.6 130.04,143.33 131.01,143.33 134.79,147.1 136.13,147.1 140.93,151.9 141.52,151.9 v6(142.04,152.41)
  BOTTOM w0.133: U7801.C2 142.29,152.6 142.22,152.6 v6(142.04,152.41) ; v6(125.9,143.1) 125.5,142.7 U7000.E27
FBC_DQS_WP5: length 23.9
  TOP w0.133: v6(142.08,143.54) 142.47,143.15 v1(142.6,143.15)
  IN2 w0.089: 127.41,139.56 127.1,139.25 127.1,138.97 126.84,138.71 124.96,138.71 124.7,138.97 124.7,139.88 124.34,140.24 v6(124.34,140.7)
  IN2 w0.146: 127.41,139.56 128.89,139.56 129.04,139.41 130.05,139.41 131.04,140.4 136.33,140.4 139.92,143.99 140.32,143.99 140.36,144.03 141.58,144.03 v6(142.08,143.54)
  BOTTOM w0.133: v6(124.34,140.7) 124.52,140.52 124.52,140.49 U7000.F24 ; v6(142.08,143.54) 142.3,143.76 142.3,143.81 U7801.C13
FBC_DQS_WP6: length 35.6
  TOP w0.133: v6(151.64,144.36) 151.13,144.87 v1(151.12,144.87)
  IN4 w0.095: v6(123.56,135.96) 124.18,135.34 127.04,135.34 127.46,135.76 128.8,135.76 129.07,136.04 135.28,136.04 140.07,140.82 144.28,140.82 145.16,139.94 148.27,139.94 149.52,141.19 149.89,141.19 151.12,142.42 151.12,143.83 v6(151.64,144.36)
  BOTTOM w0.133: v6(151.64,144.36) 152.04,143.95 U7801.R13 ; U7000.H18 v6(123.56,135.96)
FBC_DQS_WP7: length 36.7
  TOP w0.133: v6(123.5,138.3) 123.5,138.77 v1(123.38,138.9)
  IN1 w0.095: v6(123.5,138.3) 123.5,138.76 124.49,139.74 127,139.74 128.24,140.98 129.69,140.98 130.14,141.43 131.31,141.43 133.63,143.75 135.13,143.75 140.15,148.77 146.15,148.77 146.6,149.22 149.11,149.22 150.08,150.2 150.08,150.69 150.49,151.09 150.49,151.83 150.62,151.96 151.25,151.96 v2(151.66,152.37)
  BOTTOM w0.133: U7801.R2 v2(151.66,152.37) ; U7000.G21 v6(123.5,138.3)
FBC_MF1: length 3.9
  TOP w0.254: v1(145.9,114.44) 145.9,115.54 R7815.2
  TOP w0.457: v2(147.19,116.65) R7816.1 R7815.2
  BOTTOM w0.305: v2(147.19,116.65) 147.19,116.73 147.24,116.78 U7800.J1
FBC_MF2: length 3.2
  TOP w0.203: v1(147.63,156.64) R7817.2 R7818.1 147.63,154.27 v6(147.42,154.07)
  BOTTOM w0.203: v6(147.42,154.07) 147.24,153.89 U7801.J1
FBC_VREF_CA1: length 31.8
  TOP w0.381: v2(146.97,140.69) 146.97,140.36 147.19,140.15 147.19,131.6 v1(147.84,130.95) 148.1,130.69 v2(148.1,129.89) ; v2(155.04,129.04) 154.89,129.19 151.6,129.19 151.34,128.92 v6(150.29,128.92)
  BOTTOM w0.305: U7800.J14 147.24,128.36 147.5,128.62 ; 147.24,142.1 U7801.J14
  BOTTOM w0.381: v2(146.97,140.69) 147.05,140.76 C7805.1 147.05,141.9 147.04,141.9 147.24,142.1 ; R7809.2 158.44,125.64 158.42,125.66 158.42,125.73 157.44,126.71 155.75,126.71 155.04,127.42 v2(155.04,129.04) ; v6(150.29,128.92) 150.29,129.91 149.83,130.37 R7810.1 R7811.2 148.64,130.37 148.16,129.89 v2(148.1,129.89) 147.92,129.89 147.88,129.85 147.84,129.85 C7803.1 147.5,128.62
FBC_VREF_DQ1: length 80.2
  TOP w0.381: v6(154.53,124.47) 155.4,125.34 155.4,128.62 155.59,128.81 155.59,129.26 155.18,129.67 151.39,129.67 151.19,129.46 148.58,129.46 148.37,129.26 146.87,129.26 ; v2(139.84,129.34) 140.28,129.78 144.81,129.78 145.33,129.26 146.87,129.26 ; 146.87,129.26 146.87,130.23 146.66,130.44 146.66,139.37 144.95,141.09 v1(143.59,141.09) 140.15,141.09 138.25,142.99 138.25,144.91 140.62,147.28 142.04,147.28 142.04,146.7 v6(142.03,146.69)
  IN4 w0.381: v6(142.03,146.69) 142.03,146.95 142.52,147.44 143.74,147.44 144.11,147.81 153.48,147.81 155.19,146.09 v2(155.19,145.68)
  BOTTOM w0.254: U7800.U10 139.99,125.43 139.99,125.98 140.13,126.13 140.13,129.05 v2(139.84,129.34)
  BOTTOM w0.305: U7800.A10 154.18,124.57 154.28,124.47 ; U7801.A10 141.28,146.78 141.95,146.78 v6(142.03,146.69) ; U7801.U10 153.94,146.64 154.87,146.64 155.19,146.32 v2(155.19,145.68)
  BOTTOM w0.381: 154.28,124.47 v6(154.53,124.47) 154.81,124.47 154.88,124.55 C7800.1 R7801.2 155.18,122.81 R7800.1 155.18,122.76 155.7,122.24 156.85,122.24 157.55,122.94 R7808.2
FBC_WCK01: length 31.2
  IN1 w0.102: v7(151.64,120.13) 151.06,120.71 145.63,120.71 144.55,121.78 136.43,121.78 134.81,123.4 133.68,123.4 131.77,125.31 131.75,125.31 131.58,125.48 130.68,125.48 129.59,126.57 126.07,126.57 125.1,127.54 v6(125.1,127.88)
  BOTTOM w0.133: v6(125.1,127.88) 124.88,127.66 124.86,127.66 U7000.F8 ; U7800.D4 151.24,120.02 151.36,120.13 v7(151.64,120.13)
FBC_WCK01#: length 31.1
  IN1 w0.102: v6(150.84,120.13) 150.84,120.4 150.72,120.52 145.55,120.52 144.48,121.59 136.35,121.59 134.73,123.2 133.6,123.2 131.69,125.12 131.67,125.12 131.51,125.29 130.6,125.29 129.51,126.37 125.99,126.37 124.45,127.92 v7(124.31,127.92)
  BOTTOM w0.133: v6(150.84,120.13) 151.07,120.37 151.07,120.4 U7800.D5 ; v7(124.31,127.92) 124.31,127.91 U7000.G8
FBC_WCK23: length 33
  IN1 w0.102: v7(143.64,120.13) 143.41,120.13 142.99,120.55 142.69,120.55 142.54,120.7 139.08,120.7 138.87,120.49 138.87,118.89 138.74,118.76 138.39,118.76 138.26,118.89 138.26,120.49 138.05,120.7 137.48,120.7 137.27,120.49 137.27,119.71 137.17,119.61 136.76,119.61 136.66,119.71 136.66,120.49 136.45,120.7 135.35,120.7 132.75,123.3 131.02,123.3 128.23,126.1 125.07,126.1 122.32,128.84 122.32,129.69 122.68,130.05 v6(122.68,130.28)
  BOTTOM w0.133: U7800.P4 143.61,120.13 v7(143.64,120.13) ; v6(122.68,130.28) U7000.H12
FBC_WCK23#: length 32.9
  IN1 w0.102: v6(142.84,120.13) 142.46,120.51 139.16,120.51 139.06,120.41 139.06,118.81 138.82,118.57 138.31,118.57 138.07,118.81 138.07,120.41 137.97,120.51 137.56,120.51 137.46,120.41 137.46,119.63 137.25,119.42 136.68,119.42 136.47,119.63 136.47,120.41 136.37,120.51 135.27,120.51 132.67,123.11 130.94,123.11 128.15,125.91 124.99,125.91 122.13,128.76 122.13,129.76 122.28,129.92 122.28,130.11 122.16,130.24 v7(121.84,130.24)
  BOTTOM w0.133: v7(121.84,130.24) 122.12,130.24 122.3,130.42 U7000.J12 ; U7800.P5 143.06,120.38 143.06,120.35 v6(142.84,120.13)
FBC_WCK45: length 33
  IN4 w0.102: v6(143.64,150.78) 143.64,150.56 143.05,149.97 143.05,149.22 142.84,149.01 141.25,149.01 137.61,145.37 137.61,145.07 137.97,144.71 137.97,144.56 137.68,144.28 137.54,144.28 137.18,144.63 136.88,144.63 136.32,144.07 136.32,143.77 136.68,143.41 136.68,143.27 136.39,142.98 136.24,142.98 135.89,143.34 135.48,143.34 135.24,143.1 135.24,142.33 134.97,142.06 134.75,142.06 133.95,142.86 133.61,142.86 133.2,142.45 133.2,142.12 134.19,141.13 134.19,140.98 133.9,140.69 133.76,140.69 133.06,141.39 132.05,141.39 131.83,141.18 131.83,140.67 131.73,140.57 131.33,140.57 131.23,140.67 131.23,141.18 131.01,141.39 130.27,141.39 130.06,141.18 130.06,140.65 129.84,140.44 129.06,140.44 128.96,140.54 128.96,140.8 128.75,141.01 128.18,141.01 127.97,140.8 127.97,140.54 127.87,140.44 126.77,140.44 126.42,140.79 126.42,141.25 v7(126.68,141.51)
  BOTTOM w0.133: v7(126.68,141.51) 126.44,141.74 126.44,141.76 U7000.D26 ; U7801.D4 143.24,151.15 143.44,150.95 143.47,150.95 v6(143.64,150.78)
FBC_WCK45#: length 33.1
  IN4 w0.102: v6(125.91,141.49) 126.23,141.17 126.23,140.71 126.69,140.25 127.95,140.25 128.16,140.46 128.16,140.72 128.26,140.82 128.67,140.82 128.77,140.72 128.77,140.46 128.98,140.25 129.92,140.25 130.25,140.57 130.25,141.1 130.35,141.2 130.93,141.2 131.03,141.1 131.03,140.59 131.25,140.38 131.81,140.38 132.03,140.59 132.03,141.1 132.13,141.2 132.98,141.2 133.68,140.5 133.98,140.5 134.38,140.9 134.38,141.2 133.39,142.2 133.39,142.37 133.69,142.67 133.87,142.67 134.67,141.87 135.05,141.87 135.43,142.25 135.43,143.02 135.56,143.15 135.81,143.15 136.17,142.79 136.47,142.79 136.87,143.19 136.87,143.49 136.51,143.85 136.51,144 136.96,144.44 137.1,144.44 137.46,144.09 137.76,144.09 138.16,144.48 138.16,144.79 137.8,145.14 137.8,145.29 141.33,148.82 142.92,148.82 143.24,149.14 143.24,149.86 143.33,149.95 v6(143.64,149.95)
  BOTTOM w0.133: v6(143.64,149.95) 143.36,149.95 143.24,150.06 U7801.D5 ; U7000.E26 v6(125.91,141.49)
FBC_WCK67: length 39
  IN4 w0.102: v6(122.73,137.53) 122.33,137.93 122.33,138.47 122.93,139.07 123.23,139.07 123.75,139.59 128.32,139.59 128.8,139.11 133.78,139.11 139.1,144.44 139.1,145.2 139.89,145.98 139.89,146 141.97,148.08 143.44,148.08 144,148.64 151.47,148.64 152.1,149.27 152.1,150.3 v7(151.64,150.75)
  BOTTOM w0.133: v7(151.64,150.75) 151.24,151.15 U7801.P4 ; v6(122.73,137.53) U7000.J20
FBC_WCK67#: length 39
  IN4 w0.102: v6(151.61,149.98) 151.88,149.71 151.88,149.32 151.39,148.83 143.92,148.83 143.36,148.27 141.89,148.27 139.7,146.08 139.7,146.06 138.91,145.28 138.91,144.52 133.7,139.3 128.88,139.3 128.4,139.78 123.67,139.78 123.15,139.27 122.85,139.27 121.91,138.32 v7(121.89,138.32)
  BOTTOM w0.133: U7000.K20 121.5,137.11 121.89,137.5 v7(121.89,138.32) ; v6(151.61,149.98) 151.35,149.71 151.05,149.71 150.92,149.84 150.92,150.03 U7801.P5
FBC_ZQ0: length 4.5
  BOTTOM w0.203: v1(145.21,130.27) 145.98,129.5 R7812.2 146.86,129.25 146.86,127.35 U7800.J13
FBC_ZQ1: length 5.5
  BOTTOM w0.152: v1(144.03,140.32) 144.54,140.84 144.54,140.95 144.93,141.34 R7813.2
  BOTTOM w0.203: U7801.J13 146.86,143.57 146.86,142.83 146.88,142.82 146.88,142.46 146.44,142.02 145.75,142.02 R7813.2
FBD_CLK0: length 34.8
  TOP w0.133: R7903.1 122.68,106.69 122.56,106.69 v6(122.33,106.92)
  IN1 w0.102: v6(114.7,127.9) 115,128.2 115.26,128.2 115.35,128.1 115.35,122.53 115.67,122.22 116.18,122.22 116.5,122.54 116.91,122.54 117.23,122.21 117.23,118.71 120.89,115.05 120.89,114.18 121.18,113.89 122.15,113.89 122.88,113.16 123.56,113.16 123.65,113.07 123.65,112.56 123.86,112.35 124,112.35 124.13,112.22 124.13,111.86 124,111.74 123.86,111.74 123.65,111.52 123.65,110.86 123.86,110.64 124.02,110.64 124.12,110.54 124.12,110.14 124.02,110.04 123.86,110.04 123.65,109.82 123.65,109.25 123.94,108.96 123.94,108.63 122.97,107.67 122.97,107.33 123.21,107.09 124,107.09 124.13,106.96 124.13,106.62 123.98,106.47 122.47,106.47 122.33,106.61 v6(122.33,106.92)
  BOTTOM w0.133: U7900.J12 122.6,106.69 122.56,106.69 v6(122.33,106.92) ; U7000.V9 v6(114.7,127.9)
FBD_CLK0#: length 35
  TOP w0.133: R7903.2 122.76,106.37 122.66,106.37 v6(122.38,106.09)
  IN1 w0.102: v6(122.38,106.09) 122.57,106.28 124.06,106.28 124.32,106.54 124.32,107.04 124.08,107.28 123.29,107.28 123.16,107.41 123.16,107.59 124.13,108.55 124.13,109.03 123.84,109.33 123.84,109.74 123.94,109.84 124.1,109.84 124.31,110.06 124.31,110.62 124.1,110.84 123.94,110.84 123.84,110.94 123.84,111.44 123.94,111.55 124.08,111.55 124.32,111.78 124.32,112.3 124.08,112.54 123.94,112.54 123.84,112.64 123.84,113.15 123.64,113.35 122.96,113.35 122.23,114.08 121.26,114.08 121.08,114.26 121.08,115.13 117.42,118.79 117.42,122.29 116.99,122.73 116.42,122.73 116.1,122.41 115.75,122.41 115.54,122.61 115.54,128.18 115,128.73 v7(114.7,128.73)
  BOTTOM w0.133: U7000.V10 114.92,128.92 114.9,128.92 v7(114.7,128.73) ; U7900.J11 122.11,106.38 122.11,106.35 v6(122.38,106.09)
FBD_CLK1: length 34
  TOP w0.133: v7(128.88,106.16) 129.18,105.86 129.18,105.49 R7902.1
  IN1 w0.102: v6(117.13,125.53) 116.71,125.11 116.71,124.5 116.92,124.3 117.38,124.3 117.77,123.92 117.77,119.26 123.17,113.86 125.36,113.86 125.57,113.65 125.57,113.15 125.45,113.04 125.18,113.04 124.98,112.83 124.98,112.35 125.18,112.15 126.01,112.15 126.14,112.03 126.14,111.77 126.01,111.65 125.4,111.65 125.18,111.43 125.18,110.97 125.4,110.76 125.98,110.76 126.11,110.63 126.11,110.38 125.98,110.25 125.4,110.25 125.18,110.04 125.18,109.52 126.2,108.51 126.2,107.51 127.35,106.35 128.21,106.35 128.61,106.76 129.01,106.76 129.11,106.65 129.11,106.39 v7(128.88,106.16)
  BOTTOM w0.133: v6(117.13,125.53) 117.5,125.9 U7000.R6 ; U7901.J12 128.91,106.19 128.91,106.19 v7(128.88,106.16)
FBD_CLK1#: length 33.9
  TOP w0.133: v6(129.69,106.16) 129.44,105.91 129.44,105.44 R7902.2
  IN1 w0.102: v7(117.12,124.71) 117.24,124.71 117.96,124 117.96,119.34 123.24,114.05 125.44,114.05 125.76,113.73 125.76,113.07 125.53,112.84 125.26,112.84 125.17,112.75 125.17,112.43 125.26,112.34 126.09,112.34 126.33,112.11 126.33,111.69 126.09,111.45 125.48,111.45 125.37,111.35 125.37,111.05 125.48,110.95 126.06,110.95 126.3,110.71 126.3,110.3 126.06,110.06 125.48,110.06 125.37,109.96 125.37,109.6 126.39,108.59 126.39,107.59 127.43,106.55 128.13,106.55 128.53,106.95 129.09,106.95 129.3,106.73 129.3,106.56 v6(129.69,106.16)
  BOTTOM w0.133: v7(117.12,124.71) 117.44,124.71 117.48,124.68 117.7,124.68 117.73,124.66 117.83,124.66 117.96,124.78 117.96,124.97 117.83,125.1 U7000.R5 ; U7901.J11 130.09,106.29 129.97,106.16 v6(129.69,106.16)
FBD_CMD0: length 28.9
  TOP w0.133: v6(107.51,123.89) 107.87,123.54 110.16,123.54 110.77,122.92 110.77,122.52 119.61,113.68 119.61,106.7 118.48,105.58 116.88,105.58 v1(116.78,105.47) 116.63,105.32 v6(115.98,105.32)
  BOTTOM w0.133: U7900.G3 v6(115.98,105.32) ; U7000.AG3 v6(107.51,123.89)
FBD_CMD1: length 21.6
  BOTTOM w0.133: U7000.AG2 107.39,122.19 107.39,120.18 108.5,119.08 108.5,117.81 R7115.1 v1(108,116.02) 108,115.46 108.97,114.49 108.97,113.01 109.54,112.44 109.54,110.84 113.46,106.93 114.06,106.93 114.35,106.63 114.35,106.45 114.64,106.17 115.23,106.17 U7900.J3
FBD_CMD2: length 20.3
  BOTTOM w0.133: U7900.J2 114.78,106.74 115.12,107.09 115.12,107.46 114.86,107.72 113.86,107.72 113.18,108.4 112.62,108.4 110.03,110.99 110.03,112.77 109.73,113.07 v1(109.73,115.13) 109.14,115.71 R7118.2 109.65,117.82 109.65,119.16 109.27,119.54 108.51,119.54 107.9,120.15 U7000.AG1
FBD_CMD3: length 22
  TOP w0.133: v6(108.56,120.31) 111.69,117.19 112.08,117.19 v1(112.57,116.71) 112.57,116.26 113.56,115.26 115.2,115.26 117.48,112.98 117.48,112.35 117.19,112.05 117.19,111.28 117.48,110.99 117.48,109.96 117.19,109.67 117.19,109.17 116.88,108.86 116.4,108.86 v6(116.03,108.5)
  BOTTOM w0.133: U7000.AF3 108.29,123.09 108.29,121.59 108.13,121.43 108.13,120.75 v6(108.56,120.31) ; v6(116.03,108.5) 115.81,108.28 115.74,108.28 U7900.L3
FBD_CMD4: length 21.8
  TOP w0.133: v6(116.79,106.92) 117.3,107.43 v1(117.78,107.43) 117.98,107.43 118.41,107.86 118.41,113.18 113.31,118.29 112.19,118.29 111.38,119.1 110.9,119.1 108.72,121.28 v6(108.56,121.28)
  BOTTOM w0.133: U7900.K5 117,107.14 117,107.13 v6(116.79,106.92) ; U7000.AF1 108.7,121.42 v6(108.56,121.28)
FBD_CMD5: length 24.8
  TOP w0.133: v6(109.14,123.13) 107.91,121.9 v1(107.91,121.32) 107.91,121.1 108.21,120.81 108.69,120.81 111,118.5 111.42,118.5 112.03,117.89 113.14,117.89 118.01,113.02 118.01,108.37 117.77,108.13 117.2,108.13 117.2,108.13 116.63,108.13 115.98,107.48 v6(115.98,106.92)
  BOTTOM w0.133: U7900.K4 116.24,107.18 116.23,107.18 v6(115.98,106.92) ; U7000.AF2 108.87,122.87 108.88,122.87 v6(109.14,123.13)
FBD_CMD6: length 21.1
  TOP w0.133: v6(111.1,121.22) v1(111.75,120.57) 111.96,120.37 112.36,120.37 119.21,113.51 119.21,106.89 118.41,106.09 v6(117.6,106.09)
  BOTTOM w0.133: U7900.J5 v6(117.6,106.09) ; U7000.AC1 v6(111.1,121.22)
FBD_CMD7: length 23
  TOP w0.133: v6(111.1,119.5) 111.51,119.5 112.04,118.97 v1(112.65,118.97) 113.19,118.97 118.81,113.35 118.81,107.22 118.12,106.53 117.48,106.53 117.06,106.11 v6(116.79,106.11)
  BOTTOM w0.133: U7900.J4 116.51,106.38 116.52,106.38 v6(116.79,106.11) ; v6(111.1,119.5) 111.1,120.11 111.51,120.51 111.51,122.09 111.1,122.49 U7000.AC2
FBD_CMD8: length 22.6
  BOTTOM w0.133: U7000.AA2 112.31,122.31 112.31,119.03 v1(112.7,118.64) 113.09,118.25 113.09,117.94 113.36,117.67 113.54,117.67 113.57,117.7 113.76,117.7 118.19,113.27 118.19,112.77 118.32,112.64 118.48,112.64 118.62,112.51 118.62,112.13 118.48,112 118.32,112 118.19,111.87 118.19,111.49 118.32,111.36 118.48,111.36 118.62,111.22 118.62,110.85 118.48,110.72 118.32,110.72 118.19,110.58 118.19,107.4 118.05,107.27 117.79,107.27 117.65,107.13 117.65,106.76 117.79,106.63 118.05,106.63 118.19,106.49 118.19,106 117.82,105.64 117.44,105.64 117.36,105.72 U7900.H5
FBD_CMD9: length 22.1
  BOTTOM w0.133: U7900.H4 116.79,105.3 118.59,105.3 118.95,105.66 118.95,109.51 118.82,109.65 118.75,109.65 118.62,109.78 118.62,110.15 118.75,110.29 118.82,110.29 118.95,110.42 118.95,113.15 v1(115.12,116.97) 112.7,119.39 U7000.AA1
FBD_CMD10: length 27.2
  TOP w0.133: v6(113.92,123.95) 114.55,123.32 114.55,122.72 115.77,121.5 115.77,120 121.65,114.11 v1(122,114.11) 122.22,114.11 123.72,112.62 123.72,108.48 123.37,108.12 122.76,108.12 121.78,107.14 121.78,105.11 v6(122.38,104.52)
  BOTTOM w0.133: U7000.AA3 112.71,123.5 113.15,123.94 113.65,123.94 113.66,123.95 v6(113.92,123.95) ; U7900.G12 v6(122.38,104.52)
FBD_CMD11: length 19.8
  BOTTOM w0.133: U7000.Y1 113.5,120.37 v1(115.06,118.81) 119.99,113.89 119.99,106.1 120.37,105.72 U7900.H10
FBD_CMD12: length 22.8
  BOTTOM w0.133: U7900.H11 121.58,105.32 120.68,105.32 120.5,105.15 119.89,105.15 119.59,105.45 119.59,113.47 v1(117.03,116.03) 113.14,119.92 113.14,122.34 U7000.Y2
FBD_CMD13: length 21.8
  TOP w0.133: v6(120.7,106.95) 120.01,107.64 120.01,113.94 113.78,120.17 113.78,121.41 113.64,121.54 113.41,121.54 113.28,121.67 113.28,122.05 v1(113.32,122.09) 113.41,122.18 113.64,122.18 113.78,122.31 113.78,122.5 113.9,122.62 v6(113.9,123.03)
  BOTTOM w0.133: U7000.Y3 113.64,123.36 113.64,123.3 v6(113.9,123.03) ; v6(120.7,106.95) 120.97,106.95 121.02,106.9 121.56,106.9 U7900.K11
FBD_CMD14: length 23.3
  TOP w0.133: v6(120.68,107.63) 120.41,107.9 120.41,112.38 120.57,112.54 v1(120.57,112.9) 120.57,113.94 114.19,120.33 v6(114.19,120.89)
  BOTTOM w0.133: U7000.V3 115.1,123.24 115.46,122.89 115.46,120.64 115.59,120.52 115.75,120.52 115.88,120.39 115.88,119.96 115.75,119.83 114.96,119.83 114.83,119.96 114.83,120.74 114.68,120.89 v6(114.19,120.89) ; v6(120.68,107.63) 120.99,107.32 U7900.K10
FBD_CMD15: length 21.5
  TOP w0.133: v6(114.19,121.6) 114.54,121.96 114.68,121.96 114.83,121.81 v1(114.83,120.57) 114.83,120.25 121.22,113.86 121.22,108.11 v6(121.56,107.76)
  BOTTOM w0.133: v6(114.19,121.6) 114.54,121.25 114.78,121.25 114.88,121.35 114.88,121.48 114.74,121.62 114.74,122.34 U7000.V2 ; U7900.L12 122.42,107.76 v6(121.56,107.76)
FBD_CMD16: length 27.7
  BOTTOM w0.133: U7000.C2 127.38,122.7 127.76,122.32 129.69,122.32 129.86,122.49 131.94,122.49 137.03,117.39 137.03,116.35 v1(137.91,115.47) 139.47,113.91 139.47,110.59 139.67,110.39 139.67,108.76 139.42,108.51 139.42,107.48 139.17,107.23 138.76,107.23 138.52,106.99 138.03,106.99 137.7,106.67 137.7,106.49 137.37,106.15 137.19,106.15 136.85,105.82 136.85,105.33 U7901.L3
FBD_CMD17: length 26.1
  TOP w0.133: v6(128.81,120.33) 128.34,119.86 R7116.1
  BOTTOM w0.133: U7901.J3 136.06,107 136.06,107.59 135.86,107.79 134.6,107.79 134.01,108.38 134.01,112.25 134.54,112.79 134.54,113.35 135.08,113.89 135.53,113.89 136.07,114.42 v1(136.07,114.93) 135.23,115.77 135.23,115.87 131.27,119.83 129.32,119.83 v6(128.81,120.33) 128.48,120 126.64,120 126.3,120.35 U7000.D1
FBD_CMD18: length 28.8
  TOP w0.133: R7119.2 127.16,120.23 127.15,120.23 v6(127.15,120.66)
  BOTTOM w0.133: U7000.D2 126.46,122.54 126.67,122.54 126.88,122.34 127.19,122.34 127.51,122.02 127.51,121.02 v6(127.15,120.66) 128.07,120.66 128.52,121.12 132.44,121.12 v1(132.91,120.66) 136.55,117.01 136.55,116.07 139.04,113.58 139.04,110.3 139.26,110.09 139.26,109.03 138.82,108.59 137.19,108.59 136.88,108.27 136.88,107.27 137.29,106.85 U7901.J2
FBD_CMD19: length 23.5
  BOTTOM w0.133: U7000.E1 125.89,122.29 126.42,122.29 126.67,122.04 126.67,120.41 126.85,120.23 128.12,120.23 128.63,120.74 129.21,120.74 129.72,120.23 131.55,120.23 132.36,119.42 133.48,119.42 135.99,116.91 v1(135.99,116.71) 135.99,115.79 136.89,114.89 136.89,108.85 136.49,108.45 U7901.G3
FBD_CMD20: length 22.9
  BOTTOM w0.133: U7000.F2 125.07,122.33 125.07,120.82 126.47,119.42 131.09,119.42 134.21,116.3 v1(134.21,114.9) 134.21,113.99 134.09,113.86 134.09,112.94 133.71,112.56 133.71,108.12 134.46,107.37 U7901.H5
FBD_CMD21: length 23.7
  BOTTOM w0.133: U7000.F1 124.7,120.3 125.43,119.57 125.43,119.06 125.94,118.55 v1(127.74,118.55) 131.15,118.55 133.66,116.04 133.66,113.1 133.3,112.74 133.3,108.21 134.52,106.98 135.31,106.98 U7901.H4
FBD_CMD22: length 26.6
  BOTTOM w0.133: U7000.L2 120.7,122.45 121.07,122.07 121.07,120.68 v1(122.1,119.65) 123.77,119.65 125.45,117.97 131.12,117.97 133.17,115.92 133.17,113.09 133.08,113 133.08,108.06 134.57,106.57 U7901.J5
FBD_CMD23: length 27.2
  BOTTOM w0.133: U7901.J4 135.31,106.19 134.47,106.19 132.77,107.89 132.77,115.56 130.76,117.57 124.59,117.57 v1(123.85,118.31) 123.51,118.65 122.23,118.65 120.72,120.16 120.7,120.16 U7000.L1
FBD_CMD24: length 28.8
  BOTTOM w0.133: U7000.M3 120.32,123.08 120.32,119.5 v1(122.02,117.8) 122.66,117.16 130.58,117.16 132.36,115.38 132.36,108.65 132.46,108.55 132.46,107.86 134.56,105.77 U7901.K5
FBD_CMD25: length 28.2
  BOTTOM w0.133: U7901.K4 135.35,105.42 134.59,105.42 132.23,107.77 132.23,108.45 131.95,108.73 131.95,114.62 v1(131.06,115.51) 129.82,116.75 122.33,116.75 119.9,119.19 U7000.M1
FBD_CMD26: length 29.8
  BOTTOM w0.133: U7901.L12 129.6,104.97 129.95,105.31 131.34,105.31 132.14,106.11 132.14,107.55 132.01,107.68 132.01,108.34 131.55,108.8 131.55,114.27 129.47,116.35 121.9,116.35 v1(120.12,118.13) 119.43,118.81 119.43,121.97 119.9,122.44 U7000.M2
FBD_CMD27: length 28.9
  BOTTOM w0.133: U7000.R3 117.9,123.1 117.9,121.54 118.59,120.85 v1(118.59,119.65) 118.59,119.02 121.67,115.94 129.19,115.94 130.86,114.27 130.86,113.76 131.29,113.33 131.29,108.75 131.79,108.25 131.79,107.59 131.92,107.46 131.92,106.2 131.48,105.77 U7901.K10
FBD_CMD28: length 25.2
  TOP w0.133: v6(116.7,119.63) 120.72,115.61 v1(121.08,115.61) 121.29,115.61 124.19,112.72 124.19,109.23 124.5,108.93 125.3,108.93 126.11,108.12 126.97,107.25 127.53,107.25 127.66,107.38 130,107.38 130.56,106.82 v6(130.56,106.19)
  BOTTOM w0.133: v6(116.7,119.63) 117.5,120.43 U7000.R1 ; U7901.K11 130.31,105.98 130.35,105.98 v6(130.56,106.19)
FBD_CMD29: length 23.1
  TOP w0.133: v6(129.72,107.81) 127.84,107.81 127.46,108.19 126.7,108.19 126.44,108.45 125.11,109.78 125.11,112.36 120.19,117.28 v1(119.94,117.28) 119.68,117.28 v6(116.7,120.26)
  BOTTOM w0.133: U7000.R2 117.14,122.34 117.14,120.7 v6(116.7,120.26) ; v6(129.72,107.81) 129.89,107.64 129.89,107.58 U7901.H11
FBD_CMD30: length 23.1
  TOP w0.133: v6(116.7,121.55) 117.2,121.55 v1(117.8,120.95) 126.1,112.66 126.1,110.06 127.07,109.08 127.17,108.99 128.24,108.99 128.29,108.94 129.25,108.94 v6(130.48,107.71)
  BOTTOM w0.133: U7000.U2 116.28,122.32 116.28,121.97 v6(116.7,121.55) ; v6(130.48,107.71) 130.59,107.6 130.66,107.6 U7901.H10
FBD_CMD31: length 20.6
  TOP w0.133: v6(128.07,108.54) 127.75,108.54 127.7,108.59 127,108.59 126.79,108.8 125.58,110.02 v1(125.58,111.17) 125.58,112.46 117.15,120.89 v6(116.7,120.89)
  BOTTOM w0.133: v6(128.07,108.54) 128.92,108.54 U7901.G12 ; v6(116.7,120.89) 115.9,121.69 U7000.U1
FBD_D0: length 27.1
  TOP w0.133: v1(108.36,126.94) 108.71,126.59 109.07,126.59 v6(109.19,126.46)
  IN4 w0.095: v6(109.19,126.46) 109.35,126.3 109.73,126.3 110.33,125.71 110.33,122.58 111.53,121.38 111.53,118.89 112.54,117.88 112.54,117.88 112.72,117.7 112.72,107.76 112.98,107.51 112.98,106.87 113.19,106.66 113.71,106.66 113.72,106.67 114.45,105.93 114.45,105.2 v6(115.16,104.5)
  BOTTOM w0.133: U7000.AF7 108.95,126.46 v6(109.19,126.46) ; v6(115.16,104.5) U7900.F2
FBD_D1: length 35.6
  TOP w0.133: v6(109.1,128.7) 108.89,128.49 v1(108.31,128.49)
  IN4 w0.095: v6(115.95,100.49) 116.36,100.9 116.92,100.9 117.22,101.21 117.22,104.79 116.09,105.92 115.89,105.92 114.44,107.37 114.44,107.5 113.69,108.24 113.69,109.03 113.93,109.27 113.93,110.02 113.93,114 114.48,114.54 114.48,116.79 112.1,119.16 112.1,121.6 110.86,122.85 110.86,126.95 110.54,127.27 109.95,127.27 109.55,127.67 109.55,128.26 v6(109.1,128.7)
  BOTTOM w0.133: U7000.AF9 108.7,128.3 v6(109.1,128.7) ; U7900.B4 v6(115.95,100.49)
FBD_D2: length 26.5
  IN4 w0.095: v6(109.1,125.5) 109.53,125.08 109.53,122.72 110.72,121.53 110.72,119.3 112.42,117.59 112.42,107.66 112.67,107.41 112.67,106.78 112.7,106.75 112.7,106.75 113,106.44 113.01,106.44 113.07,106.38 113.6,106.38 114,105.98 114,105.02 114.94,104.07 115.62,104.07 v6(115.98,103.72)
  BOTTOM w0.133: U7000.AF6 v6(109.1,125.5) ; U7900.E4 v6(115.98,103.72)
FBD_D3: length 31
  TOP w0.133: v1(118.36,103.19) 117.42,103.19 117.12,103.5 116.99,103.5 116.79,103.7 v6(116.79,103.7)
  IN4 w0.095: v6(109.1,127.9) 109.1,127.86 109.87,127.09 110.32,127.09 110.59,126.81 110.59,122.71 111.82,121.48 111.82,119.03 113.01,117.84 113.01,108.47 113.91,107.57 113.91,106.94 114.82,106.02 115.05,106.02 115.57,105.5 115.57,105.12 115.77,104.92 116.18,104.92 116.38,104.71 116.38,104.1 v6(116.79,103.7)
  BOTTOM w0.133: U7000.AF8 v6(109.1,127.9) ; v6(116.79,103.7) 116.38,104.11 U7900.F4
FBD_D4: length 34.2
  IN4 w0.095: v6(107.5,127.1) 105.97,125.57 105.97,120.61 109.67,116.91 109.67,112.48 110.27,111.88 110.27,105.59 111.04,104.83 111.04,103.1 114.45,99.68 v6(115.24,99.68)
  BOTTOM w0.133: v6(115.24,99.68) 115.94,99.68 U7900.A4 ; U7000.AG7 v6(107.5,127.1)
FBD_D5: length 31.4
  IN4 w0.095: v6(107.44,126.46) 107.32,126.46 106.3,125.44 106.3,120.74 109.96,117.08 109.96,112.6 110.56,112 110.56,105.73 111.33,104.96 111.33,103.22 113.31,101.24 113.66,101.24 v6(114.38,100.51)
  BOTTOM w0.133: v6(107.44,126.46) 107.62,126.28 107.62,126.18 U7000.AG6 ; U7900.A2 v6(114.38,100.51)
FBD_D6: length 30.7
  TOP w0.133: v1(115.04,102.95) v6(114.41,102.95)
  IN4 w0.095: v6(114.41,102.95) 114.41,103.31 113.98,103.74 113.34,103.74 112.67,104.42 112.67,105.58 111.85,106.4 111.85,117.2 110.19,118.86 110.19,119.67 109.06,120.8 109.06,121.4 108.27,122.18 108.27,127.94 v6(107.5,128.7)
  BOTTOM w0.133: v6(107.5,128.7) 107.9,128.3 U7000.AG9 ; U7900.E2 v6(114.41,102.95)
FBD_D7: length 32.1
  IN4 w0.095: v6(114.39,101.3) 113.57,102.12 113.16,102.12 111.67,103.62 111.67,105.17 110.85,105.99 110.85,112.11 110.25,112.71 110.25,117.38 106.86,120.77 106.86,125.49 107.24,125.87 107.87,125.87 108,126 108,127.47 v6(107.57,127.9)
  BOTTOM w0.133: v6(107.57,127.9) 107.57,127.9 107.75,127.72 107.75,127.66 U7000.AG8 ; U7900.B2 v6(114.39,101.3)
FBD_D8: length 31.2
  IN1 w0.095: v6(111.58,125.54) 110.94,124.9 110.94,122.91 112.53,121.32 112.53,120.75 119.02,114.25 119.02,105.6 119.72,104.91 119.72,103.62 120.17,103.16 120.83,103.16 121.19,102.81 121.47,102.81 121.76,102.51 122.8,102.51 v6(123.2,102.91)
  BOTTOM w0.133: v6(123.2,102.91) 123.39,103.11 123.39,103.13 U7900.E13 ; v6(111.58,125.54) 111.37,125.33 111.33,125.33 U7000.AC5
FBD_D9: length 28.6
  TOP w0.133: v1(110.79,123.96) 111.13,124.3 111.78,124.3 v6(112.24,123.84)
  IN1 w0.095: v6(123.19,103.72) 122.99,103.72 122.65,104.06 122.22,104.06 122.14,104.15 121.97,104.31 121.97,105.58 121.03,106.52 120.6,106.52 120.17,106.95 120.17,115 114.65,120.52 114.03,120.52 113.69,120.85 113.69,122.39 v6(112.24,123.84)
  BOTTOM w0.133: U7000.AA4 112.7,124.3 v6(112.24,123.84) ; v6(123.19,103.72) 123.58,104.11 U7900.F13
FBD_D10: length 27.7
  TOP w0.089: v6(121.59,104.5) 121.59,104.24 121.89,103.94 121.89,103.27 v1(121.75,103.14)
  IN1 w0.095: v6(121.59,104.5) 121.38,104.72 121.31,104.79 121.31,105.09 121.56,105.33 121.56,105.51 121.31,105.76 121.13,105.76 120.8,105.43 120.67,105.43 119.88,106.22 119.88,114.88 114.43,120.33 113.95,120.33 113.43,120.85 113.43,121.25 113.18,121.5 113.18,121.71 112.8,122.09 112.6,122.09 111.94,122.75 111.94,123.47 v6(111.5,123.9)
  BOTTOM w0.133: U7000.AC4 v6(111.5,123.9) ; U7900.F11 v6(121.59,104.5)
FBD_D11: length 25.8
  TOP w0.133: v1(111.56,122.55) v6(111.56,123.23)
  IN1 w0.095: v6(111.56,123.23) 111.56,122.85 113.19,121.22 113.19,120.76 113.94,120 114.36,120 119.6,114.76 119.6,106.1 121.08,104.61 121.08,104.41 121.51,103.98 v6(121.51,103.7)
  BOTTOM w0.133: v6(121.51,103.7) 121.6,103.61 121.89,103.32 U7900.E11 ; U7000.AC3 111.29,123.5 v6(111.56,123.23)
FBD_D12: length 30.8
  TOP w0.133: v1(121.34,101.39) 121.34,100.82 v6(121.61,100.55)
  IN1 w0.095: v6(109.92,123.12) 109.92,122.97 111.68,121.2 111.68,119.77 114.28,117.18 116,115.45 117.22,114.23 117.22,105.57 118.43,104.37 118.43,102.67 119.54,101.55 120.55,100.55 v6(121.61,100.55)
  BOTTOM w0.133: U7900.B11 v6(121.61,100.55) ; v6(109.92,123.12) 109.92,123.91 U7000.AD4
FBD_D13: length 31.6
  TOP w0.133: v1(121.44,99.61) v2(122.17,99.61)
  IN1 w0.095: v6(110.26,120.61) 110.57,120.31 110.57,119.39 110.87,119.09 111.46,119.09 114.77,115.77 114.77,108.25 115.29,107.73 115.29,106.62 117.22,104.69 117.22,102.58 118.9,100.91 119.38,100.42 119.38,99.86 119.63,99.61 v2(122.17,99.61)
  BOTTOM w0.133: U7900.A11 121.98,99.81 v2(122.17,99.61) ; v6(110.26,120.61) 109.78,121.1 109.78,121.43 109.91,121.55 109.91,122.09 110.3,122.48 U7000.AD2
FBD_D14: length 33.7
  TOP w0.133: v1(110.8,125.54) 110.73,125.48 v6(109.92,125.48)
  IN1 w0.095: v6(123.19,101.3) 122.79,100.91 121.95,100.91 121.24,101.61 119.95,101.61 118.71,102.85 118.71,104.49 118.02,105.18 118.02,113.84 111.91,119.94 111.91,121.29 110.39,122.82 110.39,125.01 v6(109.92,125.48)
  BOTTOM w0.133: v6(109.92,125.48) U7000.AD5 ; U7900.B13 v6(123.19,101.3)
FBD_D15: length 30.7
  TOP w0.133: v1(110.11,121.89) 110.11,121.36 v6(110.28,121.19)
  IN1 w0.095: v6(123.17,100.52) 122.75,100.1 120.59,100.1 119.34,101.35 118.01,102.68 118.01,104.35 115.59,106.77 115.59,112.35 115.54,112.4 115.54,113.03 116.13,113.62 116.13,114.92 111.49,119.56 111.49,119.97 v6(110.28,121.19)
  BOTTOM w0.133: v6(123.17,100.52) 123.17,100.52 U7900.A13 ; U7000.AD1 110.3,121.45 110.28,121.43 v6(110.28,121.19)
FBD_D16: length 16.4
  TOP w0.133: v1(117.38,122.67) 117.12,122.93 v6(117.12,123.92)
  IN4 w0.095: v6(117.12,123.92) 117.98,123.05 117.98,119.01 121.73,115.27 121.73,114.24 122.39,113.58 122.39,113.34 v6(123.22,112.51)
  BOTTOM w0.133: U7900.U13 123.41,112.75 123.41,112.71 v6(123.22,112.51) ; v6(117.12,123.92) 117.17,123.97 117.17,123.97 U7000.R4
FBD_D17: length 16
  TOP w0.133: v6(116.38,123.2) 115.86,122.68 v1(115.86,122.25)
  IN4 w0.095: v6(116.38,123.2) 117.1,122.49 117.1,118.68 120.79,115 120.79,113.67 121.64,112.82 v6(121.64,111.72)
  BOTTOM w0.133: v6(116.38,123.2) 116.25,123.33 116.07,123.33 U7000.U3 ; v6(121.64,111.72) 121.82,111.9 121.82,111.96 U7900.T11
FBD_D18: length 17.3
  TOP w0.133: v1(115.6,123.56) 115.95,123.56 v6(116.3,123.91)
  IN4 w0.095: v6(123.16,111.7) 122.73,112.13 122.22,112.13 122,112.36 122,112.9 121.07,113.82 121.07,115.11 117.4,118.79 117.4,122.81 v6(116.3,123.91)
  BOTTOM w0.133: U7000.U4 115.91,124.3 v6(116.3,123.91) ; U7900.T13 123.58,112.11 v6(123.16,111.7)
FBD_D19: length 16.5
  TOP w0.133: v6(116.29,125.48) 116.12,125.48 v1(115.54,124.9)
  IN4 w0.095: v6(121.98,113.45) 121.36,114.07 121.36,115.23 117.7,118.89 117.7,122.77 116.7,123.78 116.7,125.06 116.28,125.48 v6(116.29,125.48)
  BOTTOM w0.133: U7000.U5 115.91,125.1 v6(116.29,125.48) ; U7900.U11 v6(121.98,113.45)
FBD_D20: length 22.6
  IN4 w0.095: v6(114.55,126.27) 115.46,125.35 115.46,122.93 115.82,122.57 115.82,118.54 119.78,114.58 119.78,111.42 120.65,110.56 121.39,110.56 122.21,109.73 122.72,109.73 v6(123.16,109.29)
  BOTTOM w0.133: v6(114.55,126.27) 114.91,125.9 U7000.V6 ; U7900.N13 123.44,109.58 123.44,109.56 v6(123.16,109.29)
FBD_D21: length 21.8
  IN4 w0.095: v6(123.21,108.55) 122.86,108.9 122.24,108.9 122.01,109.13 122.01,109.45 121.79,109.67 121.71,109.75 120.66,109.75 119.5,110.91 119.5,114.46 115.47,118.49 115.47,122.52 115.28,122.71 115.28,124.15 114.73,124.7 v6(114.7,124.7)
  BOTTOM w0.133: U7000.V5 v6(114.7,124.7) ; U7900.M13 v6(123.21,108.55)
FBD_D22: length 21.6
  IN4 w0.095: v6(121.62,108.48) 121.62,108.48 121.24,108.1 120.66,108.1 120.16,108.61 120.16,109.45 118.93,110.68 118.93,114.03 114.67,118.29 114.67,123.29 114.3,123.67 114.3,124.12 113.92,124.5 v6(113.92,124.65)
  BOTTOM w0.133: v6(113.92,124.65) 113.79,124.53 113.73,124.53 U7000.Y4 ; U7900.M11 121.85,108.79 121.85,108.71 v6(121.62,108.48)
FBD_D23: length 22.4
  TOP w0.133: v6(113.92,125.49) 113.36,125.49 v1(113.29,125.56)
  IN4 w0.095: v6(121.63,109.29) 121.63,109.29 121.27,108.93 120.66,108.93 120.44,109.15 120.44,109.56 119.21,110.79 119.21,114.23 115.09,118.35 115.09,124.07 114.84,124.32 114.55,124.32 114.32,124.54 114.32,125.09 v6(113.92,125.49)
  BOTTOM w0.133: v6(121.63,109.29) 121.75,109.41 121.75,109.49 U7900.N11 ; U7000.Y5 113.68,125.28 113.71,125.28 v6(113.92,125.49)
FBD_D24: length 16.9
  TOP w0.133: v1(116.34,113) v6(116.79,112.56)
  IN2 w0.089: 114.71,123.28 114.33,123.66 114.33,125.89 v6(113.91,126.3)
  IN2 w0.146: v6(116.79,112.56) 116.79,117.46 114.71,119.54 114.71,123.28
  BOTTOM w0.133: v6(116.79,112.56) 116.55,112.79 116.5,112.79 U7900.U4 ; v6(113.91,126.3) 113.91,125.99 113.83,125.9 U7000.Y6
FBD_D25: length 21.4
  IN2 w0.146: v6(113.9,127.1) 114.3,126.7 114.68,126.7 115.17,126.21 115.17,122.62 115.46,122.33 115.46,119.41 118.11,116.76 118.11,110.65 116.79,109.33 v6(116.79,109.34)
  BOTTOM w0.133: U7900.M4 116.79,109.33 v6(116.79,109.34) ; U7000.Y7 113.5,126.7 v6(113.9,127.1)
FBD_D26: length 19.4
  TOP w0.133: v6(112.34,127.9) 112.94,127.9 v1(113.29,127.55)
  IN2 w0.146: v6(112.34,127.9) 112.68,127.9 113.18,127.4 113.18,122.42 113.35,122.25 113.35,119.47 115.72,117.1 115.72,114.6 115.21,114.09 v6(115.21,113.35)
  BOTTOM w0.133: v6(112.34,127.9) 113.1,127.9 U7000.Y8 ; v6(115.21,113.35) 115.21,113.35 U7900.U2
FBD_D27: length 23
  TOP w0.133: v6(111.5,128.7) 111.68,128.52 v1(112.12,128.52)
  IN2 w0.146: v6(111.5,128.7) 110.6,127.8 110.6,122.41 111.51,121.5 111.51,118.86 111.25,118.61 111.25,117.98 112.45,116.77 112.45,112.15 112.45,112.08 112.88,111.66 112.88,110.91 113.16,110.63 113.86,110.63 v6(114.39,110.11)
  BOTTOM w0.133: U7000.AC9 111.1,128.3 v6(111.5,128.7) ; v6(114.39,110.11) 114.39,110.11 U7900.N2
FBD_D28: length 22.4
  IN2 w0.146: v6(111.49,127.09) 111.9,127.49 112.46,127.49 112.93,127.02 112.93,119.26 115.27,116.92 115.27,114.83 114.78,114.34 114.78,113.07 115.45,112.4 115.45,111.3 115.63,111.12 115.64,111.12 115.64,110.55 115.47,110.38 115.47,109.87 v6(116,109.34)
  BOTTOM w0.133: v6(116,109.34) 116.38,109.71 U7900.N4 ; U7000.AC7 v6(111.49,127.09)
FBD_D29: length 18.8
  IN2 w0.146: v6(114.4,111.74) 114.4,112.21 113.9,112.71 113.9,112.87 113.9,114.83 114.34,115.28 114.34,116.6 112.27,118.68 112.27,121.79 111.1,122.95 111.1,125.63 111.42,125.95 111.79,125.95 v6(112.17,125.57)
  BOTTOM w0.133: v6(112.17,125.57) 111.76,125.98 111.18,125.98 U7000.AC6 ; U7900.T2 v6(114.4,111.74)
FBD_D30: length 23.4
  TOP w0.133: v6(109.93,127.88) 110.08,127.73 v1(110.08,127.22)
  IN2 w0.146: v6(109.93,127.88) 109.93,127.69 110.33,127.29 110.33,121.98 110.68,121.63 110.68,117.86 111.99,116.55 111.99,111.73 112.34,111.37 112.34,110.71 113.28,109.77 113.92,109.77 v6(114.38,109.32)
  BOTTOM w0.133: U7000.AC8 111.1,127.5 110.72,127.88 v6(109.93,127.88) ; v6(114.38,109.32) 114.41,109.28 114.41,109.28 U7900.M2
FBD_D31: length 22.1
  TOP w0.133: v1(111.89,130.01) 111.89,129.81 v6(111.56,129.48)
  IN2 w0.146: v6(116.79,111.72) 116.34,112.17 116.34,117.16 113.69,119.81 113.69,122.44 113.46,122.67 113.46,127.98 112.56,128.88 112.01,128.88 111.56,129.33 v6(111.56,129.48)
  BOTTOM w0.133: U7000.AC10 111.3,129.3 111.38,129.3 v6(111.56,129.48) ; v6(116.79,111.72) 116.51,112 116.49,112 U7900.T4
FBD_D32: length 26.7
  TOP w0.133: v1(123.06,118.97) 122.68,119.35 122.68,120.29 123.08,120.69 v6(123.1,120.69)
  IN1 w0.095: v6(123.1,120.69) 123.59,120.2 125.43,120.2 125.89,119.74 126.66,119.74 126.95,119.45 129.12,119.45 129.22,119.34 131.18,119.34 134.13,116.39 134.13,112.79 134.85,112.08 134.85,111.63 134.13,110.91 134.13,110.33 134.9,109.56 134.9,108.98 v6(135.31,108.57)
  BOTTOM w0.133: U7000.H2 123.1,122.5 123.51,122.1 123.51,121.1 v6(123.1,120.69) ; v6(135.31,108.57) 135.69,108.96 U7901.F4
FBD_D33: length 20.6
  TOP w0.133: v1(123.19,122.9) 123.19,123.6 v6(123.5,123.91)
  IN1 w0.095: v6(135.36,113.38) 134.99,113.74 134.99,116.75 131.27,120.46 129.31,120.46 128.14,121.63 125.19,121.63 123.5,123.33 v6(123.5,123.91)
  BOTTOM w0.133: v6(123.5,123.91) U7000.H4 ; v6(135.36,113.38) 135.46,113.27 135.46,113.2 U7901.A4
FBD_D34: length 23.9
  TOP w0.133: v1(123.9,121.56) 123.38,121.56 v6(123.1,121.28)
  IN1 w0.095: v6(135.31,109.38) 135.31,109.57 134.9,109.97 134.9,111.12 135.18,111.4 135.44,111.4 135.66,111.62 135.66,111.93 135.44,112.15 135.17,112.15 134.42,112.91 134.42,116.51 131.29,119.63 129.34,119.63 129.31,119.66 127.18,119.66 126.46,120.39 123.74,120.39 123.49,120.65 123.49,120.89 v6(123.1,121.28)
  BOTTOM w0.133: U7901.E4 v6(135.31,109.38) ; v6(123.1,121.28) U7000.H1
FBD_D35: length 21.5
  TOP w0.133: v6(123.9,120.77) 124.97,120.77 v1(124.97,120.77)
  IN1 w0.095: v6(123.9,120.77) 126.45,120.77 127.3,119.92 131.41,119.92 134.7,116.63 134.7,113.16 v6(135.28,112.58)
  BOTTOM w0.133: v6(123.9,120.77) 123.9,120.77 123.9,122.1 123.5,122.5 123.5,123.1 U7000.H3 ; U7901.B4 v6(135.28,112.58)
FBD_D36: length 27.6
  TOP w0.133: v1(124.23,125.01) 124.61,125.01 v6(125.1,125.5)
  IN1 w0.095: v6(137.69,109.41) 136.47,110.63 136.47,113.45 135.27,114.65 135.27,116.86 131.39,120.75 129.51,120.75 128.37,121.89 125.22,121.89 123.93,123.18 123.93,124.33 v6(125.1,125.5)
  BOTTOM w0.133: U7000.F5 125.1,125.5 v6(125.1,125.5) ; v6(137.69,109.41) 137.44,109.41 137.29,109.27 U7901.F2
FBD_D37: length 21.1
  TOP w0.133: v1(124.49,123.1) v6(125.1,123.1)
  IN1 w0.095: v6(137.69,112.56) 137.69,113.35 137.94,113.6 137.94,113.94 136.56,115.32 136.56,117.4 131.92,122.04 130,122.04 129.39,122.65 125.55,122.65 v6(125.1,123.1)
  BOTTOM w0.133: v6(137.69,112.56) 137.3,112.17 U7901.B2 ; v6(125.1,123.1) U7000.E2
FBD_D38: length 21.3
  TOP w0.133: v1(138.02,113.17) 138.02,113.32 v6(137.57,113.78)
  IN1 w0.095: v6(137.57,113.78) 136.28,115.07 136.28,117.28 131.81,121.75 129.77,121.75 129.13,122.39 125.27,122.39 124.72,122.94 124.72,123.52 v6(125.1,123.9)
  BOTTOM w0.133: v6(137.57,113.78) 137.57,113.24 U7901.A2 ; U7000.E4 v6(125.1,123.9)
FBD_D39: length 26.5
  TOP w0.133: v6(137.69,110.17) 138.14,110.62 138.67,110.62 139.02,110.28 v1(139.02,109.83)
  IN1 w0.095: v6(137.69,110.17) 138.15,110.63 138.67,110.63 139.01,110.98 139.01,113.1 138.59,113.52 138.59,114.1 137.13,115.56 137.13,117.63 132.16,122.61 130.67,122.61 128.99,124.28 126.29,124.28 v6(125.9,123.9)
  BOTTOM w0.133: U7901.E2 137.69,110.17 v6(137.69,110.17) ; U7000.D3 v6(125.9,123.9)
FBD_D40: length 18.9
  TOP w0.133: v6(121.92,124.68) 121.36,124.12 v1(120.98,124.12)
  IN4 w0.095: v6(121.92,124.68) 121.15,123.91 121.15,123.04 122,122.2 122,119.86 125.14,116.72 127.32,116.72 128.35,115.69 128.35,115 129.03,114.31 v6(129.03,113.65)
  BOTTOM w0.133: U7901.A11 129.41,113.65 v6(129.03,113.65) ; v6(121.92,124.68) 122.3,124.3 U7000.J4
FBD_D41: length 18.2
  IN4 w0.095: v6(121.16,125.54) 120.59,124.97 120.59,119.65 124.4,115.84 124.4,115.4 126.39,113.4 127.46,113.4 128.07,112.79 v6(128.07,112.54)
  BOTTOM w0.133: U7000.L5 120.92,125.32 120.94,125.32 v6(121.16,125.54) ; U7901.A13 v6(128.07,112.54)
FBD_D42: length 17.9
  TOP w0.133: v6(121.5,121.58) 121.65,121.73 v1(122.38,121.73)
  IN4 w0.095: v6(128.9,111.75) 129.29,112.14 129.29,112.69 129.06,112.92 128.78,112.92 128.15,113.55 128.15,114.21 127.56,114.8 127.56,115.51 126.93,116.15 124.9,116.15 121.12,119.93 121.12,121.2 v6(121.5,121.58)
  BOTTOM w0.133: v6(128.9,111.75) 128.49,112.16 U7901.B13 ; v6(121.5,121.58) 121.9,121.99 121.9,122.3 U7000.J2
FBD_D43: length 18.8
  TOP w0.133: v6(121.5,120.92) 121.84,120.57 v1(121.84,120.21)
  IN4 w0.095: v6(129.69,110.17) 129.69,110.4 130.08,110.78 130.08,111.6 130.1,111.62 130.1,112.68 129.57,113.21 128.9,113.21 128.43,113.67 128.43,114.34 127.92,114.85 127.92,115.56 127.05,116.43 125.02,116.43 121.5,119.95 v6(121.5,120.92)
  BOTTOM w0.133: v6(129.69,110.17) 129.74,110.13 129.74,110.12 U7901.E11 ; U7000.J1 122.3,121.72 v6(121.5,120.92)
FBD_D44: length 21.8
  TOP w0.133: v1(122.68,126.13) 122.07,126.13 v6(121.92,126.28)
  IN4 w0.095: v6(130.49,112.51) 130.49,114.7 128.19,117 125.25,117 122.3,119.96 122.3,122.34 121.34,123.31 121.34,123.7 121.82,124.18 121.96,124.18 122.31,124.53 122.31,125.9 v6(121.92,126.28)
  BOTTOM w0.133: U7901.B11 130.18,112.26 130.24,112.26 v6(130.49,112.51) ; v6(121.92,126.28) U7000.J6
FBD_D45: length 24
  TOP w0.133: v1(121.76,122.95) v6(121.76,123.59)
  IN4 w0.095: v6(121.76,123.59) 121.76,123.42 122.63,122.55 122.63,120.03 125.37,117.29 128.31,117.29 130.98,114.62 130.98,110.11 130.71,109.84 130.22,109.84 v6(129.72,109.34)
  BOTTOM w0.133: v6(129.72,109.34) U7901.F11 ; U7000.H5 122.72,124.72 122.72,124.2 122.46,123.94 122.11,123.94 v6(121.76,123.59)
FBD_D46: length 25.8
  TOP w0.133: v1(121.45,128.77) 121.45,128.2 121.17,127.92 v6(121.16,127.93)
  IN4 w0.095: v6(121.16,127.93) 119.92,126.69 119.92,118.49 122.73,115.68 122.73,115.24 126.44,111.53 126.44,110.16 126.74,109.86 126.74,109.36 127.05,109.06 127.16,108.95 127.61,108.95 v6(128.07,109.4)
  BOTTOM w0.133: v6(121.16,127.93) 120.91,128.18 120.83,128.18 U7000.L9 ; v6(128.07,109.4) 128.31,109.16 128.31,109.16 U7901.F13
