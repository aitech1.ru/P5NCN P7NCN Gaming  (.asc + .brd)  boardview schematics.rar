# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCK_LED2: length 260.9
  TOP w0.102: R3088.2 101.14,23.97 100.79,23.61 98.07,23.61 97.71,23.97 v1(95.17,23.97) 94.03,23.97 93.75,23.69 90.14,23.69 87.58,26.25 87.58,32.78 94.39,39.58 94.39,40.67 92.61,42.45 v2(92.61,42.85)
  IN2 w0.102: v2(35.33,181.04) 35.33,180.76 33.82,179.25 31.69,179.25 31.31,178.87 24.91,178.87 24.1,178.06 24.1,177.58 21.32,174.8 19.7,174.8 19.28,174.38 19.28,173.32 18.89,172.93 18.89,168.86 20.65,167.1 20.65,158.97 12.89,151.21 12.89,149.76 11.44,148.31 11.44,146.22 12.21,145.45 12.21,137.92 11.24,136.95 11.24,132.64 12.12,131.76 12.12,125.63 11.63,125.14 11.63,118.01 17.22,112.43 17.22,89.2 25.25,81.17 25.25,74.9 24.81,74.46 24.81,64.52 27.99,61.34 27.99,59.62 34.63,52.98 34.63,51.56 36.77,49.42 41.07,49.42 44.09,46.4 44.09,45.85 45.05,44.9 47.04,44.9 48.65,43.29 57.43,43.29 58.15,44.01 66.76,44.01 67.5,43.27 68.7,43.27 69.43,42.55 92.31,42.55 v2(92.61,42.85)
  BOTTOM w0.102: v2(35.33,181.04) 35.33,178.91 35.75,178.49 CON5602.13
MCK_LED2_IO: length 33.3
  TOP w0.114: CON402.13 189.2,176.07 190.2,175.07 v1(190.2,173.95) 190.2,173.24 195.61,167.83 206.61,167.83 208.77,169.99 208.77,175 209.4,175.63 PCON702.5
MCK_LED3: length 267
  TOP w0.102: v2(93.98,40.51) 93.98,40.1 93.93,40.05 93.93,39.46 86.72,32.24 86.72,26.83 90.13,23.41 v1(97.08,23.41) 97.13,23.46 97.93,23.46 97.99,23.41 104.65,23.41 104.83,23.59 R3085.2
  IN2 w0.102: v2(93.98,40.51) 93.98,40.99 93.2,41.77 69.34,41.77 68.47,42.65 45.1,42.65 39.09,48.66 36.67,48.66 34.02,51.3 34.02,52.73 27.38,59.37 27.38,61.09 23.42,65.05 23.42,70.15 24.2,70.94 24.2,74.72 24.64,75.15 24.64,77.92 20.8,81.75 19.16,81.75 15.15,85.76 15.15,88.3 13.93,89.51 11.52,89.51 10.35,90.68 10.35,98.99 10.69,99.34 10.69,119.95 9.96,120.69 9.96,140.58 10.52,141.14 10.65,141.14 11.8,142.3 11.8,145.28 11.03,146.05 11.03,148.48 12.48,149.93 12.48,151.38 20.24,159.14 20.24,166.91 18.49,168.67 18.49,173.1 18.87,173.49 18.87,175.49 19.55,176.17 22.11,176.17 23.7,177.75 23.7,178.23 24.74,179.28 31.14,179.28 31.52,179.65 33.65,179.65 34.49,180.49 v2(34.49,180.78)
  BOTTOM w0.102: v2(34.49,180.78) 34.49,178.71 34.75,178.45 CON5602.11
MCK_LED3_IO: length 30.2
  TOP w0.114: PCON702.7 208.4,175.63 208.09,175.31 208.09,171.21 v1(206.08,169.2) 205.39,168.51 195.94,168.51 191.41,173.04 191.41,174.87 190.2,176.09 CON402.11
MCK_LED4: length 277.6
  TOP w0.102: v2(92.74,40.55) 92.74,38.55 86.51,32.33 86.51,26.74 90.05,23.21 92.91,23.21 93.14,22.98 108.41,22.98 v1(109.02,23.59) 109.78,24.35 R3086.2
  IN2 w0.102: v2(33.66,180.97) 33.66,180.32 33.4,180.06 31.35,180.06 30.97,179.68 24.57,179.68 23.57,178.68 20.86,178.68 19.68,177.49 19.68,176.88 18.47,175.66 18.47,173.66 18.08,173.27 18.08,168.5 19.84,166.74 19.84,159.68 18.3,158.14 14.78,158.14 10.63,153.99 10.63,143.95 11.33,143.25 11.33,142.4 10.48,141.54 10.35,141.54 9.55,140.75 9.55,120.52 10.29,119.79 10.29,99.51 9.94,99.16 9.94,90.51 11.35,89.11 13.76,89.11 14.74,88.13 14.74,85.59 19,81.33 20.65,81.33 24.23,77.75 24.23,75.32 23.7,74.79 23.7,72.02 20.85,69.18 20.85,66.88 22.47,65.27 22.56,65.27 22.79,65.04 22.79,64.82 26.77,60.83 26.77,58.96 33.3,52.44 33.3,48.76 37.81,44.25 39.61,44.25 42.03,41.83 68.13,41.83 69,40.96 75.06,40.96 75.87,40.14 92.33,40.14 v2(92.74,40.55)
  BOTTOM w0.102: v2(33.66,180.97) 33.75,180.87 CON5602.9
MCK_LED4_IO: length 27.2
  TOP w0.114: PCON702.9 207.4,175.61 207.4,175.61 207.4,172.14 204.45,169.2 196.27,169.2 192.58,172.89 v1(192.58,174.59) 192.58,174.72 191.2,176.1 CON402.9
MCK_LED5: length 278.8
  TOP w0.102: R3098.2 133.58,40.1 v2(133.58,39.41) 134.15,38.84 v1(134.48,38.84)
  IN2 w0.102: v2(32.59,180.47) 32.38,180.26 31.27,180.26 30.89,179.89 24.49,179.89 23.49,178.88 20.78,178.88 19.48,177.58 19.48,177.02 18.26,175.8 18.26,173.74 16.66,172.14 16.66,169.57 19.63,166.6 19.63,159.76 18.21,158.34 14.7,158.34 10.42,154.07 10.42,143.87 11.13,143.16 11.13,142.48 10.39,141.75 10.26,141.75 9.35,140.83 9.35,120.44 10.08,119.7 10.08,99.59 9.74,99.25 9.74,90.43 11.26,88.9 13.68,88.9 14.54,88.04 14.54,85.5 18.92,81.13 20.56,81.13 24.03,77.66 24.03,75.4 23.5,74.87 23.5,72.11 20.65,69.26 20.65,66.45 21.23,65.86 21.23,65.15 21.92,64.46 22.85,64.46 26.57,60.74 26.57,58.88 33.1,52.35 33.1,48.67 37.77,44 39.49,44 42.54,40.94 49.77,40.94 49.81,40.99 61.42,40.99 61.55,41.12 68.56,41.12 70.24,39.44 111.48,39.44 111.66,39.26 112.71,39.26 112.73,39.28 118.93,39.28 119.5,39.84 122.42,39.84 122.86,39.41 v2(133.58,39.41)
  BOTTOM w0.102: CON5602.7 32.75,180.3 v2(32.59,180.47)
MCK_LED5_IO: length 24.3
  TOP w0.114: CON402.7 192.2,176.25 193.59,174.86 193.59,173.06 194.93,171.71 ; 194.93,171.71 196.76,169.88 203.67,169.88 206.4,172.62 PCON702.11 ; 194.93,171.71 v1(194.93,171.71)
MCK_LED_B: length 290.7
  TOP w0.102: R3091.2 116.75,22.46 v1(115.95,23.26) 115.95,23.78 v2(116.38,24.21)
  IN2 w0.102: v2(31.29,181.55) 31.01,181.83 29.06,181.83 28.74,181.51 24.1,181.51 22.9,180.3 16.86,180.3 11.96,175.41 11.96,174.06 13.82,172.2 13.82,165.92 13.24,165.34 12.34,165.34 9.19,162.2 9.19,143.74 8.12,142.67 8.12,128.38 6.9,127.15 6.9,126.01 7.34,125.57 7.34,120.72 8.86,119.2 8.86,105.32 7.93,104.38 7.93,90.52 9.53,88.92 9.53,86.39 9.63,86.29 9.63,75.71 7.34,73.42 7.34,68.76 8.09,68.01 8.8,68.01 13.09,63.72 19.63,63.72 20.14,63.21 22.38,63.21 25.35,60.24 25.35,58.36 29.16,54.55 29.16,50.41 37.02,42.55 39.07,42.55 43.55,38.07 46.36,38.07 46.49,37.94 46.83,37.94 47.52,38.63 54.82,38.63 55.28,39.08 57.56,39.08 58.45,38.19 98.23,38.19 98.88,37.53 101.37,37.53 102.03,38.19 111.01,38.19 111.69,37.51 115.19,37.51 116.03,38.35 119.25,38.35 v2(120.09,37.51)
  BOTTOM w0.102: v2(116.38,24.21) 116.38,24.43 117.55,25.6 119.35,25.6 120.12,26.37 120.12,30.61 119.25,31.48 119.25,32.81 119.18,32.88 119.18,36.23 120.06,37.12 120.06,37.48 v2(120.09,37.51) ; CON5602.3 30.75,180.47 31.29,181.02 v2(31.29,181.55)
MCK_LED_B_IO: length 18.5
  TOP w0.114: CON402.3 194.2,176.28 195.2,175.28 195.2,173.6 197.19,171.61 v1(197.57,171.61) 202.9,171.61 204.4,173.11 PCON702.15
MCK_LED_G: length 288.8
  TOP w0.102: R3090.2 118.03,24.22 v2(118.02,24.21)
  IN2 w0.102: v2(121.46,37.48) 120.39,38.55 115.95,38.55 115.11,37.71 111.77,37.71 111.09,38.39 101.8,38.39 101.14,37.74 99.06,37.74 98.4,38.39 58.54,38.39 57.64,39.29 55.19,39.29 54.77,38.86 43.05,38.86 39.1,42.8 37.06,42.8 29.36,50.5 29.36,54.64 25.55,58.45 25.55,60.32 22.46,63.41 20.22,63.41 19.71,63.92 13.17,63.92 8.86,68.24 8.15,68.24 7.54,68.84 7.54,73.34 9.83,75.63 9.83,86.37 9.73,86.47 9.73,89 8.72,90.01 8.72,99.67 9.07,100.01 9.07,119.28 7.54,120.8 7.54,125.65 7.1,126.09 7.1,127.07 8.33,128.29 8.33,142.59 9.39,143.66 9.39,162.11 12.42,165.14 13.32,165.14 14.02,165.84 14.02,172.29 12.98,173.33 12.98,175.04 18.04,180.1 22.98,180.1 24.19,181.31 28.82,181.31 29.14,181.63 30.63,181.63 31.12,181.15 31.72,181.15 31.9,181.32 v2(31.9,181.6)
  BOTTOM w0.102: v1(121.7,38.13) 121.7,37.71 v2(121.46,37.48) 120.27,36.28 119.97,36.28 119.58,35.9 119.58,33.11 119.66,33.04 119.66,31.67 120.53,30.79 120.53,26.2 119.32,24.99 118.42,24.99 118.02,24.59 v2(118.02,24.21) ; CON5602.4 31.25,180.42 31.9,181.07 v2(31.9,181.6)
MCK_LED_G_IO: length 20
  TOP w0.114: PCON702.14 204.91,173.1 202.85,171.05 v1(199.42,171.05) 197.24,171.05 194.86,173.44 194.86,175.11 193.7,176.27 CON402.4
MCK_LED_R: length 290.5
  TOP w0.102: v2(117.01,24.21) 117.15,24.35 R3089.2
  IN2 w0.102: v2(32.56,181.58) 32.53,181.58 31.84,180.89 31.03,180.89 30.64,180.49 24.24,180.49 23.23,179.49 19.45,179.49 17.35,177.39 17.35,176.54 16.07,175.26 14.96,175.26 14.5,174.81 14.5,174.45 15.69,173.27 15.69,167.84 19.02,164.5 19.02,160.02 17.96,158.95 14.3,158.95 9.8,154.45 9.8,143.49 8.74,142.43 8.74,120.19 9.47,119.45 9.47,99.84 9.13,99.5 9.13,90.18 11.13,88.18 13.54,88.18 13.93,87.79 13.93,85.25 18.67,80.51 20.29,80.51 22.66,78.14 22.66,74.9 22.89,74.67 22.89,72.42 19.63,69.17 19.63,64.75 19.63,64.58 20.39,63.82 22.63,63.82 25.96,60.49 25.96,58.63 29.8,54.79 29.8,50.64 37.18,43.26 39.22,43.26 42.21,40.28 47.14,40.28 48.15,39.27 54.6,39.27 55.02,39.69 57.81,39.69 58.71,38.8 111.26,38.8 111.94,38.12 114.94,38.12 115.9,39.08 119.68,39.08 v2(120.04,39.44)
  BOTTOM w0.102: v2(32.56,181.58) 32.21,181.23 32.21,181.02 31.75,180.56 CON5602.5 ; v2(117.01,24.21) 117.01,24.32 117.93,25.24 119.28,25.24 120.33,26.29 120.33,30.69 119.46,31.56 119.46,32.89 119.38,32.97 119.38,36.14 120.5,37.26 120.5,38.7 120.8,39.01 v1(120.8,39.82) 120.42,39.82 v2(120.04,39.44)
MCK_LED_R_IO: length 21.4
  TOP w0.114: CON402.5 193.2,176.26 194.41,175.05 194.41,173.37 197.21,170.57 202.9,170.57 205.4,173.07 v1(205.4,174.18) 205.4,174.18 PCON702.13
MCT0: length 3.8
  TOP w0.102: v1(255.27,145.9) 254.88,145.9 254.25,146.52 R3400.1
  TOP w0.508: R3400.1 253.66,147.54 U3401.24
MCT1: length 3.8
  TOP w0.254: R3401.1 255.32,143.47 v1(255.32,143.05)
  TOP w0.508: U3401.21 254.25,144.54 R3401.1
MCT2: length 3.3
  TOP w0.102: v1(255.26,140.43) 254.75,140.94 254.74,140.94 254.74,141.01 R3402.1
  TOP w0.508: U3401.18 253.75,141.54 253.8,141.49 R3402.1
MCT3: length 3.5
  TOP w0.102: R3403.1 254.25,137.99 254.76,137.48 v1(255.26,137.48)
  TOP w0.508: U3401.15 254.16,138.54 R3403.1
ME_AC_PRESENT: length 94.4
  TOP w0.102: v2(178.52,55.51) 178.94,55.93 179.33,55.93 179.37,55.89 180.04,55.89 180.59,56.44 180.68,56.53 181.27,56.53 182.29,57.56 183.24,57.56 184.41,58.73 185.56,58.73 R2459.1 186.54,58.69 187.33,58.69 R2442.2 ; R3037.1 v2(118.42,49.66)
  IN1 w0.102: v2(119.33,44.09) 119.96,44.72 138.77,44.72 139.63,45.58 142.18,45.58 145.62,42.13 147.17,42.13 149.32,44.28 160.49,44.28 161.68,43.09 162.27,43.09 163.25,42.11 171.22,42.11 173.71,44.6 173.71,53.22 175.37,54.88 177.89,54.88 v2(178.52,55.51)
  BOTTOM w0.089: U2000.BB15 180.27,55.76 180.27,55.32 180.08,55.13 179.8,55.13 179.74,55.18 179.44,55.18 179.37,55.11 179.01,55.11 178.91,55.21 178.83,55.21 v2(178.52,55.51)
  BOTTOM w0.102: v2(118.42,49.66) 119.01,49.06 v1(119.01,47.69) 119.01,47.29 119.3,47 119.3,44.11 119.33,44.09 v2(119.33,44.09)
MSM_TP: length 1.3
  TOP w0.102: v6(34.41,133.22) 34.77,133.59 T1001.1
  BOTTOM w0.102: U0300.AW13 34.08,132.9 v6(34.41,133.22)
N16_REST_BACKUP#: length 217.5
  TOP w0.102: U7002.1 96.88,112.4 96.7,112.21 96.7,110.96 v1(96.46,110.73) v2(95.68,109.95) ; v2(192.94,60.6) 197.66,60.6 201.6,64.53 203.28,64.53 210.31,71.57 210.31,79.72 209.7,80.34 209.06,80.34 207.75,81.65 207.75,82.74 207.99,82.98 208.59,82.98 208.93,83.32 209.46,83.32 v2(209.91,82.87) ; v2(187.25,44.85) 187.3,44.8 R2481.1
  IN1 w0.102: v2(187.25,44.85) 186.11,45.99 186.11,57.37 186.66,57.93 191.08,57.93 191.82,58.67 191.82,59.02 192.94,60.14 v2(192.94,60.6)
  IN4 w0.102: v2(209.91,82.87) 209.46,83.32 208.86,83.32 208.53,82.98 207.7,82.98 206.05,81.33 192.4,81.33 188.4,77.33 186.96,77.33 186.12,76.5 183.38,76.5 182.38,77.5 182.38,77.92 181,79.3 178.38,79.3 175.9,76.82 173.95,76.82 173.16,76.03 172.47,76.03 171.72,76.77 160.64,76.77 157.36,73.49 155.18,73.49 151.67,69.98 150.31,69.98 149.61,69.27 146.48,69.27 144.17,66.96 143.01,66.96 141.6,68.37 137.32,68.37 135.8,69.89 135.8,70.9 134.83,71.88 130.69,71.88 126.21,76.35 126.21,76.96 125.08,78.09 123.91,78.09 123.18,78.82 122.48,78.82 118.73,82.57 116.58,82.57 115.56,83.59 115.01,83.59 109.24,89.36 109.24,92.78 96.38,105.64 96.38,109.25 v2(95.68,109.95)
  BOTTOM w0.089: U2000.BD34 181.01,46.27 181.15,46.27 181.32,46.09 183.54,46.09 184.37,45.26 184.71,45.26
  BOTTOM w0.102: 184.71,45.26 184.92,45.26 184.93,45.27 186.83,45.27 v2(187.25,44.85) R2465.2
NC_B4: length 5
  TOP w0.102: U1101.B4 247.05,37.48 247.22,37.66 247.77,37.66 248.81,36.62 250.16,36.62 v1(250.31,36.78) 250.56,36.53 250.96,36.53 R1126.1
NC_B5: length 4.7
  TOP w0.102: U1101.B5 247.27,36.75 247.68,36.75 248.54,35.88 248.72,35.88 R1127.1 248.54,35.2 248.54,34.49 248.75,34.29 248.76,34.29 v1(249.17,33.88)
NC_F19: length 6.7
  TOP w0.076: U1101.F19 245.05,30.5 v4(245.37,30.82)
  BOTTOM w0.102: v4(245.37,30.82) 245.74,31.19 246.16,31.19 246.76,30.58 246.76,28.21 246.61,28.06 R1124.2 246.61,26.88 v1(247.07,26.42)
NC_G2: length 6.8
  TOP w0.102: R1125.1 242.09,42.64 v1(242.45,42.27) 242.59,42.13 243.84,42.13 244.68,41.28 244.68,39.24 244.53,39.08 244.53,38.57 U1101.G2
Net_105: length 0.3
  BOTTOM w0.203: 168.35,62.77 168.35,62.52
Net_116: length 0.3
  BOTTOM w0.203: 161.65,41.14 161.65,41.44
Net_120: length 0.3
  BOTTOM w0.203: 162.72,41.14 162.5,41.27
Net_134: length 0.3
  BOTTOM w0.203: 166.07,62.77 166.33,62.77
Net_417: length 0.3
  BOTTOM w0.203: 126.13,183.07 125.8,183.07
Net_418: length 0.3
  BOTTOM w0.203: 126.13,170.27 126.46,170.22
Net_420: length 0.3
  BOTTOM w0.203: 108.41,183.07 108.41,183.4
Net_422: length 0.3
  BOTTOM w0.203: 140.84,159.94 140.84,159.61
Net_423: length 0.3
  BOTTOM w0.203: 142.37,177.4 142.37,177.73
Net_425: length 0.3
  BOTTOM w0.203: 153.64,120.57 153.64,120.24
Net_426: length 0.3
  BOTTOM w0.203: 140.84,120.57 140.84,120.9
Net_427: length 0.3
  BOTTOM w0.203: 140.84,150.35 140.84,150.02
Net_429: length 0.3
  BOTTOM w0.203: 117.18,100.12 117.18,99.79
Net_430: length 0.3
  BOTTOM w0.203: 117.18,112.92 117.18,113.25
Net_1506: length 0.4
  BOTTOM w0.203: 22.88,125.09 22.88,125.44
Net_3353: length 0.3
  BOTTOM w0.203: 134.89,100.17 134.89,99.84
Net_3354: length 0.3
  BOTTOM w0.203: 134.89,112.97 134.89,113.3
Net_3426: length 0.3
  BOTTOM w0.203: 92.7,121.9 92.7,122.24
Net_3427: length 0.3
  BOTTOM w0.203: 93.5,121.9 93.5,122.24
Net_3432: length 0.3
  BOTTOM w0.203: 100.7,122.7 100.7,123.04
Net_3441: length 0.3
  BOTTOM w0.203: 99.1,122.7 99.1,123.04
Net_3443: length 0.3
  BOTTOM w0.203: 103.9,121.9 103.9,122.24
Net_3455: length 0.3
  BOTTOM w0.203: 103.9,122.7 103.9,123.04
Net_3465: length 0.3
  BOTTOM w0.203: 101.5,121.9 101.5,122.24
Net_3469: length 0.3
  BOTTOM w0.203: 103.1,121.9 103.1,122.24
Net_3476: length 0.3
  BOTTOM w0.203: 101.5,122.7 101.5,123.04
Net_3481: length 0.3
  BOTTOM w0.203: 103.1,122.7 103.1,123.04
Net_3486: length 0.3
  BOTTOM w0.203: 91.1,125.9 91.44,125.9
Net_3487: length 0.3
  BOTTOM w0.203: 90.3,125.9 90.63,125.81
Net_3489: length 0.3
  BOTTOM w0.203: 91.1,127.5 91.44,127.5
Net_3490: length 0.3
  BOTTOM w0.203: 90.3,127.5 90.63,127.41
Net_3491: length 0.3
  BOTTOM w0.203: 90.3,128.3 90.63,128.21
Net_3496: length 0.3
  BOTTOM w0.203: 91.1,124.3 91.44,124.26
Net_3497: length 0.3
  BOTTOM w0.203: 90.3,124.3 90.63,124.21
Net_3506: length 0.3
  BOTTOM w0.203: 91.1,123.5 91.43,123.59
Net_3514: length 0.3
  BOTTOM w0.203: 91.1,128.3 91.44,128.3
Net_3517: length 0.3
  BOTTOM w0.203: 91.1,129.9 91.1,130.24
Net_3518: length 0.3
  BOTTOM w0.203: 90.3,129.9 90.3,130.24
Net_3519: length 0.3
  BOTTOM w0.203: 90.3,130.7 90.57,130.48
Net_3520: length 0.3
  BOTTOM w0.203: 91.1,130.7 91.44,130.7
Net_3526: length 0.3
  BOTTOM w0.203: 90.3,135.5 90.3,135.16
Net_3527: length 0.3
  BOTTOM w0.203: 90.3,134.7 90.63,134.61
Net_3529: length 0.3
  BOTTOM w0.203: 91.1,134.7 91.44,134.7
Net_3530: length 0.3
  BOTTOM w0.203: 91.1,133.1 91.1,133.44
Net_3532: length 0.3
  BOTTOM w0.203: 90.3,132.3 90.3,132.64
Net_3533: length 0.3
  BOTTOM w0.203: 90.3,133.1 90.57,132.88
Net_3535: length 0.3
  BOTTOM w0.203: 91.1,135.5 91.1,135.16
Net_3547: length 0.3
  BOTTOM w0.203: 91.1,132.3 91.1,132.64
Net_3582: length 0.3
  BOTTOM w0.203: 115.1,121.9 115.1,122.24
Net_3609: length 0.3
  BOTTOM w0.203: 122.3,159.5 122.3,159.84
Net_3611: length 0.3
  BOTTOM w0.203: 119.9,160.3 120.24,160.3
Net_3618: length 0.3
  BOTTOM w0.203: 128.7,151.5 128.36,151.54
NO_REBOOT_MODE: length 12
  BOTTOM w0.089: 184.71,48.99 182.63,48.99 182.55,48.9 181.8,48.9 181.63,49.07 181.26,49.07 U2000.BD28
  BOTTOM w0.102: 184.71,48.99 188.27,48.99 R2413.1 188.9,49.62 190.29,49.62 R2405.2 190.92,49 191.92,49 192.01,48.91 v1(192.27,48.91)
NTC_A: length 6.5
  BOTTOM w0.102: R8081.2 16.41,172.41 13.39,172.41 12.67,173.12 v1(12.4,173.12) 12.4,173.27 11.87,173.8 U8000.15
NTC_B: length 6.2
  BOTTOM w0.102: R8031.2 15.8,182.34 15.1,182.34 15,182.24 15,181.42 v1(14.48,180.91) 14.66,180.73 14.66,179.5 13.73,178.58 U8000.3
NVDD_GND_SENSE: length 126.4
  TOP w0.203: SR8703.2 155.52,83.22 T7002.1 v2(155.52,81.93) 156.1,81.36 SR8707.2
  IN1 w0.203: v6(97.97,138.57) 97.97,138.7 97.56,139.11 97.24,139.11 96.83,138.69 96.83,136.41 95.86,135.44 95.86,133.07 96.73,132.19 97.22,132.19 97.5,131.92 97.89,131.92 98.62,131.19 98.62,128.69 97.71,127.78 97.71,121.43 96.57,120.28 96.57,117.82 96.22,117.47 96.22,101.8 106.38,91.64 106.38,84.69 108.3,82.77 111.6,82.77 112.66,81.71 116.68,81.71 117.53,80.86 121.27,80.86 124.25,83.84 136.53,83.84 140.01,80.36 142.63,80.36 145.15,82.88 145.71,82.88 147.62,84.79 149.29,84.79 149.84,84.24 153.98,84.24 155.52,82.69 v2(155.52,81.93)
  BOTTOM w0.254: U7000.AW23 97.97,138.97 v6(97.97,138.57) ; U8700.10 154.13,81.05 154.9,81.82 155.41,81.82 v2(155.52,81.93)
NVDD_SENSE: length 132.8
  IN1 w0.203: v6(97.36,138.59) 97.18,138.41 97.18,136.26 96.16,135.24 96.16,133.19 96.86,132.5 97.39,132.5 97.59,132.3 98.1,132.3 98.98,131.42 98.98,128.61 98.02,127.65 98.02,121.3 96.95,120.23 96.95,117.7 96.52,117.26 96.52,101.93 106.68,91.76 106.68,84.81 108.42,83.07 111.75,83.07 112.8,82.02 116.9,82.02 117.73,81.19 121.17,81.19 124.14,84.16 136.72,84.16 140.13,80.74 142.55,80.74 145.04,83.24 145.04,83.23 145.63,83.23 147.5,85.1 149.45,85.1 150,84.54 154.18,84.54 155.29,83.44 158.61,83.44 v2(159.69,82.36)
  BOTTOM w0.254: v6(97.36,138.59) 97.57,138.81 97.57,139.43 U7000.AY23 ; R8715.1 160.38,83.53 159.69,82.85 v2(159.69,82.36) 159.69,80.6 T7001.1 159.14,80.11 157.28,80.11 156.63,80.76 154.48,80.76 154.26,80.54 U8700.11
OC0#: length 111.7
  TOP w0.102: U5200.13 253.03,56.03 v2(253.09,55.97)
  IN1 w0.102: v2(204.3,37.05) 209.78,42.53 209.78,45.43 213.8,49.45 213.8,56.76 214.21,57.16 217.97,57.16 v2(220.14,59.34)
  IN2 w0.102: v2(204.3,37.05) 204.25,37 202.59,37 201.71,36.12 200.07,36.12 199.33,35.38 196.12,35.38 193.98,33.24 192.46,33.24 191.67,34.03 178.37,34.03 178.32,34.08 171.47,34.08 v2(170.87,34.69)
  BOTTOM w0.089: 170.87,37.73 170.87,39.29 171.41,39.83 171.41,41.38 171.47,41.43 171.47,41.82 U2000.AD43
  BOTTOM w0.102: v2(170.87,34.69) 170.45,35.11 170.45,36.35 R2118.2 170.87,37.73 ; v2(220.14,59.34) 220.79,59.99 220.79,60.44 v1(220.82,60.47) 225.17,60.47 227.51,58.13 229.7,58.13 230.48,57.35 231.82,57.35 232.84,56.33 234.07,56.33 234.52,56.78 252.28,56.78 v2(253.09,55.97)
OC1#: length 211.8
  IN1 w0.102: v2(30.79,41.62) 32.94,39.46 34.11,39.46 34.98,40.33 48.82,40.33 51.62,37.54 77.05,37.54 78.78,39.27 95.82,39.27 96.22,39.67 110.98,39.67 111.46,39.19 113.26,37.38 115.06,37.38 116.11,36.34 119.93,36.34 120.01,36.42 126.67,36.42 126.95,36.13 168.47,36.13 169.11,35.49 169.11,35.17 v2(169.6,34.69)
  IN4 w0.102: v2(30.79,41.62) 31.24,42.08 31.24,55.13 23.78,62.59 23.78,66.93 23.03,67.68 22.66,67.68 22.1,68.24 22.1,71.14 22.78,71.83 22.78,74.39 22.4,74.77 22.4,77.84 21.03,79.21 15.93,79.21 15.77,79.06 14.66,79.06 12.71,77.11 11.5,77.11 10.47,76.07 10.47,73.93 v2(10.66,73.74)
  BOTTOM w0.089: 170.41,37.73 170.41,39.42 171.03,40.04 171.03,41.35 170.94,41.45 170.94,41.59 170.97,41.63 170.97,42.43 U2000.AD42
  BOTTOM w0.102: v2(169.6,34.69) 170.04,35.13 170.04,36.32 R2117.2 170.41,37.58 170.41,37.73 ; v2(10.66,73.74) 10.66,73.43 10.47,73.25 CON6700.24
OC2#: length 137.7
  TOP w0.102: v2(162.1,29.81) 162.23,29.94 v1(162.23,31.59) 162.51,31.87 163.86,31.87 164.17,32.19 166,32.19 166.37,32.56 166.37,34.35 166.24,34.48 166.24,36.39 166.62,36.77 R2119.2 168.94,39.03 170.02,39.03 171.22,40.23 171.22,41.24 172.02,42.04 172.02,42.38 171.22,43.18 171.22,43.48 v2(170.62,44.09) ; U5501.3 247.57,62.31 246.71,63.17 244.89,63.17 244.55,63.51 243.04,63.51 242.68,63.15 242.68,59.73 242.21,59.25 241.07,59.25 240.54,58.72 238.38,58.72 238.18,58.51 226.87,58.51 226.62,58.26 v2(225.35,58.26)
  IN2 w0.102: v2(162.1,29.81) 162.48,29.43 163.86,29.43 166.09,27.19 169.29,27.19 169.73,26.75 182.72,26.75 183.24,26.23 196.15,26.23 197.04,27.12 204.14,27.12 205.92,28.9 207.06,28.9 207.86,29.7 207.86,30.84 208.51,31.49 208.77,31.49 210.38,33.1 211.57,33.1 214.91,36.44 217.32,36.44 218.02,37.14 218.02,37.16 218.02,37.17 218.02,37.85 218.44,38.27 218.44,38.92 218.55,39.02 218.55,44.54 219.24,45.23 219.24,47.2 221.8,49.76 221.8,53.63 225.35,57.18 v2(225.35,58.26)
  BOTTOM w0.102: U2000.AD39 170.97,44.09 v2(170.62,44.09)
OP_SD#: length 222.9
  TOP w0.102: Q3601.2 2.72,72.23 3.05,72.56 4.52,72.56 6.17,70.92 v1(6.17,70.13) 6.17,67.3 7.24,66.23 v2(8.04,66.23)
  IN1 w0.102: v2(38.07,41.19) 38.72,40.54 48.31,40.54 48.56,40.78 61.55,40.78 62.13,41.37 89.55,41.37 90.52,42.33 96.81,42.33 97.39,41.75 103.76,41.75 105.64,43.63 110.58,43.63 112.21,42 123.79,42 124.22,41.57 130.7,41.57 130.77,41.65 132.4,41.65 133,41.04 135.1,41.04 136.29,39.84 145.22,39.84 146.82,38.24 159.26,38.24 159.84,38.83 170.45,38.83 172.56,40.94 178.27,40.94 179.27,39.93 179.97,39.93 182.78,42.74 182.78,49.09 183.54,49.85 183.54,51.71 184.36,52.53 v2(184.36,52.73)
  IN2 w0.102: v2(8.04,66.23) 8.04,65.3 8.44,64.9 9.17,64.9 10.6,63.47 11.91,63.47 12.67,62.7 19.21,62.7 19.72,62.19 21.95,62.19 24.31,59.84 24.31,57.96 28.05,54.21 28.05,50.08 36.94,41.19 v2(38.07,41.19)
  BOTTOM w0.089: U2000.BD24 181.15,51.46 183.55,51.46 183.86,51.77 183.86,52.56 184.04,52.73 v2(184.36,52.73) 184.7,53.08 184.71,53.08
  BOTTOM w0.102: 184.71,53.08 R2420.2
OPC_RCOMP: length 4.5
  TOP w0.203: v1(18.57,145.86) 18.81,146.11 v6(18.81,146.48)
  TOP w0.254: R1014.1 18.8,146.5 v6(18.81,146.48)
  BOTTOM w0.203: v6(18.81,146.48) 19.66,145.63 21.16,145.63 21.24,145.71 U0300.BT29
OPCE_RCOMP: length 7
  BOTTOM w0.216: U0300.BR25 21.85,142.17 21.25,142.17 21.24,142.18
  BOTTOM w0.254: 21.24,142.18 19.45,142.18 19.45,142.19 19.37,142.19 19.32,142.23 19.31,142.23 19.28,142.27 19.12,142.44 16.68,142.44 R1015.1
OPCE_RCOMP2: length 6.3
  BOTTOM w0.229: U0300.BP25 22.49,142.95 20.09,142.95 18.97,144.08 v1(18.72,144.08) 18.31,144.08 R1016.1
OUT_AUXN: length 25.5
  TOP w0.114: v1(249.3,112.77) 249.12,112.95 ; 249.12,112.95 249.45,113.27 249.71,113.27 249.82,113.16 249.82,113.06 R4607.2 250.67,113.17 252.57,113.17 252.84,113.43 252.84,113.71 v2(253.04,113.91) ; 249.12,112.95 248.84,112.67 248.84,112.51 247.3,110.96 247.3,110.62 247.42,110.5 U4601.27
  IN1 w0.089: CON4601.17 259.18,114.81 259.18,114.87 259.07,114.99 255.9,114.99 255.54,115.34 255.54,117.51 255.45,117.59 255.03,117.59 254.94,117.51 254.94,115.82 254.75,115.62 254.18,115.62 253.99,115.82 253.99,117.51 253.9,117.59 253.48,117.59 253.39,117.51 253.39,115.31 252.73,114.65 252.73,114.21 v2(253.04,113.91)
OUT_AUXP: length 25.6
  TOP w0.114: v2(252.4,113.91) 252.55,113.76 252.6,113.71 252.6,113.53 252.48,113.4 250.72,113.4 R4608.2 249.77,113.51 249.35,113.51 248.61,112.76 248.61,112.61 247.86,111.85 ; 247.86,111.85 v1(247.68,112.03) ; 247.86,111.85 247.07,111.06 247.07,110.61 246.92,110.47 U4601.28
  IN1 w0.089: CON4601.15 259.26,115.17 255.97,115.17 255.72,115.42 255.72,117.58 255.52,117.77 254.96,117.77 254.76,117.58 254.76,115.89 254.68,115.8 254.26,115.8 254.17,115.89 254.17,117.58 253.97,117.77 253.41,117.77 253.22,117.58 253.22,115.38 252.56,114.73 252.56,114.07 v2(252.4,113.91)
OUT_HPD: length 22.1
  TOP w0.102: U4601.11 v2(247.92,102.32) 248.29,101.95 249.1,101.95 250.09,102.94 v1(250.27,102.94)
  IN2 w0.102: CON4601.18 260.42,113.33 260.42,112.73 250.63,102.94 248.54,102.94 v2(247.92,102.32)
PCBEEP: length 292.6
  TOP w0.102: v2(33.33,39.97) v2(30.66,39.97) ; v2(19.36,80.1) 19.36,79.72 19.61,79.47 R3606.2 ; v2(109.53,46.77) 112.07,44.23 112.07,43.31 111.91,43.15 U3001.34
  IN1 w0.102: v2(193.62,50.79) 193.85,50.56 193.85,42.67 192.15,40.97 192.15,30.22 191.26,29.33 191.26,27.3 192.71,25.85 192.71,25.34 192.34,24.97 178.93,24.97 176.07,27.83 157.85,27.83 157.08,28.6 134.98,28.6 134.2,27.82 117.48,27.82 v2(117.07,28.23)
  IN4 w0.102: v2(30.66,39.97) 30.79,39.97 31.65,40.84 31.65,55.3 24.23,62.72 24.23,67.06 23.2,68.09 22.82,68.09 22.5,68.41 22.5,70.68 23.29,71.47 23.29,74.59 22.86,75.02 22.86,78.03 22.71,78.18 22.71,78.53 20.63,80.61 19.86,80.61 v2(19.36,80.1) ; v2(33.33,39.97) 33.2,39.97 32.61,40.56 32.61,42.09 34.14,43.61 34.14,52.25 35.92,54.03 37.16,54.03 41.84,49.34 100.75,49.34 102.48,47.61 108.68,47.61 109.49,46.8 109.49,46.8 v2(109.53,46.77)
  BOTTOM w0.089: 184.71,50.68 184.24,50.68 184.17,50.75 183.57,50.75 183.57,50.74 182.92,50.74 182.28,50.1 181.2,50.1 U2000.BD26
  BOTTOM w0.102: 184.71,50.68 188.28,50.68 R2460.2 188.9,50.46 190.29,50.46 R2449.2 191.22,50.98 191.49,50.98 191.84,50.62 192.47,50.62 192.64,50.79 v2(193.62,50.79) ; v2(117.07,28.23) 116.71,28.59 116.71,32.25 115.6,33.37 114,33.37 112.4,34.97 v1(112.16,34.97) 110.96,34.97 108.92,37.01 108.92,42.05 109.4,42.54 109.4,46.64 v2(109.53,46.77)
PCH_BATL#: length 8.5
  BOTTOM w0.089: 184.71,59.5 184.49,59.5 184.29,59.3 184.29,58.9 182.72,57.32 182.23,57.32 182.02,57.11 U2000.BD13
  BOTTOM w0.102: 184.71,59.5 186.16,59.5 v1(186.89,58.77) 187.49,58.77 R2444.2
PCH_BKLT_EN: length 363
  TOP w0.102: R4594.1 v1(33.15,183.13) 33.15,182.14 v2(33.4,181.88)
  IN1 w0.102: v2(177.51,34.71) 177.95,34.28 182.77,34.28 182.91,34.42 182.91,36.69 183.87,37.64 v2(183.87,37.94)
  IN2 w0.102: v2(183.87,37.94) 183.57,38.24 182.76,38.24 182.57,38.44 181.21,38.44 180.74,37.97 177.37,37.97 176.81,37.41 168.63,37.41 167.67,38.37 155.84,38.37 152.03,42.18 150.13,42.18 149.74,41.79 149.74,40.84 147.67,38.78 124.63,38.78 122.92,37.07 119.95,37.07 118.88,38.14 117.51,38.14 117.22,37.85 117.22,37.77 116.55,37.1 111.52,37.1 111.04,37.58 107.05,37.58 106.39,36.92 98.24,36.92 97.57,37.6 49.1,37.6 48.22,36.72 42.34,36.72 41,38.07 41,40.05 38.9,42.14 36.86,42.14 28.75,50.25 28.75,54.38 24.94,58.19 24.94,60.07 22.21,62.8 19.97,62.8 19.46,63.31 12.92,63.31 8.63,67.61 8.17,67.61 8.17,67.61 8,67.61 7.83,67.61 6.92,68.52 6.92,73.58 9.22,75.88 9.22,85.81 8.48,86.55 8.48,87.64 7.7,88.43 7.7,88.63 7.52,88.81 7.52,104.54 8.46,105.48 8.46,117.68 6.91,119.23 6.91,123.78 6.1,124.59 6.1,125.16 4.67,126.59 4.67,139.24 7.92,142.49 7.92,142.76 8.99,143.83 8.99,162.28 12.25,165.55 13.16,165.55 13.61,166.01 13.61,172.01 11.76,173.86 11.76,175.49 16.78,180.51 22.81,180.51 24.02,181.71 28.65,181.71 28.97,182.03 33.25,182.03 v2(33.4,181.88)
  BOTTOM w0.089: 177.03,37.73 177.03,37.91 176.65,38.28 176.57,38.28 175.07,39.78 175.07,40.68 175.4,41.02 175.4,41.3 175.25,41.45 U2000.AM44
  BOTTOM w0.102: R2360.2 177.37,34.57 v2(177.51,34.71) 177.13,35.1 177.13,37.08 177.03,37.18 177.03,37.73
PCH_C1: length 16.8
  BOTTOM w0.089: 156.52,64.76 157.89,64.76 158.48,64.17 159.25,64.17 160.35,63.08
  BOTTOM w0.102: 160.35,63.08 U2000.C1 ; 156.52,64.76 156.02,64.76 155.55,65.24 155.55,73.07 156.48,74.01 T2502.1
PCH_CPUPWRGD: length 9
  BOTTOM w0.089: 173.16,65.9 173.39,65.68 173.39,65.58 173.53,65.43 173.53,65.25 174.73,64.05 174.73,62.63 174.84,62.51 174.84,62.03 175.06,61.8 U2000.AM3
  BOTTOM w0.114: 173.16,65.9 173.16,68.32 v1(173.28,68.45) 173.43,68.6 R2462.1
PCH_D1: length 17.7
  BOTTOM w0.089: 156.52,65.04 157.99,65.04 158.65,64.38 159.54,64.38 160.66,63.27
  BOTTOM w0.102: 156.52,65.04 156.05,65.04 155.79,65.3 155.79,72.88 158.35,75.44 T2503.1 ; 160.66,63.27 U2000.D1
PCH_DDIC_CTRCLK: length 53.3
  TOP w0.102: v2(237.67,39.87) 237.8,39.87 238.54,39.13 238.54,38.58 U1101.Y2
  TOP w0.114: v2(253.79,77.17) Q4803.2 251.24,77.17 R4817.2
  IN1 w0.076: v2(237.67,39.87) 237.67,40.13 239.03,41.5 241,41.5 241.2,41.7 241.2,42.65 243.01,44.46 243.01,45.07 244.03,46.08 244.03,46.27 245.5,47.74 245.5,48.35 246.16,49 246.16,55.11 251.65,60.6 251.65,63.83 252.81,64.99 v2(252.81,68.14)
  IN4 w0.076: v2(253.79,77.17) 252.81,76.19 252.81,73.81 254.85,71.76 254.85,70.16 253.55,68.85 253.1,68.85 252.81,68.56 v2(252.81,68.14)
  BOTTOM w0.114: v2(253.79,77.17) 253.65,77.31 v1(253.04,77.31)
PCH_DDIC_CTRLDATA: length 52.5
  TOP w0.114: v2(253.39,73.87) 253.39,73.86 253.38,73.87 Q4802.2 251.45,73.87 251.28,74.04 R4818.2 ; U1101.Y1 238.77,39.51 v2(238.43,39.84)
  IN1 w0.076: v2(253.54,68.21) 253.26,67.93 253.26,64.8 252.11,63.64 252.11,60.41 246.65,54.96 246.65,48.8 245.99,48.14 245.99,47.54 244.49,46.03 244.49,45.89 243.48,44.89 243.48,44.28 241.66,42.45 241.66,41.51 241.13,40.99 239.17,40.99 238.61,40.43 238.61,40.3 238.79,40.12 238.94,40.12 239.4,40.58 239.85,40.58 239.93,40.51 239.93,39.82 239.73,39.62 238.66,39.62 v2(238.43,39.84)
  IN4 w0.076: v2(253.39,73.87) 253.39,74.01 253.52,74.14 254.21,74.14 254.34,74.01 254.34,72.92 255.31,71.95 255.31,69.97 v2(253.54,68.21)
  BOTTOM w0.114: v1(252.7,68.9) 252.85,68.9 v2(253.54,68.21)
PCH_DEVSLP1: length 141.4
  TOP w0.102: R5104.1 56.07,26.75 56.19,26.87 v1(56.19,28.66) 56.19,29.21 60.11,33.13 60.11,38.83 v2(59.5,39.44)
  IN1 w0.102: v2(59.5,39.44) 60.16,39.44 60.56,39.84 68.63,39.84 69.17,39.3 78.24,39.3 78.61,39.67 95.53,39.67 95.94,40.07 111.15,40.07 111.42,39.8 113.43,37.79 115.31,37.79 116.35,36.75 119.76,36.75 119.84,36.82 127.49,36.82 127.77,36.54 172,36.54 173.05,35.49 173.05,35.17 v2(173.53,34.69)
  BOTTOM w0.089: 172.26,37.85 172.12,37.99 172.12,40.71 172.27,40.85 172.27,41.38 172.24,41.41 172.24,41.87 U2000.AG43
  BOTTOM w0.102: v2(173.53,34.69) 173.53,34.38 R2102.2 173.25,34.36 173.06,34.55 173.06,37.05 172.26,37.85
PCH_DEVSLP4: length 11.8
  TOP w0.102: R2164.2 166.23,37.22 166.75,37.22 169.05,39.51 v1(169.7,39.51) 170.22,39.51 171.02,40.32 171.02,41.33 171.78,42.09 171.78,42.33 170.72,43.39 v2(170.63,43.39)
  BOTTOM w0.089: U2000.AB42 170.1,42.7 170.22,42.81 170.22,43.13 170.48,43.39 v2(170.63,43.39)
PCH_DEVSLP5: length 6.4
  BOTTOM w0.089: U2000.AB43 170.13,41.82 169.96,41.65 169.96,41.44 169.99,41.42 169.99,40.94 169.63,40.59 169.63,39.01 169.63,38.87 169.63,38.86 168.71,37.94 168.7,37.94 168.53,37.76 168.51,37.76 168.48,37.73
  BOTTOM w0.102: 168.48,37.73 168.07,37.32 168.07,37.28 R2124.2
PCH_DEVSLP6: length 24.2
  TOP w0.102: v2(169.37,45.77) 168.76,46.39 168.76,46.77 168.39,47.13 167.49,47.13 167.22,47.4 166.31,47.4 164.25,45.34 164.25,45.2 163.12,44.07 163.12,43.55 162.69,43.12 161.53,43.12 v1(160.22,41.81) 159.82,41.81 159.22,41.22 158.42,41.22 156.46,39.26 156.46,34.03 R2123.2
  BOTTOM w0.089: v2(169.37,45.77) 169.4,45.77 169.7,45.48 U2000.AB36
PCH_DEVSLP7: length 12.2
  TOP w0.102: R2122.2 164.39,37.15 164.89,37.15 166.11,38.37 166.6,38.37 v1(167.76,39.52) 168.19,39.52 168.57,39.91 168.57,40.63 167.96,41.24 167.96,41.75 168.62,42.4 168.62,43.72 v2(169.37,44.47)
  BOTTOM w0.102: U2000.AB39 169.94,43.91 169.4,44.45 169.4,44.46 169.39,44.47 v2(169.37,44.47)
PCH_DGPU_EN: length 29.4
  TOP w0.102: v2(197.08,47.36) 197.08,47.45 v1(196.63,47.9) 195.82,48.71 195.47,48.71 194.62,47.86 192.9,47.86 192.79,47.97 R2407.2 R2427.1 192.08,47.56 v2(192.08,47.24)
  IN4 w0.102: v2(192.08,47.24) 191.93,47.39 185.43,47.39 183.74,49.08 175.32,49.08 v2(174.67,49.73)
  BOTTOM w0.102: v2(197.08,47.36) 197.49,47.77 R2496.2 197.74,48.53 R2495.2 ; U2000.AL27 174.42,49.97 v2(174.67,49.73)
PCH_DP_PD#: length 69.9
  TOP w0.102: Q1302.2 216.46,48.48 216.16,48.18 v2(215.91,48.18) ; v2(179.08,32.66) 179.02,32.59 R2370.2
  IN2 w0.102: v2(201.5,34.84) 201.21,35.13 200.1,35.13 199.4,34.42 196.5,34.42 193.93,31.84 190.09,31.84 189.99,31.74 189.3,31.06 188.7,31.06 188.69,31.05 180.69,31.05 v2(179.08,32.66)
  IN3 w0.102: v2(201.5,34.84) 201.5,34.66 201.73,34.43 202.3,34.43 202.92,35.05 202.92,35.39 203.73,36.2 206.12,36.2 207.02,37.1 210.75,37.1 210.79,37.06 217.5,37.06 217.75,37.31 217.75,37.99 218.15,38.39 218.15,38.79 217.74,39.2 217.74,45.63 215.91,47.46 v2(215.91,48.18)
  BOTTOM w0.089: 179.79,37.73 179.79,38.26 179.2,38.85 178.96,38.85 178.79,39.01 177.92,39.01 177.16,39.77 177.16,40.24 176.85,40.55 176.85,41.33 176.78,41.39 176.78,41.87 U2000.AT43
  BOTTOM w0.102: v2(215.91,48.18) 216.14,48.18 216.85,47.46 v1(217.09,47.46) ; v2(179.08,32.66) 179.79,33.37 179.79,37.73
PCH_DRAM_RESET#: length 15.2
  TOP w0.102: R2478.1 187.25,62.3 187.25,61.28 186.92,60.95 184.06,60.95 183.59,60.48 183.59,58.85 182.7,57.96 182.12,57.96 181.33,57.17 v1(180.9,57.17) 180.65,57.17 180.02,56.54 v2(179.83,56.54) ; R2478.1 R2452.1 R2485.2 ; R2478.1 C2402.1
  BOTTOM w0.089: U2000.BC14 179.89,56.6 v2(179.83,56.54)
PCH_DSW_PWROK: length 11.7
  TOP w0.102: R2492.2 R2476.1 183.22,64.42 183.22,61.68 182.72,61.18 182.1,61.18 v1(181.98,61.06) 181.35,60.43 180.64,60.43 179.96,59.75 179.96,59.29 179.66,58.99 179.49,58.99 178.82,58.99 v2(178.38,58.56)
  BOTTOM w0.089: v2(178.38,58.56) 178.01,58.19 U2000.AV11
PCH_EDP_BKLTCTL: length 16.4
  TOP w0.102: R2140.1 v1(158.67,37.66) 158.67,38.68 160.05,40.05 160.05,40.05 160.96,40.95 162.23,40.95 164.37,43.1 164.37,44.47 165.01,45.1 165.01,45.24 165.94,46.17 167.54,46.17 v2(168.2,45.51)
  BOTTOM w0.089: U2000.W36 168.83,45.31 168.39,45.31 v2(168.2,45.51)
PCH_EDP_BKLTEN: length 20.3
  TOP w0.102: R2150.1 157.35,34.86 157.35,36.34 R2148.1 v1(157.79,39.21) 157.79,39.36 158.67,40.25 159.97,40.25 160.87,41.15 162.14,41.15 164.17,43.18 164.17,44.55 164.68,45.06 164.68,45.2 165.86,46.37 167.97,46.37 v2(168.22,46.12)
  BOTTOM w0.102: v2(168.22,46.12) 168.79,46.12 U2000.W35
PCH_EN_PWR: length 51.9
  IN4 w0.102: v2(217.25,77.14) 217.25,76.06 214.84,73.65 214.84,66.31 215.44,65.71 215.44,61.77 213.12,59.45 208.7,59.45 208.07,58.81 v2(204,58.81)
  BOTTOM w0.102: R2495.1 199.57,49.5 R2498.1 200.33,50.26 200.95,50.88 204.67,50.88 205.74,51.95 205.74,54.93 204,56.67 v2(204,58.81) ; v2(217.25,77.14) 216.33,78.05 216.33,78.6 v1(216.3,78.63) 215.54,79.39 215.12,79.39 213.28,81.23 SR9104.1
PCH_FLASH_DESCRIPTOR: length 82.2
  TOP w0.102: v2(135.08,44.09) 135.08,44.38 133.35,46.11 129.86,46.11 129.51,46.45 128.04,46.45 126.17,44.58 125.7,44.58 125.34,44.22 125.34,43.91 125.04,43.6 124.7,43.6 124.46,43.84 124.46,44.24 124.72,44.5 U3001.2 ; D2301.1 181.08,73.47 180.63,73.02 178.03,73.02 v1(177.92,72.91) 177.72,72.71 177.72,71.77 176.7,70.76 174.98,70.76 174.52,70.29 174.52,68.39 174.38,68.26 174.38,66.01 v2(174.48,65.91)
  IN2 w0.102: v2(135.08,44.09) 135.51,44.52 135.51,46.53 135.85,46.87 140.84,46.87 144.13,50.16 144.13,53.24 144.73,53.84 149.84,53.84 150.7,54.7 150.7,57.31 152.85,59.47 154.86,59.47 158.15,62.75 158.15,63.57 159.16,64.58 168.62,64.58 170.53,66.49 173.9,66.49 v2(174.48,65.91)
PCH_GPP_F22: length 10.9
  TOP w0.102: v2(168.21,44.21) 167.76,43.75 167.76,42.59 167.41,42.24 167.41,40.28 164.91,37.78 v1(164.49,37.78) 163.9,37.78 163.39,37.27 163.39,37.04 R2131.2
  BOTTOM w0.102: v2(168.21,44.21) 168.64,43.78 U2000.W39
PCH_GPP_F23: length 6.9
  BOTTOM w0.089: U2000.V44 167.95,41.4 167.91,41.35 167.91,40.88 167.58,40.56 167.58,40.14 167.58,40.14 167.58,39.85 166.68,38.94 166.03,38.3 165.13,38.3 164.62,37.78 164.62,37.73
  BOTTOM w0.102: R2146.1 164.26,37.02 164.26,37.38 164.62,37.73
PCH_GSXDIN: length 11.1
  BOTTOM w0.089: 166.69,40.83 166.69,41.19 166.95,41.45 166.95,42.18 166.58,42.55 U2000.R42
  BOTTOM w0.102: 166.69,40.83 166.69,40.22 166.04,39.57 166.03,39.57 165.65,39.19 164.58,39.19 164.34,38.95 163.57,38.95 162.58,37.96 161.66,37.96 v1(161.48,37.79) 160.87,37.17 160.87,36.48 160.72,36.33 160.72,36.17 R2261.1
PCH_GSXSLOAD: length 11.3
  TOP w0.102: R2248.2 160.88,37.2 v1(160.88,37.82) 160.88,38.51 165.52,43.15 165.52,44.58 v2(166,45.06)
  BOTTOM w0.102: v2(166,45.06) 166.34,45.41 U2000.R36
PCH_GSXSRST#: length 3
  TOP w0.102: v1(166.01,44.21) 166.01,43.48 v2(166.01,43.48) 166.31,43.18 166.31,42.57 166.29,42.56 R2260.1
  BOTTOM w0.089: v2(166.01,43.48) 166.19,43.48 U2000.R41
PCH_H_TRST#: length 8.8
  TOP w0.102: v2(178.87,60.24) 178.87,60.5 178.89,60.52 178.89,60.89 178.65,61.13 177.98,61.13 177.17,61.93 177.17,65.48 v1(177.8,66.11) 177.85,66.16 R2322.2
  BOTTOM w0.089: U2000.AY5 178.87,60.39 v2(178.87,60.24)
PCH_HDMI_DDC_CLK: length 84.5
  TOP w0.114: v2(182.31,69.1) 182.31,69.33 R2128.2 181.81,69.4 181.72,69.31 R2156.1
  IN1 w0.076: v2(182.31,69.1) 182.63,68.78 184.14,68.78 184.85,68.06 191.59,68.06 194.62,65.04 194.62,64.93 195.36,64.18 196.93,64.18 198.73,62.38 198.73,59.97 199.49,59.22 201.1,59.22 201.95,60.07 201.95,62.19 203.31,63.54 213.48,63.54 214.05,64.11 214.95,64.11 217.92,61.14 218.53,61.14 218.87,60.8 v2(218.87,60.55)
  BOTTOM w0.114: R1148.1 231.61,38.96 231.61,38.96 228.43,38.96 227.78,39.61 227.78,40.31 227.66,40.44 227.66,40.83 226.93,41.56 226.93,44.56 227.25,44.88 227.25,46.27 227.05,46.48 227.05,54.37 226.53,54.89 v1(223.19,54.89) 218.49,54.89 217.98,55.4 217.98,58.89 218.62,59.53 218.62,60.29 v2(218.87,60.55)
PCH_HDMI_DDC_DATA: length 84.5
  TOP w0.114: R2101.1 R2129.2 183.47,69.81 183.57,69.72 v2(183.57,69.18)
  IN1 w0.076: v2(183.57,69.18) 183.62,69.23 184.33,69.23 185.04,68.52 191.78,68.52 195.07,65.23 195.07,65.12 195.55,64.64 197.12,64.64 199.19,62.57 199.19,60.16 199.68,59.67 200.91,59.67 201.43,60.19 201.43,62.31 203.12,64 213.29,64 213.86,64.57 215.14,64.57 217.75,61.96 218.11,61.6 219.04,61.6 219.33,61.31 219.33,60.24 219.13,60.04 v2(219.13,59.78)
  BOTTOM w0.114: v2(219.13,59.78) 219.13,59.15 218.49,58.51 218.49,55.64 218.75,55.39 v1(225.22,55.39) 226.73,55.39 227.54,54.58 227.54,46.87 227.8,46.61 227.8,44.69 227.43,44.32 227.43,41.76 228.15,41.04 228.15,40.64 228.28,40.52 228.28,39.81 228.63,39.46 231.72,39.46 231.88,39.62 231.88,40.2 232.16,40.49 232.43,40.49 232.61,40.3 R1149.1
PCH_HDMI_PD#: length 61.8
  TOP w0.102: v2(216.43,46.29) 216.42,46.29 216.4,46.31 216.46,46.37 Q1302.5
  IN1 w0.102: v2(202.46,38.68) 202.54,38.68 203.17,38.04 203.17,35.11 203.78,34.51 205.33,34.51 v2(206.2,33.64)
  IN2 w0.102: v2(206.2,33.64) 207.18,33.64 207.39,33.85 208.81,33.85 209.7,34.74 210.89,34.74 211.63,35.48 211.63,39.87 213.49,41.72 213.49,42.26 214.32,43.09 214.51,43.09 215.17,43.75 215.17,45.03 215.98,45.84 215.98,45.84 v2(216.43,46.29) ; v2(202.46,38.68) 202.39,38.61 194.08,38.61 193.46,37.99 184.79,37.99 183.95,37.15 182.51,37.15 181.63,38.03 v2(181.38,38.03)
  BOTTOM w0.089: U2000.AU43 177.29,42 177.29,41.36 177.2,41.27 177.2,40.7 177.52,40.39 177.52,39.92 177.75,39.69 178.62,39.69 179.11,39.2 179.36,39.2 180.53,38.03 181.36,38.03 ; v2(181.38,38.03) 181.36,38.03 ; 181.36,38.03 181.06,37.73
  BOTTOM w0.102: 181.06,37.73 180.94,37.61 180.94,34.46 R2369.2 ; v1(216.56,45.58) 216.56,46.13 216.43,46.26 v2(216.43,46.29)
PCH_JTAG_TCK: length 248.8
  TOP w0.102: v2(96.04,40.61) 98.99,40.61 104.52,46.14 104.52,49.08 104.77,49.32 107.7,49.32 109.75,51.37 109.75,54.54 v2(110.21,54.99)
  IN1 w0.102: v2(110.21,54.99) 111.52,56.3 115.62,56.3 116.53,55.39 123.24,55.39 123.65,55.79 135.06,55.79 135.52,56.25 139.26,56.25 141.66,58.65 143.2,58.65 144.05,59.5 145.43,59.5 146.04,60.11 150.34,60.11 153.83,63.59 154.87,63.59 155.58,64.3 157.74,64.3 158.66,65.22 168.09,65.22 168.69,65.82 171,65.82 171.21,65.62 173.94,65.62 174.14,65.42 v2(175.54,65.42)
  IN2 w0.102: v2(96.04,40.61) 94.67,41.98 69.42,41.98 68.55,42.85 67.35,42.85 66.59,43.6 58.32,43.6 57.6,42.89 48.15,42.89 47.5,43.54 44.5,43.54 39.18,48.86 36.75,48.86 34.22,51.39 34.22,52.81 27.58,59.45 27.58,61.17 23.62,65.13 23.62,70.07 24.41,70.85 24.41,74.63 24.84,75.07 24.84,80.27 19.47,85.64 19.19,85.64 18.95,85.88 18.95,86.89 16.71,89.13 16.71,111.86 11.23,117.34 11.23,120.28 v2(10.72,120.79)
  BOTTOM w0.089: 175.51,66.69 175.96,66.25 175.96,65.84 v2(175.54,65.42) 175.96,65 175.96,62.42 175.8,62.25 175.8,62.04 U2000.AN3
  BOTTOM w0.102: 175.46,67.02 175.46,66.74 175.51,66.69 ; R4402.2 v2(10.72,120.79) ; v1(96.04,39.86) v2(96.04,40.61)
PCH_JTAG_TDI: length 4.9
  BOTTOM w0.089: 176.42,63.65 176.42,63 176.45,62.97 176.45,62.63 176.21,62.38 U2000.AP2
  BOTTOM w0.102: 176.35,67.02 176.35,66.54 176.42,66.47 176.42,63.65
PCH_JTAG_TDO: length 9.9
  BOTTOM w0.089: U2000.AP1 176.21,64.35
  BOTTOM w0.102: v1(175.03,71.47) 175.03,70.09 175.31,69.81 R2344.1 175.59,69.46 175.59,69.45 175.59,68.45 175.77,68.27 175.79,68.27 175.92,68.13 175.92,66.6 176.21,66.31 176.21,64.35
PCH_JTAG_TMS: length 4.7
  BOTTOM w0.089: U2000.AR2 176.84,62.37 176.84,63.11 176.8,63.14 176.8,63.66
  BOTTOM w0.102: R2343.2 177.34,65.96 v1(177.14,65.75) 176.8,65.42 176.8,63.66
PCH_JTAGX: length 8.5
  BOTTOM w0.089: 176.61,63.49 176.61,63.06 176.66,63.02 176.66,62.56 176.57,62.48 176.57,62.22 176.82,61.97 U2000.AR3
  BOTTOM w0.102: R2346.1 176.44,69.42 176.44,68.51 176.77,68.18 176.77,66.07 176.61,65.91 176.61,63.49
PCH_NMI#: length 12.5
  BOTTOM w0.089: U2000.N43 165.55,42.03 165.27,41.74 165.27,41.02 165.12,40.87 164.92,40.87 163.94,39.9 162.94,39.9 162.06,39.01 157.74,39.01 156.46,37.73
  BOTTOM w0.102: 156.46,37.73 156.46,37.17 R2205.2
PCH_OCB4: length 6.9
  BOTTOM w0.089: 166.49,37.73 168.28,39.52 168.44,39.52 168.92,40.01 168.92,40.89 169.04,41.01 169.04,41.27 169.2,41.43 169.2,41.82 168.95,42.07 U2000.Y43
  BOTTOM w0.102: 166.49,37.73 166.49,37.57 166.05,37.14 166.05,37.04 R2114.2
PCH_OCB5: length 12.8
  TOP w0.102: R2113.2 164.01,34.75 163.6,35.15 163.6,35.2 163.59,35.21 163.59,37.05 163.89,37.35 164.77,37.35 167.13,39.71 167.13,39.72 167.61,40.19 167.61,41.91 168.19,42.48 v1(168.19,42.77) 168.19,43.1 168.21,43.12 v2(168.21,43.45)
  BOTTOM w0.102: v2(168.21,43.45) 168.59,43.07 U2000.Y41
PCH_OCB6: length 11.4
  BOTTOM w0.089: U2000.W44 168.2,41.49 168.2,41.4 168.13,41.32 168.08,41.28 168.08,40.81 167.76,40.48 167.76,40.21 167.76,39.77 166.85,38.86 166.11,38.12 165.21,38.12 165.02,37.93 165.02,37.92 164.87,37.77 164.87,37.73
  BOTTOM w0.102: 164.87,37.73 164.87,37.6 164.48,37.21 164.48,34.85 v1(164.39,34.76) 164.14,34.51 164.14,33.24 164.39,32.98 R2115.2
PCH_OCB7: length 7.6
  BOTTOM w0.089: 165.43,37.73 165.63,37.94 166.18,37.94 167.03,38.79 168.12,39.88 168.29,39.88 168.57,40.16 168.57,41.04 168.68,41.16 168.68,41.98 U2000.W43
  BOTTOM w0.102: 165.35,37.66 v1(165.35,37.66) ; 165.35,37.66 165.43,37.73 ; 165.35,37.66 164.9,37.21 R2116.2
PCH_PLTRST#: length 10
  TOP w0.114: v2(179.66,49.71) 179.84,49.53 181.06,49.53 181.75,48.84 182.36,48.84 182.82,49.3 183.85,49.3 v1(184.1,49.55) 184.48,49.93 184.48,49.95 184.76,50.23 185.54,50.23 186.02,50.71 187.62,50.71 R2457.1
  BOTTOM w0.102: U2000.BB27 180.02,50.06 v2(179.66,49.71)
PCH_PME_IN#: length 4.8
  BOTTOM w0.089: 184.71,55.98 184.71,55.87 184.3,55.46 183.94,55.46 183.32,54.85 181.01,54.85 U2000.BD17
  BOTTOM w0.102: R2250.2 184.93,56.2 184.71,55.98
PCH_PWROK: length 34.1
  TOP w0.102: v2(178.16,57.48) 178.57,57.89 180.01,57.89 180.34,58.22 180.34,58.81 180.57,59.04 180.57,59.36 180.89,59.68 182.21,59.68 183.97,61.43 184.43,61.43 R2475.1 185.85,62.85 v1(185.85,64.25) 185.65,64.46 v2(185.24,64.46)
  BOTTOM w0.089: U2000.AW11 178.23,57.48 v2(178.16,57.48)
  BOTTOM w0.102: U2402.4 193.61,67.17 193.84,66.93 195.49,66.93 195.55,66.87 R2493.2 R2494.2 197.3,66.87 197.45,66.72 197.45,65.72 195.8,64.08 190.75,64.08 190.18,64.65 190.18,65.21 189.65,65.74 187.81,65.74 186.81,64.74 185.52,64.74 v2(185.24,64.46)
PCH_RCIN#: length 17.2
  TOP w0.102: v2(176.58,55.49) 177.23,56.13 178.71,56.13 178.71,56.14 179.42,56.14 179.46,56.1 179.96,56.1 180.5,56.64 180.6,56.74 181.18,56.74 182.2,57.76 182.78,57.76 183.82,58.8 183.82,60.43 184.14,60.75 185.37,60.75 C2200.1 186.71,59.4 v1(186.92,59.4) 187.15,59.4 R2202.2 R2218.2
  BOTTOM w0.089: U2000.AT17 177.14,54.91 176.58,55.47 v2(176.58,55.49)
PCH_RSMRST#: length 17.7
  TOP w0.102: v2(179.63,58.56) 179.93,58.87 179.93,58.98 180.16,59.21 180.16,59.53 180.72,60.09 181.09,60.09 182.04,60.09 183.43,61.47 183.43,64.5 183.25,64.68 183.25,66.9 183.16,66.99 R2492.1 182.8,67.33 183.35,67.88 183.35,68.38 184.07,69.11 R2477.1 184.1,69.72 184.38,69.72 184.54,69.88 184.54,70.41 184.68,70.55 R2488.1 185.65,70.55 v1(185.93,70.27)
  BOTTOM w0.089: U2000.BA11 179.53,58.46 v2(179.63,58.56)
PCH_SATALED#: length 329.6
  IN1 w0.102: v2(169.63,31.34) 169.23,30.93 168.54,30.93 168.43,30.81 165.95,30.81 165.46,30.32 164.76,30.32 163.75,31.34 152.26,31.34 151.5,30.57 130.86,30.57 130.01,29.72 117.47,29.72 116.04,31.16 110.13,31.16 v2(105.94,35.35)
  IN2 w0.102: v2(107.06,43.2) 106.65,42.79 102.39,42.79 100.31,44.87 73.14,44.87 72.91,45.1 68.26,45.1 67.44,45.92 60.74,45.92 59.94,46.72 48.62,46.72 47.92,47.41 45.93,47.41 40.87,52.47 39.96,52.47 33.96,58.46 33.96,61.76 33.09,62.63 32.38,62.63 29.75,65.26 29.75,68.14 27.25,70.64 27.25,81.79 19.05,90 19.05,119.24 16.41,121.87 16.41,122.67 14.95,124.13 14.95,131.68 13.07,133.56 13.07,136.09 16.01,139.03 16.01,141.22 15.58,141.65 15.53,141.65 15.19,141.99 15.19,142.64 15.38,142.83 15.38,144.46 15.14,144.7 15.14,145.33 15.75,145.94 15.75,146.82 16.01,147.09 16.45,147.09 17.45,148.09 17.45,151.9 23.95,158.41 23.95,166.67 23.33,167.29 23.33,169.85 26.07,172.59 26.07,175.78 27.33,177.04 32.07,177.04 32.45,177.42 34.66,177.42 35.97,178.73 37.4,178.73 39.08,180.41 40.14,180.41 40.35,180.62 44.93,180.62 45.69,181.37 46.46,181.37 46.74,181.1 46.74,180.62 v2(46.57,180.46)
  BOTTOM w0.089: 170.62,37.73 170.62,39.35 171.21,39.93 171.21,41.4 171.22,41.42 U2000.AD44
  BOTTOM w0.102: v2(169.63,31.34) 170.51,32.21 170.79,32.21 171.18,32.6 171.18,33.68 R2106.2 170.24,34.62 170.24,36.94 170.62,37.32 170.62,37.73 ; D5601.1 48.45,178.15 48.29,178.31 47.25,178.31 46.08,179.48 46.08,180.24 46.3,180.46 v2(46.57,180.46) ; v2(105.94,35.35) v1(105.94,41.72) 105.94,42.08 v2(107.06,43.2)
PCH_SCLOCK: length 23.4
  TOP w0.102: v2(169.39,47.08) 169.02,47.08 168.56,47.54 167.92,47.54 166.93,48.53 166.42,48.53 v1(165.94,48.05) 165.17,47.28 163.18,47.28 162.78,46.88 161.26,46.88 160.6,46.22 160.6,43.25 159.07,41.72 157.84,41.72 155.12,39.01 R2136.2
  BOTTOM w0.102: U2000.AB33 169.64,46.83 v2(169.39,47.08)
PCH_SDATAO0: length 10.3
  BOTTOM w0.089: U2000.AA44 169.56,41.53 169.22,41.18 169.22,40.93 169.1,40.82 169.1,39.58 v1(168.68,39.16) 167.92,38.4 167.44,38.4 166.77,37.73
  BOTTOM w0.102: R2133.2 R2145.1 166.26,34.52 166.26,37.05 166.73,37.52 166.73,37.69 166.77,37.73
PCH_SDATAO1: length 6
  BOTTOM w0.089: 167.1,37.73 167.11,37.74 167.11,37.76 167.51,38.17 168.29,38.17 169.28,39.15 169.28,40.74 169.39,40.85 169.39,40.97 U2000.AA45
  BOTTOM w0.102: 167.1,37.73 166.93,37.56 166.93,37.02 R2134.2
PCH_SLOAD: length 21
  TOP w0.102: v2(169.39,46.42) 168.96,46.85 168.96,46.85 168.48,47.34 167.58,47.34 167.31,47.6 166.22,47.6 164.03,45.41 164.03,45.28 162.89,44.13 162.89,43.71 162.61,43.43 v1(161.06,43.43) 159.11,41.47 157.99,41.47 156.01,39.49 R2135.2
  BOTTOM w0.102: v2(169.39,46.42) 169.41,46.42 169.77,46.07 U2000.AB35
PCH_SLP_S3#: length 13.6
  TOP w0.102: v2(177.67,56.56) 177.19,57.04 176.03,57.04 175.77,57.3 175.77,60.65 176.33,61.21 T2407.1 176.33,63.8 176.23,63.9 176.23,66.74 R2438.1
  BOTTOM w0.089: U2000.AW15 178.44,56.05 177.94,56.56 v2(177.67,56.56)
PCH_SLP_S4#: length 16.5
  BOTTOM w0.089: U2000.BD15 181.27,55.88 182.8,55.88 183.09,56.18 183.09,56.95 184.25,58.1 184.71,58.1
  BOTTOM w0.102: 184.71,58.1 187.67,58.1 187.84,58.28 189.19,58.28 189.24,58.23 189.94,58.23 R2439.1 190.5,58.01 190.59,58.09 192.77,58.09 193.8,59.12 194.35,59.12 T2406.1
PCH_SLP_S5#: length 12.6
  TOP w0.102: R2440.1 186.61,61.51 T2405.1 186.26,61.16 183.97,61.16 182.3,59.48 181,59.48 180.77,59.25 180.77,58.95 180.54,58.73 180.54,58.14 179.78,57.37 179.53,57.37 179.23,57.08 179.07,57.08 v2(178.54,56.54)
  BOTTOM w0.089: v2(178.54,56.54) 179.04,57.04 U2000.BA13
PCH_SLP_WLAN#: length 12.5
  TOP w0.102: v2(177.48,57.49) 178.08,58.09 179.92,58.09 180.14,58.31 180.14,58.89 180.37,59.12 180.37,59.45 180.8,59.88 182.13,59.88 183.64,61.4 183.64,61.53 R2441.1 183.83,61.97 183.63,62.17 183.63,63.95 T2403.1
  BOTTOM w0.089: v2(177.48,57.49) 177.48,57.41 U2000.AV13
PCH_SML2ALERT#: length 16.7
  BOTTOM w0.089: 184.71,44.4 184.71,44.39 183.64,44.39 182.5,45.53 181.22,45.53 U2000.BD35
  BOTTOM w0.102: 184.71,44.4 188.67,44.4 189.24,43.83 189.62,43.83 190.19,44.4 192.7,44.4 192.82,44.29 193.7,44.29 R2484.2 R2464.2 195.24,43.53 195.24,42.93 195.1,42.79 v1(195.1,42.51)
PCH_SRCCLKREQ1#: length 10.1
  TOP w0.102: v2(178.13,50.73) 178.43,50.43 178.5,50.43 178.61,50.32 179.74,50.32 v1(180.08,50.67) 180.31,50.44 181.32,50.44 181.84,49.91 182.34,49.91 182.51,49.74 183.09,49.74 184.03,50.67 184.61,50.67 184.86,50.92 184.86,51.78 R2410.2
  BOTTOM w0.089: v2(178.13,50.73) 178.7,51.29 U2000.AW24
PCH_SRCCLKREQ2#: length 11
  TOP w0.102: R2411.2 185.32,50.89 184.89,50.46 184.11,50.46 183.18,49.53 182.72,49.53 182.26,49.08 181.84,49.08 181.18,49.74 v1(181.18,49.96) 180.04,49.96 179.89,50.12 178.53,50.12 178.46,50.18 177.46,50.18 v2(176.9,50.74)
  BOTTOM w0.089: v2(176.9,50.74) 176.9,50.92 U2000.AT24
PCH_SRCCLKREQ4#: length 12
  TOP w0.102: v2(177.91,51.98) 178.54,51.35 180.47,51.35 180.87,50.94 182.92,50.94 183.21,50.94 184.12,51.86 v1(184.12,52.11) 183.9,52.34 183.9,52.91 184.22,53.24 184.9,53.24 R2422.2
  BOTTOM w0.102: U2000.BB24 179.89,51.6 178.66,51.6 178.65,51.59 178.3,51.59 v2(177.91,51.98)
PCH_SRCCLKREQ5#: length 4.3
  BOTTOM w0.089: U2000.BE25 181.62,51.1 183.28,51.1 183.69,51.1 184.24,51.65 184.63,51.65 184.71,51.73
  BOTTOM w0.102: 184.71,51.73 R2423.2
PCH_SRCCLKREQ6#: length 15.5
  TOP w0.102: v2(177.19,46.42) 177.62,45.99 178.49,45.99 178.85,45.62 180.35,45.62 181.4,44.57 181.4,44.55 181.86,44.09 184.05,44.09 v1(184.26,43.88) 184.27,43.87 186.26,43.87 186.41,44.02 186.41,44.02 186.78,44.39 187.38,44.39 187.91,43.86 189.1,43.86 189.12,43.83 189.59,43.83 189.87,44.11 189.87,44.16 R2428.2
  BOTTOM w0.089: v2(177.19,46.42) 177.11,46.5 U2000.AT33
PCH_SRCCLKREQ11#: length 14.7
  BOTTOM w0.089: U2000.BC33 180.86,46.61 181.55,46.61 181.72,46.45 183.88,46.45 184.65,45.67 184.71,45.67
  BOTTOM w0.102: 184.71,45.67 187,45.67 187.2,45.47 189.55,45.47 189.75,45.27 192.1,45.27 192.65,44.72 R2433.2 193.29,45.59 v1(193.42,45.71)
PCH_SUSACK#: length 15.3
  TOP w0.102: v2(178.77,53.21) 179.02,53.21 179.12,53.3 182.99,53.3 184.36,54.67 188.93,54.67 189.26,54.35 190.4,54.35 T2205.1
  BOTTOM w0.089: v2(178.77,53.21) 179.08,52.9 179.69,52.9 179.73,52.85 180.08,52.85 180.27,53.05 180.27,53.49 U2000.BB19
PCH_SYS_PWROK: length 26.5
  BOTTOM w0.089: 179.18,62.89 179.18,62.89
  BOTTOM w0.102: R2489.2 190.25,69.36 190.54,69.07 U2403.4 190.54,68.25 189.79,67.5 R2491.2 189.28,68.83 188.25,69.86 188.25,71.53 187.49,72.29 183.63,72.29 183.01,71.68 181.25,71.68 180.82,71.25 180.82,71.08 180.36,70.61 179.89,70.61 v1(179.43,70.15) 180.2,69.37 180.2,67.66 180.76,67.1 R2479.1 180.26,66.59 180.26,65.12 179.58,64.43 179.58,63.28 179.18,62.89 ; U2000.AY1 179.18,62.89
