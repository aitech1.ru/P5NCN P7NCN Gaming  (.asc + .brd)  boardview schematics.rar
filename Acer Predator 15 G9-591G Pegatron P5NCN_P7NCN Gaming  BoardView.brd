# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Nets (continued)
N126463138: T1003.1 U0300.H14
N126463140: T1002.1 U0300.J14
N126612066: Q5301.3 Q5302.3 R5301.1 R5302.1
N126612078: C5302.1 Q5300.1 R5301.2
N126612092: C5301.1 L5300.1 Q5300.3
N126721657: R1003.2 U0300.BL15 U0300.BM16
N126721746: R1006.2 U0300.BP15 U0300.BR15 U0300.BT15
N126721910: R1007.2 U0300.BP16 U0300.BR16 U0300.BT16
N126721980: R1008.2 U0300.BM15 U0300.BN15
N126722847: R1012.2 U0300.BJ35 U0300.BJ36
N127662539: C3630.1 C3631.1 C3642.1 R3609.2 R3612.2 U3600.9
N127663036: C3616.1 U3600.7
N129068465: R7403.2 U7401.6
N129068468: R7402.2 U7401.5
N129069433: R7404.2 U7000.BB7
N129069925: R7400.1 R7401.2 U7401.1
N129582425: R7401.1 U7000.BA3
N129589225: R7503.1 U7000.R49
N129589246: R7502.1 U7000.BB48
N129596305: T7501.1 U7000.R39
N129596308: T7502.1 U7000.AG11
N129596311: T7500.1 U7000.AF10
N129596314: R7501.1 U7000.P40
N129596317: R7506.1 U7000.R48
N129596320: R7500.1 U7000.R47
N129616581: C7206.1 C7207.1 C7208.1 C7209.1 L7201.2 R7206.2 U7000.AW27
N129616961: C7210.1 R7206.1 U7000.AW28
N129618256: R7210.2 U7000.BB3
N129618265: C7215.1 U7000.BB2 X7200.1
N129618849: R7208.2 R7211.1 U7000.BB1
N129619906: C7216.1 U7000.BA1 X7200.3
N129634919: C8742.1 R8727.2
N129635970: R8725.2 U8701.5
N129637628: R8728.1 U8701.1
N129637680: C8741.1 R8729.1 U8701.8
N129797271: Q7600.3 R7608.1 R7609.1
N129798096: Q7700.3 R7708.1 R7709.1
N129799839: Q7800.3 R7808.1 R7809.1
N129800921: Q7900.3 R7908.1 R7909.1
N129948629: R3306.2 U3300.10
N129953010: R3305.1 U3300.24
N129953281: R3305.2 T3303.1
N129960916: C3617.1 U3600.12
N129960923: C3617.2 C3618.1 R3606.1 R3607.1
N129962294: R3603.1 R3623.1 R3624.1 U3600.13
N129962321: R3620.2 U3600.19
N129962530: C3601.1 R3600.1 U3600.27
N129962745: C3604.1 U3600.34
N129962763: C3603.2 U3600.37
N129963384: C3613.1 L3600.2 U3600.40
N129963392: C3610.1 C3611.1 C3614.1 C3615.1 L3601.2 L3607.2 U3600.41 U3600.46
N130075477: C3600.1 U3600.28
N130157386: C3702.1 U3700.9
N130157404: C3703.1 U3700.10
N130159038: C3709.1 U3700.8
N130159071: R3702.2 U3700.7
N130819139: R3116.2 R3159.2 U3101.3
N130819371: R3160.2 U3101.2
N130819511: R3124.2 R3158.1 U3101.7
N131133476: CON5101.P1 R5108.1 R5124.1 R5127.2
N131133514: CON5101.P4 R5109.1 R5125.1 R5132.2
N131225266: R7614.1 U7601.J10
N131225824: R7714.1 U7701.J10
N131226392: R7814.1 U7801.J10
N131226956: R7914.1 U7901.J10
N131250324: R8720.2 U8700.13
N131250337: R8719.2 U8700.14
N131250344: R8718.2 U8700.15
N131316400: C9128.1 R9109.2 U9103.3 U9103.5
N131316575: C9129.1 U9103.12
N131316591: C9127.1 U9103.10
N131317511: R4526.2 R4588.1 R4590.2 R4591.1 U4502.1
N131362545: T3301.1 U3300.39
N131362585: T3302.1 U3300.38
N131411654: C9134.1 Q9105.1 R9111.1
N131411656: Q9104.2 SR9104.2
N131411685: Q9104.4 R9110.1 R9111.2 T9113.1
N131439778: R1101.1 U1101.N16
N131441491: R1102.1 U1101.N6
N131445423: R1108.1 U1101.Y18
N131647000: R1121.2 U1101.M4
N131715858: R1211.2 U1201.F1
N131716225: R1218.2 U1201.G2
N131716263: C1208.1 U1201.A2
N131716280: C1207.1 U1201.K1
N131716387: C1221.1 U1201.E1
N135192727: R3020.2 U3001.7
N135192730: R3014.2 U3001.8
N135192733: R3015.2 U3001.9
N135192736: R3016.2 U3001.10
N135193082: C3015.2 U3001.12
N135194518: R3018.2 U3001.6
N135195707: R3069.2 U3001.15
N135532945: R5201.1 U5200.16
N135533052: R5200.1 U5200.15
N135533327: R5202.2 U5200.6
N135533333: R5203.2 U5200.7
N135533339: R5204.2 U5200.8
N135596235: R3076.2 U3001.33
N135676971: C3603.1 U3600.35
N135678655: C3612.1 U3600.39
N135704866: Q3601.1 Q3601.3 R3622.1
N135705316: Q3601.6 Q3602.1 R3604.2 R3622.2
N135714980: T3602.1 U3600.14
N135717456: C3640.1 U3600.21
N135717474: C3639.1 U3600.22
N135719021: C3607.1 R3620.1
N135719044: R3621.2 U3600.20
N136259332: L1101.1 U1101.C1 U1101.C2 U1101.D1
N136259619: C1184.1 U1101.J16
N136259621: C1183.1 U1101.L16
N136630757: R2618.1 U2000.AD13
N136634176: R1317.2 R1321.1 U1301.10
N136643265: R1417.1 U1401.10
N136787184: CON6000.6 R6003.1
N136787191: CON6000.7 R6004.1
N137103573: R2151.2 R2159.1
N137103692: R2153.2 R2158.1
N137103866: R2154.2 R2160.1
N137103874: R2155.2 R2161.1
N137154023: R1150.1 U1101.L4
N137261398: F4800.1 Q4804.3
N137261420: Q4801.2 R4816.2
N137346808: CON5300.55 T5302.1
N137531212: CON5300.40 R5311.1
N137531214: CON5300.38 R5310.1
N137531216: CON5300.42 R5312.1
N137531334: CON5300.16 T5301.1
N137827968: R2144.2 U2000.AD35
N137828322: R2143.1 R2162.2 U2000.AD31
N138090086: Q7401.2 R7409.2 U7000.BF3
N138090091: Q7402.2 R7410.2 U7000.BE3
N138223875: R2376.2 U2000.AJ35
N138223878: R2375.1 U2000.AH44
N138274096: R2496.1 R2497.2 U2404.1
N138274106: R2498.2 U2404.4
N138275716: R7407.2 U7000.BB5
N138275758: R7408.2 U7000.BB4
N138278798: CON3104.3 R3163.2
N138282438: R7619.1 U7600.J10
N138285036: R7719.1 U7700.J10
N138285332: CON4601.14 R4610.1
N138286203: R7819.1 U7800.J10
N138322414: R7919.1 U7900.J10
N138336439: CON5102.50 R5123.2
N138342270: R7002.2 U7002.2
N138434716: C5005.1 R5015.2 U5001.4
N138434827: R5012.2 U5001.1
N138435027: C5006.1 R5016.2 U5002.4
N138435047: R5013.2 U5002.1
N138566355: Q7404.3 R7446.2
N138569296: C4308.1 C4309.1 R4308.2 U4301.1 U4301.13
N138687814: R8031.1 R8039.2
N138711426: C8016.2 R8030.1
N138717346: C8009.2 R8023.1
N138728527: C8021.2 R8037.1
N138728530: C8021.1 R8015.1 R8020.2
N138743980: C8036.2 C80110.2 R8040.1
N138751836: R8088.1 R8094.2
N138766947: C8034.2 R8043.2
N138776862: C8031.2 R8096.1
N138776940: R8081.1 R8084.2
N138776976: C8024.2 R8049.1
N138776978: C8024.1 R8004.2 R80100.1
N138777029: C8033.2 R8080.1
N138809198: C8018.2 R80102.1
N138810104: R8082.2 R80101.1
N138810209: C80109.1 C80133.1 R8097.2
N138844949: C8012.1 R8093.2
N138848079: C8008.1 R8047.2
N138852434: R8740.2 U8702.5
N138852479: R8730.2 R8731.1
N138852481: R8730.3 R8732.1
N138852483: R8733.2 R8734.1
N138853955: D8802.2 R8819.1 U8801.4
N138853957: C8828.1 C8829.1 D8802.1 Q8806.1 Q8807.1 R8819.2
N138853973: C8832.1 R8818.2 R8820.1 U8801.3
N138854040: Q8806.3 R8822.1 T8812.1
N138861884: C8007.1 R8079.2
N138861972: C8007.2 R8048.1 R8099.2
N138873252: C80106.2 R8036.1
N138873268: R8024.1 R8026.2
N138873283: C80103.1 C80111.1 R80124.2
N138947971: C8054.1 R8050.1
N138948723: C8054.2 U8001.5
N138948726: R8050.2 U8001.7
N138949600: JP8050.1 R8056.2 R80125.2
N138949602: JP8051.1 R8057.2
N138949618: C8071.1 R8053.1
N138973068: JP8052.1 R8058.2 R80130.2
N138973117: C8055.1 R8051.1
N138973148: C8055.2 U8002.5
N138973150: R8051.2 U8002.7
N138973254: JP8053.1 R8059.2
N138973270: C8072.1 R8054.1
N138993706: JP8054.1 R8060.2 R80135.2
N138993779: C8060.1 R8052.1
N138993809: C8060.2 U8003.5
N138993811: R8052.2 U8003.7
N138993926: JP8055.1 R8061.2
N138993942: C8073.1 R8055.1
N139012019: CON3104.10 R3151.1
N139012023: CON3104.9 R3150.1
N139012387: JP8058.1 R8062.2 R80140.2
N139012436: C80052.1 R8071.1
N139012467: C80052.2 U8006.5
N139012469: R8071.2 U8006.7
N139012573: JP8057.1 R8064.2
N139012589: C80046.1 R8073.1
N139027518: JP8059.1 R8063.2 R80145.2
N139027567: C80042.1 R8065.1
N139027598: C80042.2 U8004.5
N139027600: R8065.2 U8004.7
N139027694: JP8060.1 R8066.2
N139027720: C80056.1 R8072.1
N139084693: C8086.1 R8068.2
N139090790: JP8056.1 R8067.2
N139090792: JP8061.1 R8069.2
N139090834: C80041.1 R8070.1
N139235634: R5208.2 U5200.9
N139244830: CON5102.10 R5126.2
N139245224: CON5102.38 R5106.2
N139245248: CON5102.52 R5122.2
N139696030: R3077.1 R3079.1 U3001.83
N139696058: R3080.1 R3092.1 U3001.82
N139696517: R3156.1 U3101.5
N139696523: R3157.1 U3101.6
N139703251: CON3104.13 Q3107.3
N139978690: R1223.2 R1239.2 U1201.F10
N139982576: R1225.2 U1201.E4
N139982579: R1224.2 U1201.D5
N139982678: R1226.2 U1201.E2 U1201.F2
N140034678: C4638.1 CON4601.20 F4601.2 R4631.2
N140129525: R3138.1 U3102.26
N140129527: R3139.1 U3102.27
N140129538: R3149.2 U3102.28
N140129583: R3140.2 U3102.1
N140177504: CON6003.1 CON6003.2 Q6001.2 R6005.1
N140177624: C6001.2 CON6002.1 CON6002.2 Q6001.1 R6006.2
N140249883: C7401.1 R7449.1 U7000.AV6
N140414267: R5806.1 U5800.11
N140503834: T3300.1 U3300.23
N140505490: R3098.1 U3001.119
N140559812: R8733.3 R8735.1
N140692797: R3094.1 U3001.96
N140692856: R3096.1 U3001.98
N140692863: R3095.1 U3001.97
N140692954: R3097.1 U3001.99
N140693429: R3087.1 U3001.70
N140693431: R3088.1 U3001.71
N140693523: R3085.1 U3001.72
N140693525: R3086.1 U3001.73
N140693591: R3089.1 U3001.76
N140693593: R3090.1 U3001.77
N140693595: R3091.1 U3001.78
N140788656: Q8807.3 R8821.1
N141163560: CON6700.21 L6700.2
N141163567: CON6700.20 L6701.2
N141512226: T1209.1 U1201.F4
N141512229: T1210.1 U1201.G4
N143100577: C8206.1 SR8200.2 U8200.3
N143100638: R8203.1 U8200.11
N143101184: R8204.1 U8200.14
N143118416: C9403.1 SR9400.2 U9400.3
N143118445: R9404.1 U9400.11
N143118589: R9402.1 U9400.14
N143129465: C9612.1 U9600.11
N143236334: C8216.2 R8207.1 R8208.2
N143236888: C9416.2 R9407.1 R9408.2
N143246738: D9500.2 R9507.1
N143287072: R1161.2 U1101.AA1
N143287155: R1162.1 U1101.F4
N144172051: CON5103.38 R5104.2
N144184021: C1229.1 U1201.H7
N144362774: R0749.2 U0703.2
N144362810: R0748.2 U0703.1
N144673370: CON5100.6 R5131.1
N144979028: Q7201.3 Q7202.1 Q7203.1 R7218.2
N144979032: Q7203.2 R7216.2
N144979034: Q7202.2 R7217.2
N144979663: D3104.1 R3162.1
N144979768: D3104.2 R3161.1
N144980835: R4628.1 U4601.10
N145218678: C3105.1 R3165.1 U3103.5
N145218684: R3164.2 R3167.2 R3168.1 U3103.3
N145218718: R3166.1 U3103.1
N145218847: R3169.1 U3103.4
N145280710: T1105.1 U1101.W19
N145280722: T1106.1 U1101.Y19
N145280742: T1107.1 U1101.AC23
N145280776: T1108.1 U1101.AB23
N145283752: T1109.1 U1101.A23
N145283762: T1110.1 U1101.B23
N145283804: T1111.1 U1101.E18
N145283824: T1112.1 U1101.V18
N145473962: T1301.1 U1301.33
N145473964: T1302.1 U1301.34
N145676608: C5004.1 Q5001.1 Q5001.3 U5000.2
N145676610: C5004.2 Q5001.2 U5000.3
N145824487: R5017.1 U5003.1
N146001886: CON4500.16 R4527.2
N146002641: C4517.1 C4518.1 CON4500.39 CON4500.40 SP4502.2 T4506.1
N147122449: C5173.1 R5139.2 U5103.4
N147122492: R5134.2 U5103.1
N147122942: C5174.1 Q5102.1 R5137.1 U5102.4
N147124273: C5172.1 Q5101.1 Q5102.3 R5136.2
N147446396: Q4601.1 R4629.2 R4630.1
N147836713: D4504.1 R4591.2
N147836837: C4544.1 D4504.2 U4502.5
N148386775: D3601.2 R3632.2 U3600.4
N1484083071: D8900.2 SR8900.2

Pads without a net: CN7 5 7; CON1600 87 88 91 92 95 97 100 101 104 105; CON1601 87 88 91 92 95 97 100 101 104 105; CON1700 87 88 91 92 95 97 100 101 104 105; CON1701 87 88 91 92 95 97 100 101 104 105; CON4301 8; CON4400 6 8; CON4402 12; CON4500 38; CON4800 13 14; CON5100 1 2 3 4 5 13; CON5102 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; CON5103 5 6 7 8 10 11 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 59 60 61 62 63 64 65 66 67 68; CON5300 6 8 9 10 11 12 13 14 15 17 19 20 21 22 23 32 34 36 44 46 48 50 58 59 60 61 62 64 65 66 67 68 70 71 73; CON6001 7; NOREF#4 1; NOREF#5 1; NOREF#6 1; NOREF#7 1; NOREF#10 1; NOREF#11 1; NOREF#14 1; NOREF#17 1; NOREF#19 1; NOREF#24 1; NOREF#27 1; NOREF#28 1; NOREF#29 1; NOREF#30 1; NOREF#31 1; NOREF#34 1; NOREF#37 1; NOREF#38 1; Q9101 6; Q9102 6; Q9103 6; Q9104 6; U0300 AA14 AE29 AJ8 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B2 B30 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ21 BJ28 BK21 BK28 BL31 BL34 BN33 BN35 BP1 BR2 BR31 BR33 BR35 C1 C30 C38 D27 E27 E30 F30 G3 G13 H24 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U0701 1; U0702 1; U1101 A7 A9 A11 A13 B7 B9 B11 B13 D19 E19 W16 Y16; U1201 A9 B9 C2 E10 H6 L11; U1301 8 15 21 37 43 46; U1401 8 15 21 33 34 37 43 46; U2000 A7 AB13 AC2 AC3 AD2 AD3 AE17 AF2 AF3 AF17 AG14 AG15 AJ11 AJ13 AJ38 AJ39 AJ42 AJ43 AK44 AK45 AL35 AL36 AL43 AL44 AN17 AN29 AN44 AR19 AR22 AR39 B7 B11 B19 B36 BA4 BC8 C11 C19 C36 D3 D5 D7 D8 E6 E17 E35 E45 F2 F45 G17 G35 G37 G44 G45 H40 H42 H43 H44 J45 K37 K44 L5 L7 L37 L39 N29 N31 N38 N39 P1 P24 P27 P29 P31 R2 R3 R4 R7 R8 R11 R13 R24 R27 U2 U3 U5 U7 U13 V1 V2 W2 W3 W7 W13 Y5; U3102 9 14 18 23; U3300 25 26 28; U3600 15 16 17 18 29; U4301 24; U4501 1 6; U4601 8 15 21 37 43 46; U5000 6; U5102 1; U5800 10; U6200 1 2 3 6 7 8 9 12 13 14; U7000 A18 A38 AA6 AA9 AA10 AC40 AC41 AC43 AD6 AD8 AD9 AF43 AF46 AF49 AG4 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ7 AJ8 AJ9 AJ41 AK1 AK2 AK3 AK4 AK5 AK6 AK7 AK8 AK9 AK10 AK46 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM10 AN1 AN2 AN3 AN4 AN5 AN6 AN7 AN8 AN9 AN10 AN44 AN46 AN47 AR1 AR2 AR3 AR4 AR5 AR6 AR7 AR8 AR9 AR10 AR42 AR43 AT2 AT3 AT5 AT8 AV2 AV5 AV8 AV9 AV46 AW3 AW5 AW6 AW9 AW14 AW20 AW21 AY14 AY18 AY20 AY21 BA14 BA15 BA17 BA18 BA20 BA21 BB9 BB11 BB15 BB17 BB18 BC8 BC9 BC11 BC15 BC17 BC18 BD3 BD4 BD5 BD6 BD8 BD9 BD15 BD17 BD18 BE1 BE5 BE6 BE8 BE9 BE12 BE15 BE17 BE18 BF1 BF4 BF6 BF8 BF9 BF11 BF12 BF15 BF17 BF18 BG3 BG4 BG5 BG6 BG8 BG9 BG11 BG12 BG14 BG15 BG17 BG18 BH3 BH4 BH6 BH8 BH9 BH11 BH12 BH14 BH15 BH17 BH18 BJ4 BJ5 BJ6 BJ8 BJ9 BJ11 BJ12 BJ14 BJ15 BJ17 BJ18 C6 C11 C38 D11 D14 D18 D27 E39 E49 F3 F21 G9 G11 G18 G24 H9 H24 H30 H32 H35 J7 J8 J15 J21 J24 J32 J33 J36 J44 J45 J48 K21 K36 L3 L4 L6 L42 L43 M49 P4 R9 R41 U46 V1 V4 V7 Y41 Y42 Y44; U7600 A5 U5; U7601 A5 U5; U7700 A5 U5; U7701 A5 U5; U7800 A5 U5; U7801 A5 U5; U7900 A5 U5; U7901 A5 U5; U8001 4 6 27 30 31 34; U8002 4 6 27 30 31 34; U8003 4 6 27 30 31 34; U8004 4 6 27 30 31 34; U8006 4 6 27 30 31 34; U8200 5 7 8; U8400 7; U8702 2; U8800 11; U8900 6 14 15 16 17; U9400 5 7 8; U9500 3 5 6; U9600 3 5 6

## Via types
v1: diameter 0.559, hole 0.279, TOP to BOTTOM, 2044 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 5147 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 1241 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 154 vias
v5: diameter 0.66, hole 0.33, TOP to BOTTOM, 7 vias
v6: diameter 0.457, hole 0.203, TOP to BOTTOM, 3221 vias
v7: diameter 0.66, hole 0.254, TOP to BOTTOM, 79 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VSUS_BST:
  vias: v1(141.23,72.1)
1.0VSUS_BST_R:
  vias: v1(140.83,68.84)
1.0VSUS_EN: length 12
  BOTTOM w0.102: U8200.15 137.73,70.08 137.21,69.56 136.91,69.56 136.7,69.36 C8205.1 136.2,68.76 136.07,68.63 136.07,66.66 136.2,66.54 R8201.2 137.07,66.54 137.21,66.4 137.21,65.24 v1(137.59,64.86) 137.85,64.61 139.83,64.61 140.04,64.4 D8200.1
1.0VSUS_FB: length 11.9
  BOTTOM w0.203: U8200.13 138.73,69.86 138.77,69.83 R8206.1 138.61,68.96 R8205.2 139.08,67.87 139.08,67.23 139.28,67.02 139.75,67.02 140.64,67.91 142.42,67.91 142.62,67.71 v1(142.68,67.71) 143.34,67.05 144.76,67.05 145.5,67.78 R8207.2
1.0VSUS_FB_R: length 11.8
  BOTTOM w0.203: JP8200.1 147.55,67.69 147.19,68.05 v1(146.75,68.05) 146.31,67.61 145.76,67.61 144.89,66.74 142.76,66.74 141.97,67.53 140.77,67.53 139.81,66.58 139.06,66.58 138.61,67.03 R8205.1
1.0VSUS_LX: length 1.4
  BOTTOM w0.203: 143.69,70.07 143.38,69.77 R8208.1
1.0VSUS_RC:
  vias: v1(142.39,77.39)
1.05V_BST: length 1.3
  TOP w0.152: v1(84.4,176.37) 84.4,175.66 R9603.2
1.05V_BST_R:
  vias: v1(85.52,174.06)
1.05V_EN: length 13.3
  TOP w0.102: v2(77.59,177) 77.7,177.11 80.94,177.11 81.32,176.73 81.32,175.79 82.46,174.65 U9600.13
  BOTTOM w0.102: D9600.1 77.42,176.83 v2(77.59,177) 77.14,177.45 77.14,178.27 76.96,178.45 R9602.2 C9603.1 75.03,178.45 v1(74.47,177.89)
1.05V_FB: length 16.1
  TOP w0.102: v1(89.96,179.82) 89.92,179.77 R9604.2
  TOP w0.203: R9604.2 R9606.2 89.97,177.84 R9605.1 88.77,178.26 v2(88.77,178.35) ; v2(83.77,176.92) 83.64,177.05 81.88,177.05 81.6,176.77 81.6,175.88 82.86,174.62 U9600.12
  IN1 w0.203: v2(83.77,176.92) 84.58,176.92 86.02,178.35 v2(88.77,178.35)
1.05V_FB_R: length 5.8
  TOP w0.203: C9601.1 90.86,177.31 90.78,177.39 R9606.1 92,177.89 ; 92,177.89 92.25,177.89 92.76,177.39 92.76,176.88 92.58,176.7 JP9601.1 ; 92,177.89 v1(92,179.42)
1.05V_FB_R1: length 3.9
  TOP w0.203: 89.46,175.35 89.46,176.07 89.59,176.19 R9605.2 C9601.2 91.19,176.19 91.36,176.37 91.36,176.93 v1(91.82,177.39)
1.05V_LX: length 1.2
  TOP w0.102: T9603.1 88.6,176.01 R9600.2
1.05V_RC: length 1.1
  TOP w0.203: v1(86.92,169) 87.12,169.2 C9611.1
1.05V_VOUT: length 9.3
  TOP w0.203: JP9602.1 89.26,169.31 88.87,168.92 88.87,168.49 v1(88.28,167.9) 87.09,167.9 86.27,168.72 83.72,168.72 83.57,168.87 C9608.1 83.66,169.47 U9600.7
1.5VS_EN: length 15.5
  TOP w0.102: U8400.5 173.47,25.17 173.66,24.99 173.66,24.35 174.12,23.9 C8402.1 172.11,23.21 170.46,24.86 167.06,24.86 166.8,25.11 166.8,26.51 165.79,27.53 v1(165.79,27.91) 164.69,29 R8402.2
1.5VS_IN: length 1
  TOP w0.203: SR8400.1 v1(173.66,27.83)
1.5VS_VDD:
  vias: v1(174.3,24.63)
2.5VO_BST: length 1.9
  TOP w0.508: v1(118.26,62.71) 119.01,62.71 v2(119.18,62.88) 119.61,62.45 R9500.2
2.5VO_EN: length 7.8
  TOP w0.102: v2(120.99,63.39) 122.61,63.39 R9503.2 R9507.2 124.71,62.96 124.71,62.99 v1(124.25,63.45) 124.64,63.83 124.64,63.98 C9511.1
  BOTTOM w0.102: U9500.13 120.97,63.38 v2(120.99,63.39)
2.5VO_FB: length 6.4
  TOP w0.254: v2(120.36,63.39) 120.36,63.59 R9506.2 121.05,64.97 v1(120.75,65.26) 120.53,65.49 119.77,65.49 119.43,65.83 R9505.2 118.58,65.53 118.58,65.28 R9504.1
  BOTTOM w0.203: U9500.12 120.57,63.17 v2(120.36,63.39)
2.5VO_VOUT: length 13.8
  TOP w0.203: JP9502.1 v1(113.16,64.91) 113.82,64.91 114.96,63.77 114.96,63.09 118.8,59.25 118.8,59.22 C9503.1 119.47,58.22 118.98,58.22 v2(118.62,58.58)
  BOTTOM w0.203: v2(118.62,58.58) 119.49,58.58 119.77,58.86 U9500.7
3V_BST:
  vias: v1(215.34,73.93)
3V_BST_R:
  vias: v1(211.86,74.06)
3V_FB: length 5.1
  TOP w0.203: U8100.4 218.22,76.95 v1(218.01,77.16) 217.5,77.66 217.09,77.66 C8114.1 R8105.2 216.76,79.51 216.84,79.59 R8107.2
3V_FB_R: length 21.6
  TOP w0.203: C8114.2 R8105.1 215.9,79.57 215.95,79.62 C8116.2 211.25,80.1 210.56,80.8 209.27,80.8 v2(208.15,81.92)
  BOTTOM w0.229: JP8105.1 199.29,81.2 v1(199.52,80.97)
  BOTTOM w0.254: v2(208.15,81.92) 207.2,80.97 v1(199.52,80.97)
3V_HG: length 7.8
  BOTTOM w1.016: 212.01,64.99 212.01,65.63 214.33,67.94 214.33,71.16 214.79,71.63
  vias: v2(215.47,73.07) v2(216.1,73.07)
3V_LG: length 12.6
  TOP w0.762: 215.81,72.03 212.65,72.03 205.94,65.32
  vias: v2(205.09,65.23) v2(205.06,64.62)
3V_LX:
  vias: v2(214.91,74.94) v2(215.57,74.95)
3V_RC: length 1.1
  BOTTOM w0.508: C8112.1 v1(201.8,63.77)
5V_BST:
  vias: v1(221.16,73.98)
5V_BST_R:
  vias: v1(224.46,73.91)
5V_FB: length 7
  TOP w0.203: v1(220.24,82.26) 220.24,80.71 R8106.2 219.76,79.92 219.96,79.72 R8104.2 C8113.2 219.96,77.67 219.02,76.72 U8100.2
5V_FB_R: length 7.2
  TOP w0.203: C8113.1 R8104.1 220.83,79.52 220.78,79.57 C8115.1 v1(221.72,80.23) 221.67,80.18 221.67,79.57 221.51,79.42 v2(221.51,77.87)
  BOTTOM w0.203: v2(221.51,77.87) 221.64,77.99 JP8103.2
5V_HG: length 12.9
  IN1 w1.016: 223.85,62.68 223.85,65.61 221.95,67.52 221.95,69.92 222.99,70.96 222.99,72.69 222.63,73.04 221.49,73.04
  vias: v2(220.57,73.42) v2(220.58,72.76) v2(224.39,61.62) v2(225.03,61.62)
5V_LG: length 0.8
  BOTTOM w0.508: T8106.1 v2(219.76,72.43)
  vias: v2(219.89,73.04) v2(223.29,68.7) v2(223.31,68.09)
5V_LX: length 5.3
  BOTTOM w1.016: R8100.2 224.24,73.73 T8104.1
  vias: v2(221.95,75.49) v2(222,76.1)
5V_RC:
  vias: v1(221.89,70.38)
5V_VO1: length 12.8
  TOP w0.203: v2(221.77,71.72) 221.7,71.66 219.62,71.66 219.02,72.26 U8100.14
  BOTTOM w0.203: JP8104.2 224.1,77.59 223.93,77.41 222.02,77.41 221.16,76.55 221.16,74.13 221.77,73.53 v1(221.77,72.86) v2(221.77,71.72)
+1.0V: length 279.5
  TOP w0.102: R0737.1 18.72,150.64 v6(18.59,150.51)
  TOP w0.254: R0707.1 16.53,146.83 16.33,146.83 v2(16.18,146.68) ; R0747.1 16.82,149.49 16.76,149.44 R0708.2 v2(16.11,148.99)
  TOP w0.305: v6(56.44,144.64) 56.97,145.18 C1006.2 C1003.2 57.15,146.5 v6(56.95,146.71)
  IN1 w0.254: v2(16.11,148.99) 16.56,148.99 18.09,150.51 v6(18.59,150.51) 18.82,150.28 18.82,148.8 17.04,147.02 16.52,147.02 v2(16.18,146.68) 15.99,146.68 14.44,145.13 14.44,144.64 12.54,142.74 12.54,142.1 11.16,140.73 v2(10.69,140.73) ; v2(140.36,65.09) 141.53,66.26 142.2,66.26 143.2,67.26 144.14,67.26 145.45,68.57 151.26,68.57 153.49,70.8 156.95,70.8 157.81,69.94 168.07,69.94 v2(169.47,71.34)
  IN3 w0.305: v2(10.69,140.73) 11.79,141.84 11.79,144.89 10.96,145.73 10.96,154.49 14.08,157.62 34.92,157.62 40.06,152.48 40.06,152.05 40.69,151.41 41.2,151.41 41.61,151.01 41.61,147.33 43.13,145.81 54.15,145.81 55.3,144.67 56.41,144.67 v6(56.44,144.64)
  IN3 w0.508: v6(64.11,126.8) 63.44,127.47 59.83,127.47 59.34,127.97 59.34,128.05 58.67,128.72 58.67,133.11 57.1,134.69 57.1,137.42 56.66,137.86 56.27,137.86 55.84,138.29 55.84,141.46 56.39,142 56.48,142 57.02,142.55 57.02,144.34 56.72,144.64 v6(56.44,144.64)
  IN4 w0.508: v2(81.2,124.55) 81.2,124.52 83.34,122.38 85.21,122.38 85.8,121.79 85.8,114.57 87.38,113 90.48,113 91.21,113.73 93.9,113.73 94.99,112.65 94.99,111.73 94.67,111.41 94.67,109.76 95.56,108.87 95.56,105.5 108.63,92.43 108.63,85.26 109.82,84.07 112.42,84.07 114.2,82.28 115.97,82.28 116.31,81.94 118.5,81.94 122.31,78.13 122.88,78.13 123.54,77.47 124.4,77.47 124.78,77.08 124.78,76.56 131.02,70.32 131.02,68.71 132.01,67.72 133.04,67.72 135.71,65.04 140.31,65.04 v2(140.36,65.09)
  BOTTOM w0.254: R0736.1 R0739.1 16.83,147.89 16.48,147.53 16.18,147.24 v2(16.18,146.68) ; R0738.1 16.13,148.99 v2(16.11,148.99) ; v2(169.47,71.34) 169.47,70.8 R2450.1
  BOTTOM w0.305: v6(56.95,146.71) 56.97,146.69 U0300.H30 ; v6(56.44,144.64) 56.46,144.67 56.48,144.67 U0300.J28 U0300.H28
  BOTTOM w0.508: v2(140.36,65.09) 140.95,64.5 140.95,62.76 140.28,62.1 T9100.1 140.3,61.35 140.49,61.15 C9101.1 141.43,61.18 U9100.14 ; v6(64.11,126.8) 64.31,126.61 67.08,126.61 67.82,127.35 69.99,127.35 71.27,126.07 71.27,125.2 71.67,124.81 R0729.2 72.14,125.19 72.39,125.44 75.33,125.44 76.22,124.55 v2(81.2,124.55)
+1.0VO: length 18.3
  IN2 w0.508: v2(143.31,67.78) 143.31,67.02 142.28,65.99 142.28,65 142.37,64.92 v2(142.37,64.08)
  IN4 w0.508: v2(142.37,64.08) 145.08,64.08 v2(145.19,63.97) ; v2(143.31,67.78) 141,70.1 v2(141,74.38)
  BOTTOM w0.203: C8216.1 147.97,69.02
  BOTTOM w0.254: v2(141,74.38) 140.91,74.38 140.79,74.5 138.84,74.5 138.73,74.38 U8200.6
  vias: v2(151.62,70.88) v3(150.07,70.52) v3(150.26,71.54) v3(150.96,70.52) v3(151.15,71.54) v3(152.03,71.54)
+1.0VS: length 254.7
  TOP w0.508: v2(136.31,57.68) 135.6,56.96 135.44,56.96 133.19,54.72 131.84,54.72 131.18,54.06 129.15,54.06 127.27,55.93 117.32,55.93 116.46,56.79 111.23,56.79 110.69,56.25 110.33,56.25 109.32,55.25 109.32,51.56 107.59,49.83 104.7,49.83 104.11,49.24 v2(104.11,48.58)
  IN3 w0.305: v2(11.29,144.66) 10.55,145.39 10.55,154.66 13.91,158.03 35.09,158.03 40.46,152.65 40.46,152.21 40.86,151.82 41.37,151.82 42.01,151.18 42.01,147.59 43.38,146.22 55.66,146.22 56.1,145.78 v6(56.1,145.27)
  IN3 w0.508: v2(104.11,48.58) 99,48.58 94.84,52.74 94.84,53.37 94.35,53.85 94.35,59.7 94.69,60.04 94.69,62.88 93.09,64.48 93.09,69.3 91.64,70.74 91.64,73.42 90.68,74.39 90.68,79.4 89.29,80.79 85.61,80.79 83.91,82.49 83.91,85.75 65.57,104.09 65.57,126.49 63.7,128.36 62.79,128.36 62.08,129.08 62.08,137.01 60.57,138.52 57.89,138.52 57.41,139 57.41,140.47 57.63,140.7 57.63,144.59 56.95,145.27 v6(56.1,145.27)
  BOTTOM w0.203: v6(56.1,145.27) 56.52,145.27 56.88,145.63 57.35,145.63 U0300.H29 57.94,146.22 57.94,146.36 U0300.G30 ; v2(11.29,144.66) 12.19,145.56 14.15,145.56 15.29,146.7 15.29,151.24 R0706.2
  BOTTOM w0.508: T9102.1 145.17,58.39 137.03,58.39 v2(136.31,57.68)
+1.0VSUS: length 288.4
  TOP w0.432: R80149.1 18.09,149.82 v6(18.24,149.67) 19.18,149.67 19.66,149.19 R80148.1
  TOP w0.559: R4400.1 7.79,128.74 6.81,128.74 6.02,129.53 v2(6.02,130.14) 5.44,130.14 4.31,129.01 R4401.1 3.48,128.08 v1(3.33,127.93)
  TOP w0.635: R80147.1 v2(16.18,147.97) ; v2(11.23,109.48) 10.99,109.24 5.87,109.24 4.92,110.19 v2(4.92,110.22)
  IN1 w0.635: v2(6.02,130.14) 5.78,130.14 5.35,130.58 5.35,136.62 5.87,137.14 6.23,137.14 6.61,137.53 7.78,137.53 9.14,138.89 9.14,140.14 10.41,141.4 10.43,141.4 13.89,144.87 13.89,145.35 16.18,147.64 v2(16.18,147.97) 16.64,148.43 16.83,148.43 18.07,149.67 v6(18.24,149.67)
  IN2 w0.102: 170.37,57.8 170.74,57.86 ; 169.23,57.87 169.59,57.82 ; 168.06,57.87 168.41,57.83
  IN2 w0.635: v2(24.56,95.72) 24.81,95.72 v2(25.78,94.75) ; 149.77,62.33 150.06,62.62 153.97,62.62 155.26,63.91 155.26,64.5 v2(156.29,65.54) 158.05,67.3 v2(160.88,67.3)
  IN3 w0.102: 34.45,59.37 35.03,59.95 35.03,61.12 34.63,61.52 34.63,62.27 34.47,62.43 33.87,62.43
  IN3 w0.559: 34.45,59.37 33.99,59.84 33.99,61.79 33.87,61.9 33.87,62.43
  IN3 w0.635: v2(24.56,95.72) 21.86,95.72 14.35,103.23 14.35,106.35 v2(11.23,109.48) ; v2(25.78,94.75) 25.79,94.76 26.72,94.76 29.1,92.38 29.1,76.24 28.62,75.77 28.62,70.64 30.66,68.6 30.66,66.27 32.32,64.61 32.47,64.61 33.69,63.39 33.69,62.62 33.87,62.43 ; 149.15,50.81 148.72,50.38 142.42,50.38 139.38,47.34 133.33,47.34 133.16,47.17 131.49,47.17 131.17,47.5 99.6,47.5 98.42,46.32 74.34,46.32 73.43,47.23 66.7,47.23 66.36,46.89 57.41,46.89 57.05,46.54 51.38,46.54 49.89,48.02 47.36,48.02 47.28,47.95 43.89,47.95 37.22,54.62 37.22,56.14 34.45,58.91 34.45,59.37
  IN4 w0.635: v2(6.02,130.14) 6.02,129.97 9.04,126.95 9.04,124.53 11.98,121.59 11.98,110.23 v2(11.23,109.48)
  BOTTOM w0.254: U2000.V17 v2(167.89,54.66)
  BOTTOM w0.432: 5.59,116.53 6.36,116.53 7.06,117.23 R4410.1 ; v2(156.29,65.54) 156.29,66.11 156.31,66.11 R2512.2 ; v6(18.24,149.67) C80134.1 17.65,150.07 17.63,150.1 R80150.1
  BOTTOM w0.635: 5.59,116.53 4.92,115.86 v2(4.92,110.22) ; 154.01,43.06 155.8,44.85 155.8,45.66 156.13,45.99
  vias: v2(148.21,61.43) v2(149.78,62.53) v2(151.66,52.24) v2(152.3,52.24) v2(152.86,53.41) v2(152.93,52.21) v2(156.13,46.78) v2(165.74,55.41) v2(166.04,54.31) v2(166.81,54.31) v2(166.85,55.44) v2(167.03,53.14) v2(167.9,51.57) v2(167.89,50.83) v2(167.89,50.07) v2(167.92,49.24) v2(173.33,54.62) v3(149.02,62.52) v3(148.97,61.65) v3(149.62,63.25) v3(149.86,61.62) v3(150.55,63.34) v3(150.55,62.45)
+1.0VSUS_PWRGD: length 35.2
  TOP w0.102: v2(140.01,69.82) 140.01,68.89 T9210.1 139.99,68.86 139.99,67.52 140.16,67.35 140.71,67.35 141.78,66.27 142.11,66.27 142.24,66.15 142.24,64.83 142.11,64.7 141.31,64.7 140.22,63.61 140.22,63 v2(139.8,62.58) ; v2(138.89,57.27) 137.78,57.27 135.18,54.67 v2(135.18,54.2) 135.18,54.07 134.8,53.69 133.78,53.69 133.66,53.81 132.13,53.81 131.01,52.69 130.03,52.69 129.85,52.5 R9213.1
  BOTTOM w0.102: v2(139.8,62.58) 139.8,62.12 138.48,60.8 138.48,60.42 135.9,57.84 135.9,57.51 136.14,57.27 v2(138.89,57.27) ; v2(140.01,69.82) 140.01,69.94 139.72,70.23 139.46,70.23 139.23,70.45 U8200.12
+1.2VO_DDR: length 16.8
  IN2 w1.016: v3(128.14,62.93) 127.67,62.46 125.03,62.46 124.51,62.98 124.51,66.51 122.68,68.34 118.01,68.34 116.64,69.72
  vias: v3(112.14,72.28) v3(112.14,71.41) v3(112.14,70.55) v3(112.14,69.69) v3(112.14,68.82) v3(113,72.28) v3(113,71.41) v3(113,70.55) v3(113,69.69) v3(113,68.82) v3(113.87,72.28) v3(113.87,71.41) v3(113.87,70.55) v3(113.87,69.69) v3(113.87,68.82) v3(114.73,72.28) v3(114.73,71.41) v3(114.73,70.55) v3(114.73,69.69) v3(114.73,68.82)
+1.5VO: length 2.1
  TOP w0.203: R8401.1 C8400.1 168.2,27.51 JP8400.1
  vias: v1(169.11,28.03)
+1.5VS: length 211.5
  TOP w0.508: U5102.5 25.88,34.67 C5171.1 26.65,35.32 v1(28.02,33.95) 31.1,33.95 32.75,35.6 35.42,35.6 36.99,37.18 v2(38.02,37.18) ; v2(20.17,84.37) 21.13,84.37 25.71,79.79 25.71,77.57 R3612.1
  IN3 w0.508: v2(162.99,30.73) 156.11,30.73 152.4,34.43 145.43,34.43 144.64,35.23 141.89,35.23 141.53,34.87 135.66,34.87 134.52,36.01 124.89,36.01 124.49,36.42 112.85,36.42 112.16,35.72 106.51,35.72 105.44,36.8 82.02,36.8 81.74,37.07 48.83,37.07 48.3,36.54 38.66,36.54 v2(38.02,37.18) 36.7,38.5 36.7,43.92 34.19,46.44 34.19,53.43 32.51,55.1 32.51,55.8 28.37,59.94 28.37,60.93 28.13,61.17 28.13,63.38 28.65,63.9 28.65,66.59 26.72,68.52 26.72,80.15 22.5,84.37 v2(20.17,84.37)
  BOTTOM w0.508: L3600.1 20.24,84.3 v2(20.17,84.37)
  vias: v1(166.04,30.57)
+1.5VS_PWRGD: length 63.9
  TOP w0.102: R9210.1 129.21,47.6 130.18,46.63 T9201.1 130.98,46.48 133.52,46.48 135.48,44.52 135.48,34.27 135.08,33.87 135.08,31.53 134.28,30.73 133.94,30.73 133.58,30.36 133.58,29.47 v2(133.99,29.07) ; U8400.3 170.82,25.67 v2(170.74,25.75)
  IN2 w0.102: v2(133.99,29.07) 134.46,29.54 146.21,29.54 146.57,29.9 160.58,29.9 161.77,28.71 163.72,28.71 165.84,26.58 169.04,26.58 169.48,26.14 170.35,26.14 v2(170.74,25.75)
+1.05VS_VGA_PWRGD: length 301.5
  TOP w0.102: T9208.1 132.39,47.84 v2(132.06,47.84) R9207.1 ; v2(76.94,177.01) 76.94,176.68 75.42,175.16 75.42,170.98 76.25,170.15 82.33,170.15 82.46,170.27 U9600.4
  IN2 w0.102: v2(76.94,177.01) 76.85,177.01 76.14,177.72 55.48,177.72 54.86,178.35 40.95,178.35 40.44,177.84 40.12,177.84 39.17,176.89 36.78,176.89 35.94,176.05 35.94,174.44 34.86,173.36 34.86,170.21 35.33,169.74 35.33,168.55 36.27,167.61 36.27,159.99 34.34,158.06 29.97,158.06 28.8,156.89 25.73,156.89 21.59,152.75 21.59,151.83 21.8,151.62 21.8,145.87 21.51,145.59 21.51,138.27 20.7,137.46 20.36,137.46 19.52,136.62 19.52,131.24 16.99,128.72 16.99,125.65 21.39,121.26 21.39,96.05 30.68,86.75 30.68,78.81 33.96,75.53 33.96,69.25 33.85,69.14 33.85,66.44 34.77,65.52 35.78,65.52 38.58,62.73 38.58,60.85 38.99,60.44 38.99,57.24 41.27,54.96 48.1,54.96 51.87,51.19 64.45,51.19 65.33,50.31 75.51,50.31 76.3,49.52 98.57,49.52 102.64,45.46 112.75,45.46 113.59,46.3 113.59,47.25 113.75,47.41 117.98,47.41 118.21,47.18 123.58,47.18 124.17,47.77 131.99,47.77 v2(132.06,47.84)
+1.35VO_VGA: length 14.8
  TOP w0.381: R8909.2 176.01,89.04 v2(175.82,89.04)
  IN3 w0.508: v2(163.88,93.26) 165.99,93.26 167.23,92.02 171.55,92.02 173.56,90.01 174.55,90.01 175.52,89.04 v2(175.82,89.04)
  vias: v3(156.91,95.63) v3(157.01,94.77) v3(157.02,93.87) v3(157.02,92.98) v3(157.02,92.09) v3(157.02,91.2) v3(157.92,94.74) v3(157.91,93.87) v3(157.91,92.98) v3(157.91,92.09) v3(157.91,91.2) v3(158.8,93.87) v3(158.8,92.98) v3(158.8,92.09) v3(158.8,91.2) v3(159.69,92.93) v3(159.69,92.04) v3(159.69,91.15) v3(160.58,92.08) v3(160.58,91.19) v3(161.36,91.68)
+1V_DCPDSW: length 8.3
  TOP w0.254: v2(177.7,48.49) 177.87,48.33 178.86,48.33 178.99,48.2 180.51,48.2 181.5,47.21 181.5,47.04 181.8,46.74 181.94,46.6 v1(182.17,46.6) 182.27,46.5 C2622.1
  BOTTOM w0.254: v2(177.7,48.49) 177.76,48.56 178.95,48.56 179.4,49 U2000.BA29
+1V_PRIM_W12MIL: length 3.6
  TOP w0.102: 168.07,57.85 168.48,57.85 ; 169.23,57.86 169.65,57.86
  IN3 w0.102: 167.66,49.65 168.22,49.67
  BOTTOM w0.254: v2(170.23,54.65) 170.23,54.67 U2000.AC17 170.61,55.1 U2000.AD15 ; v2(174.42,51.96) U2000.AL22
  vias: v1(166.56,52.62) v2(154.23,54.12) v2(154.65,54.56) v2(155.09,55.01) v2(156.77,54.68) v2(157.2,55.11) v2(157.63,55.56) v2(169.45,51.59) v2(169.51,50.79) v2(169.51,50.02) v2(170.23,50.8) v2(170.23,49.98) v2(171,52.35) v2(171,51.57) v2(171.01,50.82) v2(170.99,50.05) v2(173.28,52.34) v2(173.27,51.57)
+2.5V_PWRGD: length 18.5
  TOP w0.102: R9209.1 128.32,47.46 127.6,46.75 T9200.1 126.53,46.75 126.11,46.33 v2(126.11,46.32)
  BOTTOM w0.102: v2(126.11,46.32) 125.58,46.86 125.58,52.25 121.49,56.33 121.49,58.49 120.97,59.01 U9500.4
+2.5VO:
  vias: v1(113.41,60.68) v3(111.89,63.7) v3(112.5,63.04) v3(113.06,63.72) v3(113.06,62.35)
+3V3_AON: length 381.1
  TOP w0.254: U8702.16 122.73,73.91 125.41,76.59 v2(125.41,76.85) ; v2(123.6,65.75) 122.24,65.75 121.27,66.72 121.27,67.14 121.46,67.33 R8739.2 120.68,67.66 R8737.2 120.43,67.85 119.67,67.85 118.97,68.55 118.97,69.74 118.48,70.23 117.48,70.23 117.09,70.61 R8738.2 116.73,70.88 116.12,71.49 116.12,75.75 117.97,77.59 118.55,77.59 119.7,76.44 119.7,76.05 C8747.1 ; R7000.2 96.9,119.75 97.82,119.75 98.22,120.16 98.22,120.16 R7414.1 98.68,120.62 102.03,120.62 102.54,120.11 102.54,118.2 102.29,117.95 v2(102.29,116.6) ; v2(124.16,76.77) 123.82,76.43 123.82,75.98 123.07,75.23 122.06,75.23 C8746.1 120.94,75.6 120.64,75.6 C8747.1 ; R8736.2 124.94,68.93 124.66,68.65 123.75,68.65 123.09,69.31 v2(122.86,69.31) ; v2(100.3,116.6) v2(101.4,116.6) ; U7002.5 93.99,112.4 93.99,112.4 v2(93.99,112.39) ; C8747.1 119.98,74.94 U8702.4
  TOP w0.305: v2(150.6,130.49) 150.73,130.62 156.33,130.62 158.69,128.26 158.69,117.02 v2(159.17,116.54)
  TOP w0.381: C7028.1 93.56,134.46 93.94,134.46 94.55,135.06 95.44,135.06 96.05,134.46 C7591.1 ; C7591.1 C7592.1 97.45,134.46 97.74,134.17 97.74,133.97 v6(97.84,133.87) ; C7591.1 96.44,134.08 96.66,133.86 v6(97.22,133.86) ; v2(99.62,113.93) v2(100.51,113.93) 101.35,113.93 101.91,113.38 103.33,113.38 v2(103.84,113.89) 103.84,114.29 105.72,116.18 105.72,116.98 105.44,117.26 102.94,117.26 v2(102.29,116.6)
  TOP w1.016: 194.36,81.75 194.36,81.77 191.96,81.77 191.31,82.41 191.31,84.63 191.92,85.23 v3(192.2,85.23)
  IN1 w0.381: v6(97.84,133.87) 99.87,135.9 99.87,144.61 98.92,145.56 v6(98.01,145.56)
  IN1 w0.762: v6(88.4,132.6) 86.58,130.78 85.35,130.78 v2(83.24,128.67) 83.24,127.93 82.35,127.04 82.35,124.99 82.86,124.48 v2(83.3,124.48) 84.7,123.08 85.88,123.08 v2(87.13,121.83) 87.88,121.08 v2(88.16,121.08)
  IN2 w0.254: v2(102.29,116.6) v2(101.4,116.6)
  IN2 w0.762: v3(192.2,85.23) 191.94,84.97 186.31,84.97 184.36,86.91 181.05,86.91 179.76,88.2 178.57,88.2 176.38,90.39 174.48,90.39 v2(173.95,90.91) 173.18,90.14 160.78,90.14 159.29,88.65 159.29,87.39 158.72,86.82 157.36,86.82 153.99,83.45 152.71,83.45 151.48,82.21 151.48,79.93 150.71,79.16 150.71,78.71 149.46,77.46 149.46,77.23 148.33,76.1 147.39,76.1 144.74,78.75 140.41,78.75 137.23,75.56 126.7,75.56 v2(125.41,76.85) 125.33,76.77 v2(124.16,76.77) 124.16,77.69 121.31,80.53 120.03,80.53 118.55,82.01 113.75,82.01 112.12,83.63 110.03,83.63 107.39,86.28 107.39,87.76 89.92,105.23 v2(89.92,110.77)
  IN4 w0.254: v2(173.95,90.91) 163.33,90.91 161.28,92.96 160.67,92.96 156.52,97.11 156.52,103.47 160.3,107.26 160.3,109.21 159.38,111.6 158.56,113.72 158.48,113.94 158.48,116.13 158.89,116.54 v2(159.17,116.54) ; v2(123.6,65.75) 123.62,65.78 123.62,68.55 v2(122.86,69.31)
  IN4 w0.762: v2(89.92,110.77) 89.92,110.87 91.44,112.39 v2(93.99,112.39)
  BOTTOM w0.254: v2(100.3,116.6) 99.84,116.6 99.62,116.82 R7419.1 ; v2(100.51,113.93) R7437.2 R7423.2 ; Q7400.1 98.42,113.26 98.38,113.3 ; v2(83.3,124.48) 82.14,124.48 80.51,122.84 Q7401.1 80.51,120.17 80.82,119.85 80.82,118.54 80.51,118.23 Q7402.1 ; v2(83.3,124.48) 83.3,124.48 83.68,124.09 R7311.1 ; v2(83.3,124.48) 83.94,125.11 R7307.1 ; R7445.1 v2(101.4,116.6) ; R7308.1 83.24,128.82 v2(83.24,128.67) 83.23,128.67 82.83,128.26 R7310.1 83.67,127.17 R7309.1 ; v2(88.16,121.08) 88,120.92 R7406.1 86.46,120.23 85.07,118.84 R7410.1 R7409.1 ; Q7000.1 85.87,132.6 v6(88.4,132.6) 88.4,132.13 88.06,131.79 87.05,131.79 86.82,131.56 86.82,129.91 R7001.1 ; R7405.1 86.9,122.06 v2(87.13,121.83) ; R7439.1 v2(102.29,116.6)
  BOTTOM w0.305: v6(98.01,145.56) 98.46,145.1 U7000.AW30 ; U7000.AY17 97.22,134.42 v6(97.22,133.86) ; v2(150.6,130.49) 150.14,130.95 148.26,130.95 147.12,132.09 R5702.1
  BOTTOM w0.35: U7000.AW32 98.5,146.7 v6(98,146.2) ; v6(97.84,133.87) 97.84,134.04 U7000.AW17
  BOTTOM w0.381: v2(93.99,112.39) 94.28,112.39 94.72,112.82 96.44,112.82 96.92,113.3 99.21,113.3 99.62,113.71 v2(99.62,113.93) R7438.1 R7443.1 ; v2(103.84,113.89) 103.84,114.75 R7444.2
  BOTTOM w0.762: v2(88.16,121.08) 89.31,119.92 89.94,119.92 92.09,117.77 92.09,116.59 92.14,116.54 92.14,114.78 92.23,114.69 92.23,114.58 92.48,114.34 R7208.1 92.89,112.81 93.31,112.39 v2(93.99,112.39)
+3V3_AON_DISCH_A: length 3.3
  BOTTOM w0.381: v1(147.12,135.3) R5702.2 147.83,134.29 147.84,134.28 Q5702.3
+3V3_FLASH: length 69.8
  TOP w0.203: U1201.G1 242.49,48.54 242.22,48.27 242.22,46.76 C1206.1
  TOP w0.254: R1225.1 R1224.1 236.25,49.9 v2(236.09,50.06) ; R1223.1 228.8,56.05 228.28,56.57 v1(227.03,56.57) 227.03,56.28 227.25,56.05 R1103.2 R1106.2 R1104.2 223.95,55.64 223.65,55.34 223.65,54.37 224.33,53.69 U1103.8
  TOP w0.508: U1103.8 224.33,52.42 224.08,52.16 222.68,52.16 C1129.1 R1105.2 223.54,51.07 224.15,50.46 224.15,49.64 v2(224.93,48.86) ; v2(241.22,46) 241.46,46 C1206.1
  IN1 w0.508: v2(236.09,50.06) 236.19,50.06 237.46,48.8 238.69,48.8 238.95,48.53 238.95,47.02 239.97,46 v2(241.22,46)
  IN2 w0.508: v2(236.09,50.06) 235.75,50.4 234.76,50.4 233.99,49.62 231.08,49.62 230.3,50.4 227.56,50.4 226.66,49.5 225.57,49.5 v2(224.93,48.86)
  IN3 w0.508: v2(224.93,48.86) 225.13,48.67 225.13,46.41 224.38,45.66 224.38,38.4 226.47,36.31 v2(226.47,33.68)
  IN4 w0.254: v2(226.47,33.68) 231.3,33.68 234.39,30.58 234.39,30.37 v2(234.68,30.08)
  BOTTOM w0.254: v2(234.68,30.08) 235.1,30.5 R1155.2
+3V3_MAIN: length 513.6
  TOP w0.254: R7400.2 86.97,122.83 87.15,122.65 88.16,122.65 v6(88.52,123) ; v6(88.44,128.67) 87.48,129.63 R7411.1 ; v2(148.17,140.96) 148.55,141.35 156.83,141.35 v2(157.42,140.76) ; v6(88.19,126.89) 88.19,126.76 87.43,126 R7305.1 C7400.1 R7304.1 ; R7306.2 82.3,120.31 v2(87.73,120.31)
  TOP w0.381: U7401.8 77.5,122.57 77.17,122.9 77.17,123.56 77.44,123.84 U7401.7 81.63,123.84 82.15,124.36 82.15,125.21 82.69,125.75 v2(83.31,125.75) 83.31,125.28 83.48,125.11 U7401.3
  TOP w0.432: R7218.1 R7216.1 R7217.1 v2(234.32,114.9)
  TOP w0.508: R8902.1 181.5,80.84 181.89,81.22 181.89,82.44 182.11,82.66 183.78,82.66 184.1,82.34 186.37,82.34 T9101.1 187.3,83.66 v2(189.38,85.74)
  TOP w0.635: 97.73,126.35 95.32,126.35 95.22,126.45 95.18,126.45 94.8,126.83 94.8,126.87 94.22,127.46 90.37,127.46 89.93,127.89 L7203.1 89.63,128.67 v6(88.44,128.67)
  TOP w0.813: 103.28,167.36 v3(103.28,167.35) ; 103.28,167.36 102.78,167.36 102.78,167.35 v1(100.76,167.35) v2(96.19,167.35) ; 103.28,167.36 103.16,167.47 103.16,175.16 103.94,175.94 103.94,182.85 106.24,185.15 129.12,185.15 130.17,184.09 130.45,184.09 131.06,183.48 v2(131.06,182.72)
  TOP w1.016: 155.29,74.79 153.79,73.29 149.53,73.29 148.64,72.4 148.64,64.86 147.19,63.42 147.19,59.8 150.52,56.47 150.52,48.86
  IN1 w0.203: v6(88.19,126.89) 88.75,126.33 88.75,124.45 88.52,124.22 v6(88.52,123)
  IN1 w0.254: v2(87.73,120.31) 88.43,120.31 88.82,120.7 88.82,122.7 v6(88.52,123)
  IN1 w0.432: v2(228.17,102.64) 228.17,102.74 229.79,104.36 229.79,105.76 234.32,110.28 v2(234.32,114.9)
  IN1 w0.508: v6(88.44,128.67) 88.44,127.14 v6(88.19,126.89)
  IN1 w0.762: v3(177.51,86.99) 180.24,86.99 181.95,85.28 188.92,85.28 v2(189.38,85.74)
  IN1 w0.813: v6(88.44,128.67) 88.44,129.25 87.99,129.71 87.07,129.71 85.75,128.39 85.75,126.94 84.56,125.75 v2(83.31,125.75)
  IN2 w0.813: 84.13,126.38 84.13,130.88 83.76,131.24 83.76,149.76 82.09,151.43 82.09,153.24 82.91,154.06 84.32,154.06 84.97,154.71 84.97,160.2 86.39,161.62 87.91,161.62 92.63,166.34 95.68,166.34 96.19,166.84 v2(96.19,167.35)
  IN3 w0.508: v2(189.38,85.74) 189.38,85.72 192.49,82.61 196.28,82.61 196.28,82.61 196.28,82.61 197.57,82.61 204.48,82.61 206.55,84.68 206.55,86.45 207.19,87.09 208.71,87.09 209.47,87.85 211.76,87.85 213.18,89.28 215.87,89.28 216.36,89.54 217.25,90.36 217.79,90.96 221.85,95.02 221.85,95.11 223.83,97.09 223.83,97.2 225.11,98.48 225.34,98.77 228.17,101.6 v2(228.17,102.64) ; v2(150.29,87.11) 150.29,87.65 151.55,88.9 156.04,88.9 157.33,90.19 171.65,90.19 172.97,88.87 174.83,88.87 176.71,86.99 v3(177.51,86.99)
  IN3 w0.762: v3(177.51,86.99) 177.9,87.38 177.9,88.98 176.73,90.16
  IN3 w0.813: v2(159.17,115.74) 158.77,115.74 158.37,116.14 158.37,139.52 157.42,140.47 v2(157.42,140.76) 157.65,140.76 158.37,141.48 158.37,184.04 157.39,185.02 142.22,185.02 v2(141.28,184.08)
  IN4 w0.813: v2(159.17,115.74) 159.18,115.73 159.18,114.52 160.35,111.18 160.96,109.45 160.96,106.9 157.15,103.09 157.15,97.38 160.9,93.63 161.55,93.63 163.5,91.69 v2(174.44,91.69)
  IN4 w1.016: 155.11,76.42 158.49,76.42 159.98,77.91 174,77.91 174.98,78.88 174.98,81.15 175.61,81.79 175.61,82.06 177.51,83.96 v3(177.51,86.99)
  BOTTOM w0.254: v2(148.17,140.96) 148.17,140.83 147.08,139.74 146.63,139.74 146.25,139.36 146.25,138.28 146.75,137.77 R5707.1
  BOTTOM w0.305: U7000.AW15 98.5,133.09 v6(98.87,132.72) ; U7000.AY15 97.6,133.1 v6(97.97,132.73)
  BOTTOM w0.381: v2(150.29,87.11) 150.14,87.11 149.66,87.6 R8706.2
  BOTTOM w0.813: L7100.2 104.11,166.82 103.58,167.35 v3(103.28,167.35) ; v2(131.06,182.72) 131.34,182.44 131.34,180.08 133.78,177.64 138.1,177.64 140.92,180.46 140.92,183.72 v2(141.28,184.08)
  vias: v3(154.9,76.54)
+3V3_MAIN_DISCH_A: length 4.4
  BOTTOM w0.254: R5707.2 148.4,139.12 148.79,138.72 Q5705.3 149.4,139.67 v1(150.11,140.38)
+3V3_TBTA_SX: length 6.4
  TOP w0.076: 242.82,48.02 242.82,48.17 243.24,48.58 243.24,48.94 U1201.H2
  TOP w0.102: 242.82,48.02 242.82,47.87 243.1,47.59 243.79,47.59 C1205.1 245.36,46.02 245.36,45.23 v1(244.86,44.72)
+3V_WLAN: length 12
  TOP w0.254: R5308.1 R5300.1 v2(247.35,95.71)
  IN3 w0.254: v2(247.07,90.9) 246.99,90.98 246.99,95.35 v2(247.35,95.71)
  BOTTOM w0.254: v2(236,93.47) 236,93.31 236,92.3 CON5300.2 ; v2(236.78,93.49) 236.5,93.21 236.5,92.3 CON5300.4
  BOTTOM w0.305: v2(253.42,90.95) 253.5,91.03 CON5300.72 ; v2(254.05,90.95) 254,91 CON5300.74
  vias: v1(242.8,91.36)
+3VA: length 719.1
  TOP w0.381: v2(223.63,76.01) 223.63,76.63 223.83,76.83 SR8102.2
  TOP w0.508: R4592.1 39.62,178.66 38.79,179.49 v2(38.79,179.54) ; JP9300.1 14.05,181.19 v2(14.05,179.81) ; v2(162.13,107.25) 162.13,107.77 161.67,108.73 160.73,110.69 158.51,115.66 158.16,116.53 158.16,127.61 v2(156.86,128.91) ; R3161.2 189.17,28.2 v2(188.85,28.52) ; v2(146.71,183.94) 147.37,184.6 155.52,184.6 158.58,181.54 158.58,167.64 v2(157.02,166.08) ; v2(100.79,35.23) 100.79,41.18 107.09,47.48 107.48,47.48 R3000.1 ; v2(208.76,83.81) 208.88,83.93 210.01,83.93 210.79,83.15 212.75,83.15 213.23,83.63 216.41,83.63 T8121.1 ; v2(205.01,32.94) 205.01,32.56 205.57,32 206,32 206.63,31.37 206.63,30.22 206.1,29.68 206.1,28.95 209.75,25.29 R8811.2 214.68,25.48 215.18,25.97 216.23,25.97 216.58,26.33 217.26,26.33 217.84,25.74 v2(218.95,25.74) ; 220.45,83.74 JP9303.1
  IN1 w0.508: v2(146.71,183.94) 145.34,185.31 100.43,185.31 v2(100.25,185.13) 98.48,183.35 96.95,183.35 94.41,180.81 85.7,180.81 84.31,179.42 82.22,179.42 80.95,180.69 v2(78.28,180.69) ; v2(189.31,32.78) 189.9,32.19 189.9,30.86 188.85,29.81 v2(188.85,28.52) ; v2(157.02,166.08) 156.13,165.19 156.13,158.97 156.44,158.67 157.45,158.67 v2(157.53,158.59) ; v2(13.01,164.73) 10.39,164.73 6.58,160.92 6.58,147.28 7.77,146.08 7.77,143.89 3.43,139.54 3.43,125.59 4.72,124.3 4.72,116.84 v2(6.4,115.17)
  IN2 w0.508: v2(230.35,23.65) 228.38,21.67 224.16,21.67 223.49,22.34 221.1,22.34 218.95,24.5 v2(218.95,25.74)
  IN3 w0.508: v2(14.05,179.81) 14.34,179.52 26.11,179.52 26.51,179.12 38.36,179.12 v2(38.79,179.54) 38.79,180.05 39.17,180.44 44.32,180.44 45.76,178.99 47.57,178.99 49.3,180.72 74.15,180.72 75.64,179.23 77.07,179.23 78.28,180.44 v2(78.28,180.69) ; 223.62,76.01 v2(223.63,76.01) ; 223.62,76.01 223.62,76.9 223.02,77.5 223.02,82.7 222.01,83.71 v2(222.01,83.71) ; 223.62,76.01 223.62,75.4 222.25,74.03 219.84,74.03 218.41,72.6 216.7,72.6 215.45,71.34 215.45,66.83 215.98,66.3 215.98,59.42 216.38,59.02 217.23,59.02 218.57,57.69 218.57,54.38 220.27,52.68 220.27,39.79 219.45,38.97 219.45,37.86 219.04,37.46 219.04,36.73 217.93,35.62 213.57,35.62 210.75,32.8 209.23,32.8 207.11,30.68 206.79,30.68 206.07,29.96 205.35,29.96 205.01,30.31 v2(205.01,32.94) 205.01,34.1 204.49,34.62 203.11,34.62 200.99,32.5 199.1,32.5 199.02,32.42 197.48,32.42 194.63,29.57 193.21,29.57 193.2,29.58 192.69,29.58 192.68,29.57 192.47,29.57 191.84,28.95 189.28,28.95 v2(188.85,28.52) 188.24,28.52 187.87,28.89 177.78,28.89 177,28.11 167.26,28.11 166.32,29.05 161.92,29.05 160.96,30.01 155.94,30.01 154.85,31.09 145.15,31.09 144.52,31.72 135.57,31.72 134.67,32.63 123.8,32.63 123.31,33.11 114.11,33.11 113.66,33.56 113.66,33.58 113.28,33.95 103.45,33.95 102.17,35.23 v2(100.79,35.23)
  IN4 w0.508: v2(192.48,84.27) 189.38,84.27 188.08,85.56 182.68,85.56 180.95,87.29 179.88,87.29 178.15,89.03 177,89.03 176.46,89.57 176.46,91.39 175.38,92.47 163.81,92.47 163.27,93.01 163.27,93.03 161.9,94.41 161.26,94.41 158.09,97.57 158.09,102.89 162.13,106.93 v2(162.13,107.25) ; v2(38.79,179.54) 38.79,178.02 40.89,175.91 40.89,169.23 39.14,167.48 30.39,167.48 29.08,166.17 27,166.17 26.09,165.27 13.97,165.27 13.43,164.73 v2(13.01,164.73)
  BOTTOM w0.254: R5704.1 155.12,138.9 155.13,138.9 155.13,138.54 155.96,137.71 157.92,137.71
  BOTTOM w0.279: CON5602.20 39.25,178.53 40.11,179.39 40.11,179.92 39.78,180.24 38.93,180.24 38.79,180.1 v2(38.79,179.54)
  BOTTOM w0.457: R4412.1 8.97,117.09 7.05,115.17 v2(6.4,115.17)
  BOTTOM w0.508: R6001.1 229.11,21.27 230.35,22.52 v2(230.35,23.65) ; v2(189.31,32.78) 189.31,32.96 188.68,33.59 R2619.2 ; D6006.2 228.27,26.42 228.27,24.45 227.98,24.16 D6005.2 225.76,24.16 224.54,22.93 221.71,22.93 218.95,25.69 v2(218.95,25.74) ; JP9301.1 JP9302.1 214.27,89.55 212.68,87.96 209.32,87.96 208.76,87.4 v2(208.76,83.81) 208.43,84.15 205.91,84.15 204.37,82.61 194.25,82.61 192.59,84.27 v2(192.48,84.27) ; v2(157.53,158.59) 158.12,158 158.12,137.91 157.92,137.71 157.92,133.49 157.67,133.24 155.8,133.24 155.55,132.98 155.55,129.86 155.9,129.51 156.26,129.51 v2(156.86,128.91)
+3VA_EC: length 178.2
  TOP w0.152: v2(118.72,35.68) 119.33,36.29 120.73,36.29 121.06,35.96 121.06,35.35 121.36,35.04 122.43,35.04 125.37,32.1 125.37,30.57 125.58,30.37 125.58,28.72 125.37,28.52 123.8,28.52 123.67,28.39 123.67,27.55 123.49,27.37 C3004.1
  TOP w0.178: U3001.3 124.32,46.44 124.89,47.01 125.33,47.01 C3023.1 ; v2(134.21,39.41) 134.21,40.43 133.73,40.91 131.9,40.91 131.57,40.58 130.12,40.58 C3002.1 127.99,41.04 127.71,40.75 U3001.121 ; U3001.26 115.12,46.19 115.24,46.31 115.24,46.61 114.92,46.92 114.92,47.33 C3024.1 ; U3001.127 127.91,43.15 ; 109.8,36.44 109.88,36.44 110.19,36.75 U3001.50 ; U3001.92 123.52,28.72 122.99,28.19 C3004.1 ; U3001.114 128.18,37.95 128.76,38.52 130.07,38.52 C3001.1
  TOP w0.203: v2(131.93,32.01) 131.93,31.69 R3001.1
  TOP w0.254: v2(134.39,41.95) 133.86,42.49 131.85,42.49 131.26,41.9 R3065.1 R3053.1 130.01,43.23 129.96,43.23 C3025.1 129.3,43.15 127.91,43.15 ; v2(117.27,51.83) 117.27,51.33 R3061.1
  TOP w0.305: v1(108.66,37.3) 109.19,37.3 v2(109.32,37.18) 109.32,36.85 109.22,36.75 C3003.1 109.7,36.34 109.8,36.44 ; R3071.1 132.66,34.59 v2(132.61,34.54) ; v2(134.39,41.95) 134.72,42.28 134.72,43.07 134.47,43.32 v2(134.47,44.09) 134.47,44.56 133.55,45.48 R3005.1 ; C3023.1 126.49,47.84 126.68,48.04 126.68,52.43 125.36,53.75 125.36,54.34 124.98,54.72 124.15,54.72 123.88,54.45 123.88,54.37 R5004.1 ; R3070.1 132.69,37.38 v2(132.61,37.45) 132.61,37.46 131.98,38.09 130.99,38.09 130.96,38.07 C3001.1
  TOP w0.381: C3024.1 113.78,47.58 113.78,46.71 v2(114,46.5) ; R3047.1 113.72,24.73 114.24,24.21 v2(114.43,24.21)
  TOP w0.508: v2(117.27,51.83) 117.52,52.08 117.52,53.68 118.05,54.22 R5014.2 118.47,53.98 D5004.1 120.18,54.79 123.03,54.79 123.52,54.3 R5004.1 ; R3000.2 109.55,47.72 109.69,47.58 C3000.1 C3019.1 C3020.1 113.78,47.58
  IN3 w0.508: v2(118.72,35.68) 119.28,35.12 121.66,35.12 121.94,35.4 131.98,35.4 132.61,34.76 v2(132.61,34.54)
  BOTTOM w0.305: v2(114.43,24.21) 114.43,24.66 115.81,26.04 119.37,26.04 119.82,26.5 119.82,30.41 118.95,31.28 118.95,32.68 118.72,32.91 v2(118.72,35.68) 118.72,36.2 119.57,37.05 119.57,38.87 119.25,39.18 119.25,41.63 120.93,43.3 121.69,43.3 123.37,44.98 123.37,50.14 122.76,50.74 118.97,50.74 117.88,51.83 v2(117.27,51.83)
  BOTTOM w0.508: v2(109.32,37.18) 109.32,39.74 113.31,43.73 113.31,45.81 v2(114,46.5) 114,47.08 113.13,47.94 113.13,50.52 114.44,51.83 v2(117.27,51.83) ; v2(131.93,32.01) 131.93,33.85 v2(132.61,34.54) v2(132.61,37.45) 132.61,38.14 133.23,38.75 133.83,38.75 134.21,39.14 v2(134.21,39.41) 134.39,39.59 v2(134.39,41.95)
+3VA_PWR: length 3.8
  TOP w0.254: CON402.20 185.7,175.2 v1(185.6,175.1) 186.02,174.68 PSR701.1
+3VA_PWR_HS: length 38.5
  TOP w0.127: PR700.2 v2(185.19,172.55) ; PR700.2 v1(184.23,173.19) ; PR700.2 PSR701.2 ; PR702.2 v2(210.86,171.92) PC701.1 v2(210.23,171.23)
  IN1 w0.127: v2(185.19,172.55) 185.31,172.42 207.88,172.42 209.08,171.23 v2(210.23,171.23)
  BOTTOM w0.127: v2(210.86,171.92) 210.86,176.35 210.2,177.01 PU701.1
+3VACC: length 6.1
  TOP w0.178: C3021.1 116.32,27.92 U3001.74
  TOP w0.381: v1(112.57,26.8) 112.95,26.42 R3047.2 114.37,27.07 C3021.1
+3VO: length 524.6
  TOP w0.508: v2(151.41,46.83) 151.64,46.6 Q9100.3 ; 143.13,55.12 143.13,56.28 143.69,56.84 143.69,66.54 143.96,66.82 v2(143.96,67.78) ; 143.13,55.12 v2(145.02,53.23) ; 143.13,55.12 143,55.25 v2(141.64,55.25)
  TOP w0.711: Q9100.3 151.64,44.87 153.49,43.02 154.31,43.02 155.5,41.83 155.5,40.81 154.38,39.69 154.38,34.74 154.56,34.56
  IN1 w0.203: v2(11.94,160.55) 8.81,160.55 7.04,158.77 7.04,147.47 8.23,146.27 8.23,143.7 3.96,139.43 3.96,125.7 5.18,124.49 5.18,117.03 6.86,115.35 6.86,111.67 6.14,110.95 4.99,110.95 4.16,110.12 4.16,107.91 5.68,106.39 5.68,92.52 3.99,90.83 3.99,86.2 6.81,83.38 9.49,83.38 10.86,82.01 11.49,82.01 11.91,81.59 20.23,81.59 24.42,77.41 24.42,71.68 25.25,70.84 25.25,69.65 28.28,66.62 28.28,59.98 31.38,56.87 31.38,55.6 35.66,51.33 38.95,51.33 40.41,49.86 47.68,49.86 48.83,51.01 61.1,51.01 62.07,50.04 65.01,50.04 65.97,51 100.26,51 103.26,54 111.82,54 112.31,54.49 123.65,54.49 124.09,54.93 135.41,54.93 135.74,55.25 v2(141.64,55.25)
  IN1 w0.254: v2(70.05,165.32) 66.22,165.32 63.38,168.16 59.32,168.16 57.46,170.02 57.46,172.31 56.31,173.45 54.15,173.45 53.9,173.19 53.9,171.92 53.14,171.16 52.17,171.16 50.22,173.12 48.16,173.12 47.35,172.31 v2(47.35,172.1)
  IN2 w0.508: v2(151.41,46.83) 151.41,48.48 149.89,50 146.36,50 145.02,51.34 v2(145.02,53.23)
  IN3 w0.762: 155.8,33.11 157.28,33.11 157.73,32.66 157.73,32.12 158.37,31.49 163.43,31.49 164.03,30.89 164.03,30.86 164.9,29.99 167.18,29.99 167.44,30.25 170.4,30.25 171.81,28.85 174.6,28.85 174.87,29.11 174.87,29.61 ; 174.87,29.61 175.16,29.9 191.47,29.9 191.89,30.32 192.38,30.32 192.38,30.32 193.5,30.32 193.5,30.32 194.34,30.32 197.19,33.18 198.59,33.18 201.12,35.7 202.29,35.7 203.37,36.79 203.37,37.28 203.95,37.86 213.74,37.86 215.34,39.46 215.34,43.39 215.05,43.68 215.05,46.59 215.14,46.68 215.14,47.69 214.25,48.57 214.25,50.61 213.66,51.2 213.66,57.86 213,58.51 213,63.87 214.1,64.96 214.1,65.6 213.02,66.68 213.02,74.2 214.95,76.13 214.95,76.13 ; 174.87,29.61 v2(174.87,29.61)
  IN4 w0.203: v2(78.49,153.51) 78.66,153.51 79.11,153.96 79.11,157.48 81.43,159.8 81.43,160.75 80.77,161.41 79.24,161.41 78.93,161.71 v2(76.4,161.71) 69.5,161.71 68.78,162.44 68.78,164.19 69.91,165.32 v2(70.05,165.32) ; v2(47.35,172.1) 46.64,171.4 45.51,171.4 40.25,166.14 35.58,166.14 34.39,164.95 26.8,164.95 26.26,164.42 26.26,160.62 24.23,158.59 12.78,158.59 11.94,159.43 v2(11.94,160.55)
  IN4 w0.254: v2(141,75.12) 141.55,74.56 141.55,70.81 143.96,68.4 v2(143.96,67.78)
  BOTTOM w0.203: SR9400.1 v2(78.49,153.51) ; v2(76.4,161.71) 76.12,161.43 R9404.2
  BOTTOM w0.254: R8203.2 142.6,68.42 142.72,68.29 143.63,68.29 143.96,67.96 v2(143.96,67.78) ; v2(141,75.12) 140.74,74.86 139.57,74.86 SR8200.1
  BOTTOM w0.762: 204.8,79.34 203.71,79.34
  BOTTOM w1.016: 215.32,76.8 214.66,77.46 205.54,77.46
  vias: v2(155.12,34.69) v2(156,34.69) v2(215.52,76.93) v2(215.54,76.29) v2(219.33,88.28) v2(219.94,88.28) v3(193.35,72.62) v3(193.97,74.12) v3(194.23,73.17) v3(194.23,72.28) v3(194.86,74.11) v3(195.12,73.17) v3(195.12,72.28) v3(196.01,73.17) v3(196.01,72.28) v3(196.9,73.17) v3(196.9,72.28) v3(197.79,73.17) v3(197.79,72.28) v3(197.87,74.06) v3(197.9,71.02)
