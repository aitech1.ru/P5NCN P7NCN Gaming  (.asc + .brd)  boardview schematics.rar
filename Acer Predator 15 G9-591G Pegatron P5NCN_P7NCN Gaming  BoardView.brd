# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMID_DDI2_DATA2#: length 263.8
  TOP w0.114: C1306.1 205.89,51.68 205.75,51.68 205.33,51.26 204.74,51.26 204.52,51.48 204.52,52.16 v2(204.47,52.21)
  IN2 w0.095: v6(59.22,150.09) 59.32,149.98 59.72,149.98 60.39,149.31 61.57,149.31 62.72,150.46 70.73,150.46 76.51,144.69 76.51,119.6 79.88,116.23 79.88,105.72 101.25,84.35 101.25,77 106.35,71.89 106.35,67.29 107.04,66.61 107.04,62.83 107.97,61.9 107.97,59.48 110.14,57.31 115.72,57.31 116.81,56.23 130.66,56.23 132.75,58.31 136.96,58.31 138.47,59.83 138.47,63.08 138.71,63.31 138.71,64.33 139.87,65.49 139.87,66.9 142.26,69.29 147.28,69.29 147.85,68.71 151.84,68.71 156.56,73.44 159.27,73.44 160.01,74.18 164.08,74.18 165.6,75.7 170.2,75.7 171.78,77.28 173.57,77.28 174.8,78.51 183.63,78.51 184.7,79.57 188.52,79.57 189.11,78.99 201.21,78.99 207.91,72.29 207.91,72 207.91,72 207.91,61.95 207.16,61.2 207.16,57.76 206.41,57.02 206.41,52.1 205.46,51.15 204.73,51.15 204.47,51.41 v2(204.47,52.21)
  BOTTOM w0.114: v6(59.22,150.09) 59.15,150.09 U0300.F35
HDMID_DDI2_DATA2#_C: length 3.4
  TOP w0.114: C1306.2 207.33,51.79 207.84,51.79 208.76,52.72 209.49,52.72 209.6,52.61 U1301.45
HDMID_DDI2_DATA2_C: length 3.4
  TOP w0.114: U1301.44 209.59,53.11 209.43,52.95 208.66,52.95 207.74,52.03 207.29,52.03 C1313.2
HDMID_DDI2_DATA3: length 264.7
  TOP w0.114: v2(204.57,49.95) 205.31,50.69 205.9,50.69 C1308.1
  IN2 w0.095: v2(204.57,49.95) 204.57,50 204.96,50.39 205.35,50.39 205.66,50.7 206.03,50.7 206.98,51.66 206.98,56.79 207.56,57.36 207.56,58.71 208.35,59.5 208.35,72.98 201.95,79.39 189.27,79.39 188.68,79.97 184.69,79.97 184.62,80.04 183.31,80.04 182.27,79 174.72,79 173.42,77.7 169.74,77.7 168.67,76.62 164.15,76.62 163.77,76.24 163.77,75.36 163.19,74.78 159.92,74.78 158.98,73.84 156.4,73.84 151.68,69.12 148.27,69.12 147.7,69.69 142.09,69.69 139.33,66.93 139.33,66.15 138.3,65.12 138.3,63.65 138.07,63.42 138.07,60 136.82,58.75 132.62,58.75 130.82,56.95 116.67,56.95 115.73,57.88 112.61,57.88 107.46,63.03 107.46,66.8 106.82,67.44 106.82,71.99 101.73,77.09 101.73,84.68 80.45,105.96 80.45,116.46 77.06,119.85 77.06,144.71 70.26,151.5 63.99,151.5 63.87,151.39 63.87,151.23 v2(64.06,151.04)
  BOTTOM w0.076: v2(64.06,151.04) 63.65,151.46 63.65,151.59 62.81,152.42 61.69,152.42 61.24,152.87 60.04,152.87 59.62,152.45 59.62,151.08 U0300.E37
HDMID_DDI2_DATA3#: length 264.9
  TOP w0.114: C1310.1 205.71,49.98 205.71,50.28 205.54,50.46 205.41,50.46 205.23,50.28 v2(205.23,49.98)
  IN2 w0.095: v2(205.23,49.98) 205.75,50.49 206.11,50.49 207.19,51.57 207.19,56.7 207.77,57.27 207.77,58.62 208.56,59.41 208.56,73.07 202.03,79.59 189.36,79.59 188.77,80.18 184.77,80.18 184.71,80.25 183.23,80.25 182.18,79.21 174.63,79.21 173.33,77.91 169.65,77.91 168.58,76.83 164.06,76.83 163.56,76.33 163.56,75.45 163.1,74.99 159.84,74.99 158.89,74.04 156.31,74.04 151.59,69.33 148.36,69.33 147.79,69.9 142,69.9 139.12,67.01 139.12,66.23 138.09,65.21 138.09,63.74 137.86,63.51 137.86,60.09 136.73,58.96 132.53,58.96 130.73,57.16 116.75,57.16 115.82,58.09 112.7,58.09 107.67,63.12 107.67,66.89 107.03,67.53 107.03,72.08 101.94,77.17 101.94,84.76 80.66,106.04 80.66,116.55 77.27,119.94 77.27,144.8 70.35,151.71 63.9,151.71 63.66,151.47 63.66,151.26 v2(63.45,151.04)
  BOTTOM w0.076: v2(63.45,151.04) 63.45,151.5 62.73,152.22 61.61,152.22 61.16,152.67 60.12,152.67 59.8,152.35 59.8,151.41 59.93,151.29 59.93,150.93 59.61,150.62 U0300.E36
HDMID_DDI2_DATA3#_C: length 3.8
  TOP w0.114: U1301.48 209.63,51.11 209.5,51.24 209.07,51.24 207.89,50.06 ; 207.89,50.06 v1(208.08,49.88) ; 207.89,50.06 207.68,49.85 207.21,49.85 C1310.2
HDMID_DDI2_DATA3_C: length 3.9
  TOP w0.114: 208.77,51.27 207.58,50.09 207.37,50.09 C1308.2 ; 208.77,51.27 208.97,51.47 209.47,51.47 209.61,51.61 U1301.47 ; 208.77,51.27 v1(208.61,51.43)
HDMID_TMDSD_DATA0: length 29
  TOP w0.114: 218.04,55.97 217.07,55.97 216.93,56.11 U1301.23 ; 218.04,55.97 220.61,55.97 221.5,55.08 221.5,45.31 221.83,44.97 221.83,44.08 221.67,43.91 221.67,42.82 226.34,38.14 230.29,38.14 C1119.1 ; 218.04,55.97 v1(218.04,56.21)
HDMID_TMDSD_DATA0#: length 29
  TOP w0.114: 219.9,55.74 217.11,55.74 216.99,55.61 U1301.22 ; 219.9,55.74 v1(219.9,55.5) ; 219.9,55.74 220.51,55.74 221.26,54.98 221.26,45.21 221.6,44.87 221.6,44.17 221.43,44.01 221.43,42.72 226.24,37.91 230.26,37.91 C1120.1
HDMID_TMDSD_DATA1: length 30.2
  TOP w0.114: 220.27,53.18 218.95,54.49 217.05,54.49 216.93,54.61 U1301.20 ; 220.27,53.18 220.64,52.81 220.64,42.52 225.94,37.23 227.2,37.23 228.02,36.42 229.69,36.42 229.96,36.14 232.36,36.14 232.64,36.42 C1121.1 ; 220.27,53.18 v1(220.45,53.36)
HDMID_TMDSD_DATA1#: length 30.1
  TOP w0.114: 218.54,54.26 217.08,54.26 216.93,54.11 U1301.19 ; 218.54,54.26 v1(218.54,54.02) ; 218.54,54.26 218.86,54.26 220.41,52.71 220.41,42.43 225.84,36.99 227.11,36.99 227.92,36.18 229.59,36.18 229.87,35.91 232.45,35.91 C1122.1
HDMID_TMDSD_DATA2: length 27.4
  TOP w0.114: U1301.17 216.94,53.11 217.05,53 218.68,53 219.78,51.89 219.78,41.96 225.7,36.03 226.39,36.03 ; 226.39,36.03 v1(226.39,36.29) ; 226.39,36.03 227.08,36.03 227.57,35.54 228.89,35.54 229.48,34.96 230,34.96 C1123.1
HDMID_TMDSD_DATA2#: length 27.5
  TOP w0.114: v1(217.7,52.49) 217.7,52.76 ; 217.7,52.76 217.04,52.76 216.89,52.61 U1301.16 ; 217.7,52.76 218.58,52.76 219.55,51.79 219.55,41.86 225.61,35.8 226.98,35.8 227.47,35.3 228.79,35.3 229.38,34.72 230.01,34.72 C1124.1
HDMID_TMDSD_DATA3: length 29.5
  TOP w0.114: v1(228.37,34.1) 228.37,33.86 ; 228.37,33.86 232.38,33.86 C1125.1 ; 228.37,33.86 227.91,33.86 226.9,34.87 225.58,34.87 218.93,41.52 218.93,50.98 218.29,51.61 217.21,51.61 217.1,51.5 216.82,51.5 216.7,51.61 U1301.14
HDMID_TMDSD_DATA3#: length 29.5
  TOP w0.114: 225.7,34.63 225.48,34.63 218.69,41.42 218.69,50.88 218.2,51.38 217.31,51.38 217.2,51.26 216.84,51.26 216.69,51.11 U1301.13 ; 225.7,34.63 226.8,34.63 227.81,33.62 232.43,33.62 C1126.1 ; 225.7,34.63 v1(225.7,34.38)
HG_C: length 19.2
  TOP w0.508: v3(68.87,171.4) 69.88,172.41 73.9,172.41 74.48,172.99 74.48,174.96 75.65,176.13 75.65,177.37 76.29,178.02 v2(77.73,178.02)
  BOTTOM w0.508: Q8002.4 81.79,176.29 80.06,178.02 v1(79.17,178.02) v2(77.73,178.02)
HOOK3_SPI_MOSI_VRM_PWRGD: length 17.8
  BOTTOM w0.102: R4414.1 R4411.2 9.83,118.87 10.37,119.42 10.37,120.36 10.2,120.54 R4417.1 C4403.1 10.29,121.83 10.29,122.73 v1(10.74,123.18) 11.21,123.65 11.21,124.68 10.17,125.72 7.83,125.72 7.52,126.04 7.52,126.87 7.7,127.05 7.7,129.76 7.8,129.85 XDP4400.47
HOOK6_ITP_PMODE_PLTRST_CPU#: length 17.3
  BOTTOM w0.102: R4410.2 R4413.1 5.57,118.43 v1(5.23,118.76) 5.89,119.42 R4418.1 5.47,120.09 5.47,120.96 R4423.1 5.64,121.38 5.36,121.66 5.36,125.59 6.34,126.58 6.34,129.07 5.93,129.48 5.38,129.48 4.51,130.35 XDP4400.46
HPD_DDPB_DP1_Q: length 10.5
  TOP w0.102: v1(177.09,69.97) 177.55,69.51 177.55,69 178.3,68.25 178.37,68.25 R2149.1 179.16,67.46 179.16,66.05 178.96,65.85 178.96,65.17 178.15,64.36 178.15,62.75 v2(179.2,61.7)
  BOTTOM w0.089: U2000.AW4 178.89,61.39 v2(179.2,61.7)
HPD_DDPC_HDMI: length 65.7
  TOP w0.102: U1301.9 214.41,50.28 213.95,49.83 213.8,49.83 212.95,48.98 R2163.1 213.4,48.14 213.4,46.63 212.83,46.07 211.25,46.07 211.16,45.98 209.72,45.98 209.02,46.68 206.6,46.68 205.65,47.63 204.5,47.63 v1(203.75,48.38) 201.96,50.17 201.96,53.6 202.46,54.11 v2(203.71,54.11)
  IN4 w0.102: v2(203.71,54.11) 202.04,55.78 201.97,55.78 198.68,59.07 198.68,62.18 196.59,64.28 190.6,64.28 190.13,64.75 190.13,65.21 185.75,69.59 179.14,69.59 v2(178.59,69.03)
  BOTTOM w0.089: 179.02,63.11 178.8,62.89 178.8,62.52 U2000.AY2
  BOTTOM w0.102: v2(178.59,69.03) 179.3,69.03 179.79,68.53 179.79,67.26 R2152.2 179.38,65.5 179.3,65.42 179.3,63.39 179.02,63.11
HPD_DDPC_HDMI_R: length 36.9
  TOP w0.102: v2(229.07,51.29) 229.07,50.71 228.62,50.25 228.62,49.6 229.18,49.03 229.18,46.03 229.16,46.01 229.16,44.14 229.85,43.45 230.04,43.45 230.48,43 R1119.1 230.48,41.58 231.21,40.85 235.14,40.85 236.78,39.21 237.85,39.21 238.08,38.98 238.08,38.58 U1101.AA2 ; U1301.11 v2(215.41,49.8)
  IN4 w0.102: v2(215.41,49.8) 215.41,49.79 216.21,48.99 219.62,48.99 221.32,50.69 226.39,50.69 226.99,51.29 v2(229.07,51.29)
  BOTTOM w0.102: v2(215.41,49.8) 215.59,49.99 v1(215.59,50.73)
HPD_DDPD_DP: length 83.2
  TOP w0.102: R2127.1 176.53,66.59 176.53,64.94 v1(176.73,64.74) 176.95,64.52 176.95,61.87 178.1,60.72 v2(178.49,60.72) ; U1401.9 213.52,35.27 214.08,34.7 214.08,32.22 211.32,29.46 209.61,29.46 208.1,30.96 208.1,31.22 206.61,32.71 206.61,33.94 206.11,34.44 203.65,34.44 202.92,35.17 202.92,35.88 201.75,37.05 v2(201.45,37.05)
  IN1 w0.102: v2(201.45,37.05) 201.45,38.59 197.89,42.15 197.89,44.76 196.67,45.98 196.67,50.89 194.87,52.7 194.87,60 192.48,62.39 192.48,65.16 191.11,66.53 185.67,66.53 183.94,68.26 183.27,68.26 179.67,64.66 179.67,63.75 178.08,62.15 178.08,61.13 v2(178.49,60.72)
  BOTTOM w0.089: U2000.AV4 178.02,61.19 v2(178.49,60.72)
HPD_DDPD_DP_R: length 35.2
  TOP w0.102: U1101.Y6 238.55,36.35 v4(238.87,36.02) ; v2(215.82,34.05) 215.82,34.42 214.52,35.72 U1401.11
  IN2 w0.102: v2(215.82,34.05) 216.59,33.29 218.21,33.29 219.13,34.21 219.13,34.63 224.18,39.68 225.29,39.68 225.5,39.46 226.24,39.46 226.51,39.19 228.55,39.19 v2(229.26,39.9)
  IN4 w0.102: v4(238.87,36.02) 238.73,36.16 238.05,36.16 237.65,36.56 237.65,37 237.43,37.23 235.89,37.23 234.92,38.2 233.58,38.2 232.27,39.51 229.33,39.51 229.26,39.59 v2(229.26,39.9)
  BOTTOM w0.102: v4(238.87,36.02) 238.69,36.02 238.51,36.2 238.11,36.2 237.52,36.8 v1(237.52,36.97) 237.52,37.61 R1142.1
HPD_IFPC_DP2: length 309.9
  TOP w0.102: v2(246.53,101.75) 246.92,102.14 U4601.9 ; R2377.1 176.45,32.93 176.42,32.9 176.42,31.64 176.08,31.29 174.71,31.29 174.44,31.56 172.74,31.56 172.44,31.26 172.44,30.7 172.82,30.32 172.82,30.17 173.38,29.61 v2(173.38,29.61) ; v1(209.35,82.03) 209.35,82.4 209.3,82.45 v2(209.3,82.84)
  IN1 w0.102: v2(183.26,39.06) 184.19,39.06 184.89,38.36 184.89,35.1 183.23,33.44 181.94,33.44 181.32,32.83 181.32,32.49 178.87,30.04 176.2,30.04 175.36,29.2 173.79,29.2 v2(173.38,29.61) ; v2(190.02,82.77) 190.28,83.03 192.59,83.03 192.95,83.39 192.95,84.42 192.67,84.71 192.49,84.7 191.31,84.7 190.98,85.02 190.98,85.61 189.87,86.72 188.53,86.96 187.05,86.96 186.5,87.51 184.12,87.51 183.15,88.49 182.67,88.49 182.3,88.85 181,88.85 180.76,88.62 174.9,88.62 173.86,89.65 161.51,89.65 158.6,86.73 155.8,86.73 154.65,87.89 143.37,87.89 142.75,87.27 140.02,87.27 138.15,85.4 123.56,85.4 120.67,82.5 118.28,82.5 117.26,83.53 113.75,83.53 112.56,84.72 112.56,87.7 98.07,102.19 98.07,110.1 v2(98.65,110.69)
  IN2 w0.102: v2(183.26,39.06) 183.26,39.51 183.52,39.77 184.22,39.77 184.52,40.07 199.88,40.07 200.4,39.55 203.65,39.55 205.61,41.51 205.61,43.89 206.47,44.75 206.47,47.24 210.13,50.89 210.13,56.57 210.78,57.23 210.78,58.32 213.36,60.9 213.36,61.7 213.62,61.97 213.96,61.97 214.02,61.9 214.75,61.9 215.23,62.38 215.23,64.79 211.78,68.24 211.78,75.81 209.3,78.3 v2(209.3,82.84) 210.31,83.86 210.31,84.6 213.21,87.5 215.51,87.5 216.14,88.13 216.91,88.13 217.88,89.09 221.65,89.09 223.2,90.65 223.2,91.74 225.8,94.33 229.69,94.33 230.25,94.89 233.76,94.89 235.59,93.06 238.51,93.06 240.72,95.27 240.72,99.48 241.78,100.55 245.33,100.55 v2(246.53,101.75)
  IN3 w0.102: v2(209.3,82.84) 209.29,82.84 209.29,83.86 208.93,84.22 207.92,84.22 205.35,81.65 192.1,81.65 192.07,81.68 192.02,81.68 190.93,82.77 v2(190.02,82.77)
  BOTTOM w0.102: R7435.2 102.08,115.3 102.08,112.95 R7449.2 102.31,112.36 102.41,112.26 102.79,112.26 103.18,111.87 103.18,110.46 103.08,110.36 101.11,110.36 100.57,110.9 98.95,110.9 98.74,110.69 v2(98.65,110.69)
HPD_IFPC_DP2_PCH: length 11.8
  TOP w0.102: R2377.2 176.64,34.29 176.69,34.29 176.94,34.54 176.94,34.83 177.13,35.02 177.13,35.57 177.08,35.62 177.08,36.35 R2372.2 177.22,37.05 177.22,37.59 177.49,37.86 177.49,40.25 177.63,40.4 177.63,43.21 177.37,43.47 v1(177.37,43.68) 177.75,43.68 v2(178,43.44)
  BOTTOM w0.102: U2000.AU41 177.98,43.2 177.98,43.38 178,43.39 v2(178,43.44)
HPOUT1_JD#: length 22.9
  TOP w0.102: v2(8.63,69.99) 7.57,71.05 7.57,71.94 v1(7.31,72.2) 5.94,73.57 Q6701.1
  TOP w0.203: R3623.2 21.01,75.2 v2(20.75,75.45)
  IN4 w0.203: v2(8.63,69.99) 9.24,69.99 11.04,71.8 11.58,71.8 12.57,72.79 14.28,72.79 15.49,74.01 15.49,74.67 16.41,75.58 18.34,75.58 18.97,74.94 20.5,74.94 20.75,75.2 v2(20.75,75.45)
  BOTTOM w0.203: v2(8.63,69.99) 8.88,69.75 CON6700.17
HPOUT1_JD_EC: length 173.8
  TOP w0.102: R3005.2 129.26,45.48 v1(128.75,45.99) 128.2,45.99 126.27,44.06 v2(125.76,44.06) 125.76,42.96 125.96,42.75 U3001.126 ; Q6701.3 2.95,80.23 3.48,80.76 v2(4.22,80.76)
  IN1 w0.102: v2(115.19,44.02) 114.32,44.9 104.7,44.9 103.46,43.66 90.82,43.66 89.17,42.02 49.19,42.02 48.11,40.94 41.98,40.94 41.33,41.6 35.71,41.6 35,42.31 27.64,42.31 v2(27.58,42.25)
  IN2 w0.102: v2(125.76,44.06) 125.4,44.42 123.27,44.42 123.06,44.63 118.44,44.63 118.29,44.78 115.96,44.78 115.19,44.01 v2(115.19,44.02) ; v2(27.58,42.25) 28.58,43.24 28.58,46.89 26.59,48.88 26.59,53.74 23.03,57.31 23.03,59.31 21.42,60.91 12.65,60.91 12.05,61.51 8.06,61.51 7.75,61.21 6.36,61.21 4.03,63.54 4.03,80.57 v2(4.22,80.76)
HPOUT1_L: length 7.4
  TOP w0.203: v2(11.99,69.74) 12.42,69.31 C6704.1 12.67,69.31 13.07,68.91 v1(13.56,68.91) U3600.32
  BOTTOM w0.203: CON6700.18 11.22,70.25 11.74,69.74 v2(11.99,69.74)
HPOUT1_R: length 9.9
  TOP w0.203: v2(11.99,70.37) 11.86,70.5 C6705.1 11.28,69.6 v1(11.41,69.47) 11.52,69.47 12.4,68.6 12.85,68.6 13.06,68.39 13.85,68.39 13.96,68.51 U3600.33
  BOTTOM w0.203: CON6700.19 11.61,70.75 v2(11.99,70.37)
I2C_IRQ2Z: length 13.7
  TOP w0.076: U1201.B6 239.73,50.94 239.4,50.94
  TOP w0.102: v2(229.67,52.54) 230,52.88 R3077.2 ; 239.4,50.94 239.29,50.94 238.94,51.3 236.78,51.3 v1(236.53,51.55) 236.27,51.81 234.14,51.81 233.78,51.46 233.78,50.92 R1230.1 v2(233.3,51.02)
  IN2 w0.102: v2(233.3,51.02) 231.78,52.54 v2(229.67,52.54)
I2C_SCL2: length 27.3
  TOP w0.076: 239.12,50.51 239.24,50.51 239.31,50.44 239.73,50.44 U1201.B5
  TOP w0.102: 239.12,50.51 238.73,50.89 237.8,50.89 237.54,50.64 236.02,50.64 235.81,50.44 R1231.1 v2(235.08,51.13) ; Q1202.3 220.07,60.75 221.79,59.02 223.06,59.02 v1(223.19,58.89) 226.49,58.89 v2(227.64,60.04)
  IN2 w0.102: v2(235.08,51.13) 234.45,51.76 234.45,52.94 227.64,59.76 v2(227.64,60.04)
I2C_SDA2: length 23.1
  TOP w0.089: U1201.A5 239.24,50.7
  TOP w0.102: v2(226.87,60.04) 226.11,60.04 v1(225.48,60.67) 225.45,60.65 Q1201.3 ; 239.24,50.7 238.84,51.1 235.92,51.1 235.41,51.61 234.75,51.61 234.62,51.48 234.62,50.87 R1232.1 v2(234.19,51.13)
  IN2 w0.102: v2(226.87,60.04) 228.14,58.77 228.34,58.77 229.71,57.39 233.99,53.12 233.99,51.33 v2(234.19,51.13)
IFPABCDEF_IOVDD: length 11.9
  TOP w0.254: v6(97.26,130.19) 97.21,130.19 96.95,130.44 96.95,130.52 C7220.1 92.94,130.82 C7221.1 C7227.1 91.62,129.98 91.41,129.77 C7219.1 L7204.2 88.66,129.77 v1(88.01,130.43)
  BOTTOM w0.254: U7000.BA11 96.92,129.9 97.21,130.19
  BOTTOM w0.305: U7000.BA12 96.7,130.69 97.21,130.19 v6(97.26,130.19)
IFPABCDEF_PLLVDD: length 8.5
  TOP w0.254: C7224.1 96.57,129.98 v6(96.25,130.29)
  TOP w0.381: C7224.1 96.94,129.32 C7225.1 C7226.1 C7222.1 94.38,128.51 v1(94.09,128.23) 94.06,128.2 C7223.1 91.43,128.2 L7203.2
  BOTTOM w0.254: v6(96.25,130.29) 96.25,130.35 U7000.BB12
IFPC_RSET: length 4.1
  TOP w0.102: R7212.2 94.97,133.62 v6(94.69,133.9) 94.86,134.07 v1(94.86,134.49)
  BOTTOM w0.102: U7000.BB14 95.47,132.73 94.79,132.73 94.69,132.83 v6(94.69,133.9)
ILIM_SEL: length 5.8
  TOP w0.102: U5200.4 248.26,58.13 248.21,58.18 R5206.1 247.75,58.34 247.47,58.62 v1(245.49,58.62) 245.49,57.76 R5207.2
IMON_A: length 4.6
  BOTTOM w0.102: R8092.2 C8035.2 14.96,172.94 14.91,172.89 v1(14.21,172.89) 14.04,173.07 13.18,173.07 12.27,173.99 U8000.14
IMON_B: length 7.4
  BOTTOM w0.102: C8014.2 R8029.2 14.49,184.33 v1(14.49,183.45) 14.29,183.25 14.29,181.38 14.05,181.14 14.05,180.73 14.45,180.33 14.45,179.59 13.85,178.98 U8000.2
IMON_C: length 3.3
  BOTTOM w0.203: U8000.28 7.07,176.18 6.86,176.39 v1(6.41,176.39) 5.58,175.56 R8038.1 C8004.1
IN+1: length 7.7
  TOP w0.203: U8702.12 121.93,69.38 122.45,68.85 122.45,68.42 122.67,68.2 C8745.2 125.26,68.2 125.83,68.78 v1(125.83,69.61) 125.83,70.6 R8731.2
IN+2: length 4.7
  TOP w0.203: U8702.15 123.52,72.22 123.89,72.59 124.16,72.59 C8748.1 124.23,73.23 124.07,73.23 123.77,73.54 v1(123.77,74.15) 124.37,74.15 R8734.2
IN-1: length 11.3
  TOP w0.203: R8732.2 126.42,71.21 126.42,70.35 126.34,70.27 126.34,68.85 125.37,67.88 124.82,67.88 v1(124.39,67.45) 123.8,66.86 C8745.1 122.69,66.86 122.4,67.15 122.4,68.04 122.15,68.29 122.15,68.65 121.28,69.52 U8702.11
IN-2: length 14.4
  TOP w0.203: U8702.14 124.47,71.57 C8748.2 125.22,72.32 125.22,73.39 125.11,73.5 125.11,74.3 R8735.2 124.68,75.32 125.87,76.51 125.87,77.04 125.6,77.3 125.16,77.3 v1(124.77,76.92) 124.77,76.47 122.99,74.69 122.35,74.69 121.93,74.27 U8702.1
INT_SERIRQ: length 137
  TOP w0.114: v2(117.6,35.6) 117.6,37.02 117.27,37.36 117.27,39.64 121.11,43.48 122.61,43.48 123.52,44.39 U3001.5 123.52,46.02 124.78,47.28 125.1,47.28 125.27,47.46 R3013.2 ; v2(189.66,25.82) 187.37,23.53 U6200.27 ; R2224.1 188.93,57.65 190.07,57.65 190.38,57.96 192.22,57.96 192.51,57.68 v1(192.51,57.09) 192.51,56.44 192.08,56.01 v2(192.08,55.98)
  IN1 w0.076: v2(189.66,25.82) 190.64,26.8 190.64,29.6 191.53,30.49 191.53,41.3 193.23,43 193.23,46.59 192.8,47.02 192.8,51.68 192.42,52.06 192.42,52.85 193.18,53.62 193.18,54.88 v2(192.08,55.98)
  IN4 w0.076: v2(117.6,35.6) 117.92,35.29 123.89,35.29 128.68,30.49 134.55,30.49 135.27,29.78 154.68,29.78 157.04,27.41 166.24,27.41 166.49,27.16 176.64,27.16 177.22,27.74 184.9,27.74 186.37,26.27 189.21,26.27 v2(189.66,25.82)
ISEN1_A: length 8.6
  BOTTOM w0.102: v1(8.86,168.06) 9.24,168.44 R80125.1 9.32,168.9 9.32,169.81 9.27,169.86 R8006.2 8.51,170.17 8.51,171.59 C8017.2 8.38,172.58 8.38,172.81 9.47,173.89 U8000.21
ISEN1_B: length 11.3
  BOTTOM w0.152: C8029.1 R80103.2 20.79,173.37 v1(20.25,173.37) 18.9,173.37 R80140.1 18.85,174.18 18.85,175.02 18.47,175.4 14.57,175.4 13.8,176.18 U8000.9
ISEN2_A: length 8
  BOTTOM w0.102: R80130.1 7.29,169.86 R8007.2 8.31,170.25 8.31,171.64 7.93,172.02 C8019.2 6.96,172.48 v1(6.96,173.04) 7.29,173.37 8.56,173.37 9.07,173.87 U8000.22
ISEN2_B: length 18.7
  IN4 w0.152: v2(23.29,177.92) 23.29,177.28 20.65,174.64 v2(17.58,174.64)
  BOTTOM w0.152: R8091.2 24.59,176.01 23.95,176.01 23.84,176.13 23.85,176.14 23.85,176.9 R80145.1 23.85,177.72 v1(23.85,178.3) 23.4,178.3 23.29,178.2 v2(23.29,177.92) ; U8000.10 13.84,175.78 14.47,175.15 17.91,175.15 C8030.1 v2(17.58,174.64)
ISEN3_A: length 11
  BOTTOM w0.102: v1(6.78,167.43) 6.64,167.57 6.64,168.71 6.22,169.13 R80135.1 R8034.2 6.66,169.61 6.66,170.45 6.47,170.63 6.22,170.63 6.02,170.83 6.02,171.52 C8011.2 6.12,172.43 6.12,173.02 6.73,173.62 8.43,173.62 8.66,173.86 U8000.23
ISH_I2C0_SCL: length 11.3
  BOTTOM w0.089: U2000.BC38 180.83,44.31 181.55,44.31 181.69,44.18 182.76,44.18 183.37,43.56 184.71,43.56
  BOTTOM w0.102: 184.71,43.56 186.01,43.56 187.6,41.97 v1(188.25,41.97) 189.89,41.97 R2417.2
ISH_I2C0_SDA: length 12.5
  TOP w0.102: v2(179.72,44.15) 180.07,43.8 180.12,43.76 180.57,43.76 182.34,41.98 186.72,41.98 v1(186.94,42.21) 187.17,41.98 189.41,41.98 R2416.2
  BOTTOM w0.089: U2000.BB38 179.72,44.51 v2(179.72,44.15)
ISH_I2C1_SCL: length 13.9
  BOTTOM w0.089: U2000.BD38 181.24,44.5 181.61,44.5 181.76,44.36 182.83,44.36 183.42,43.77 184.71,43.77
  BOTTOM w0.102: R2415.2 192.76,42.59 192.76,42.64 v1(192.37,43.03) 190.24,43.03 189.61,42.41 189.22,42.41 188.86,42.77 187.09,42.77 186.09,43.77 184.71,43.77
ISH_I2C1_SDA: length 10.7
  BOTTOM w0.089: 184.71,43.36 183.32,43.36 182.68,44 181.61,44 181.55,44.06 U2000.BE39
  BOTTOM w0.102: R2414.2 189.69,40.89 v1(189.62,40.89) 188.39,40.89 185.92,43.36 184.71,43.36
ISUMN_A: length 4.8
  BOTTOM w0.102: R8008.2 C8018.1 R8098.1 9.83,172.33 v1(9.22,172.94) 9.22,173.27 9.87,173.91 U8000.20
ISUMN_A_R: length 70.8
  TOP w0.102: R8082.1 48.13,170.76 48.26,170.89 48.26,171.8 v2(48,172.05)
  IN1 w0.102: v2(7.87,170.45) v2(8.94,170.45) ; v2(3.23,172.86) 3.64,173.27 5.25,173.27 5.56,173.58 5.96,173.58 6.84,172.71 13.81,172.71 14.48,173.38 34.83,173.38 35.17,173.73 42.05,173.73 44.56,171.21 47.47,171.21 48,171.74 v2(48,172.05)
  IN3 w0.102: v2(3.23,172.86) 5.64,170.45 v2(7.87,170.45)
  BOTTOM w0.102: C8020.2 1.58,170.27 R8061.1 R8059.1 ; C8020.2 2.21,171.29 2.21,172.1 1.83,172.48 1.83,172.59 v1(1.42,172.99) 2.95,172.99 3.08,172.86 v2(3.23,172.86) ; C8020.2 R8097.1 C8026.1 R8083.1 ; R8057.1 R80102.2 9.78,170.53 9.83,170.58 R8098.2 9.63,171.16 C8017.1 v2(8.94,170.45) ; C8011.1 C8019.1 7.42,170.68 7.65,170.45 v2(7.87,170.45)
ISUMN_B: length 17.5
  BOTTOM w0.152: C8034.1 25.04,175.76 23.56,175.76 23.41,175.62 23.41,174.08 23.21,173.88 22.68,173.88 22.51,174.05 22.51,175.01 22.37,175.15 19.18,175.15 18.67,175.66 15.72,175.66 v1(15.52,175.86) 15.1,176.27 14.19,176.27 13.89,176.58 U8000.8 ; C8034.1 25.27,175.08 25.2,175.01 R8045.2 ; C8034.1 25.59,175.84 25.59,176.12 R8076.1
ISUMN_B_R: length 41.2
  TOP w0.102: R8088.2 2.33,154.37 v2(1.64,155.06)
  IN4 w0.102: v2(11.73,166.26) 12.17,166.7 12.17,168.33 17.33,173.5 19.53,173.5 19.9,173.86 v2(19.9,174.13)
  BOTTOM w0.102: v2(11.73,166.26) 11.74,166.25 11.74,166 5.89,160.16 5.89,159.1 5.39,158.59 v1(5.13,158.59) 5.13,158.29 1.91,155.06 v2(1.64,155.06)
  BOTTOM w0.152: R8066.1 26.01,173.37 26.09,173.45 R8043.1 R8045.1 24.77,173.83 24.56,173.62 24.56,172.99 24.44,172.86 23.05,172.86 22.96,172.95 R8040.2 22.54,173.37 C8029.2 22.02,173.89 R8044.2 C8027.2 C8028.1 19.74,174.72 19.66,174.64 C8030.2 19.28,174.28 19.3,174.26 R8064.1 19.56,173.8 v2(19.9,174.13)
ISUMN_C: length 5.6
  BOTTOM w0.102: U8000.33 6.27,178.18 v1(6.15,178.3) 5.6,178.84 5.23,178.84 4.95,178.56 C80106.1 4.65,179.02 4.75,179.12 R8035.1 5.19,179.75 5.36,179.92 R8032.2
ISUMN_C_R: length 89.8
  TOP w0.102: v2(4.75,181.5) 4.75,182.21 R80124.1 4.93,182.39 R8069.1
  IN1 w0.102: v2(73.87,173.57) 73.87,173.69 73.52,174.04 73.52,177.56 75.08,179.12 75.08,179.77 74.23,180.61 63.05,180.61 60.29,177.86 36.17,177.86 35.38,178.65 20.42,178.65 19.03,180.05 15.78,180.05 13.92,181.9 5.16,181.9 v2(4.75,181.5)
  BOTTOM w0.102: R8026.1 74.43,173.18 74.04,173.57 v2(73.87,173.57) ; R8036.2 3.83,180.61 R8035.2 v2(4.75,181.5) 4.19,182.06 3.86,182.06 C80105.1 3.4,182.51 C80104.2 2.51,182.13 2.59,182.06 R8025.1 1.85,181.68 v1(1.61,181.44)
ISUMP_A: length 21.6
  TOP w0.102: v2(9.96,173.12) 9.57,173.5 v1(9.08,173.5)
  IN1 w0.102: v2(9.96,173.12) 6.78,173.12 6.08,173.82 5.4,173.82 5.08,173.5 v2(3.23,173.5)
  BOTTOM w0.102: v2(9.96,173.12) 9.96,172.73 10.21,172.48 11.79,172.48 R8056.1 ; R8058.1 R8060.1 5.33,169.56 5.13,169.76 5.13,170.32 5.51,170.7 R80101.2 4.78,171.67 R8083.2 ; R8083.2 4.62,172.3 C80133.2 C80109.2 4.25,173.66 3.39,173.66 v2(3.23,173.5) ; R8083.2 C8026.2
  BOTTOM w0.152: U8000.19 10.27,173.68 9.96,173.37 v2(9.96,173.12)
ISUMP_B: length 21.2
  IN3 w0.152: v2(15.36,176.84) 16.63,175.57 17.26,175.57 18.01,174.82 18.01,174.36 v2(17.65,174)
  BOTTOM w0.152: v1(18.03,171.14) 17.65,171.52 R8062.1 v2(17.65,174) ; U8000.7 13.86,176.98 14.28,176.57 15.09,176.57 v2(15.36,176.84) 16.17,176.04 20.68,176.04 C8027.1 R8044.1 22.24,175.8 22.24,176.08 R8094.1 23.42,176.49 R8063.1 22.96,175.99 C8036.1 C80110.1
ISUMP_C: length 17.1
  TOP w0.102: R8067.1 2.65,184.16 v1(2.2,183.72) 2.64,183.28 C80103.2 C80111.2 3.18,181.93 3.61,181.5 v2(4.12,181.5) 4.19,181.42 4.19,181.32 4.65,180.86 5.46,180.86 R8024.2
  BOTTOM w0.102: v2(4.12,181.5) 4.04,181.57 C80105.2 3.35,181.57 R8025.2 2.19,180.41 2.19,179.03 3.37,177.85 7.02,177.85 7.09,177.78 U8000.32
ITP_PMODE: length 239
  IN1 w0.102: v2(177.58,64.1) 173.83,64.1 173.45,64.48 171.43,64.48 170.7,65.21 168.94,65.21 168.34,64.61 158.99,64.61 158.07,63.69 155.83,63.69 155.09,62.96 154.07,62.96 150.61,59.5 146.32,59.5 145.71,58.89 144.35,58.89 141.79,56.33 140.34,56.33 139.64,55.64 135.77,55.64 135.31,55.18 123.96,55.18 123.56,54.78 112.24,54.78 111.71,54.26 102.24,54.26 99.77,51.78 91.71,51.78 91.28,51.35 64.55,51.35 64.19,50.98 61.93,50.98 61.56,51.35 51.14,51.35 50.13,52.36 48.31,52.36 46.93,50.98 43.84,50.98 39.88,54.95 39.88,56.81 38.41,58.28 38.41,62.51 37.63,63.29 33.65,63.29 32.22,64.73 31.41,64.73 26.25,69.88 26.25,70.36 24.67,71.94 24.67,77.58 20.37,81.88 12.03,81.88 11.65,82.26 10.96,82.26 9.59,83.63 6.91,83.63 4.24,86.31 4.24,90.72 5.93,92.42 5.93,108.1 v2(4.65,109.38)
  BOTTOM w0.089: U2000.AT2 177.34,62.52 177.22,62.64 177.22,63.28 177.18,63.32 177.18,63.7 v2(177.58,64.1)
  BOTTOM w0.102: R4413.2 4.72,117.57 v1(4.35,117.2) 4.35,109.74 4.65,109.44 v2(4.65,109.38)
JD_PCH: length 204.2
  TOP w0.102: v2(22.44,66.67) 22.02,66.24 21.58,66.24 21.5,66.32 U3600.48 ; v2(194.77,49.37) 194.56,49.16 R2499.2
  IN2 w0.102: v2(194.77,49.37) 194.43,49.37 193.82,48.76 186.7,48.76 185.6,49.86 185.6,50.46 184.57,51.49 184.23,51.49 183.76,51.01 183.76,49.94 181.81,48 173.62,48 172.73,48.88 169.71,48.88 168.37,47.54 161.8,47.54 160.37,46.1 155.23,46.1 154.46,45.34 154.46,42.65 155.14,41.97 155.14,41.3 154.91,41.06 153.72,41.06 152.2,42.59 149.96,42.59 149.25,41.88 149.25,40.93 147.55,39.23 135.66,39.23 134.84,40.05 124.23,40.05 124.03,40.25 119.33,40.25 118.77,39.69 113.4,39.69 112.81,40.28 106.97,40.28 106.79,40.1 93.81,40.1 93.55,40.36 93.55,40.96 92.94,41.57 69.26,41.57 68.38,42.44 45.02,42.44 39.01,48.46 36.58,48.46 33.82,51.22 33.82,52.49 27.18,59.13 27.18,61 23.19,64.99 23.19,66.18 22.71,66.67 v2(22.44,66.67)
  BOTTOM w0.203: v1(21.46,66.74) 22.36,66.74 v2(22.44,66.67)
JTAG_TCLK: length 3.8
  TOP w0.102: v6(88.7,135.78) 88.95,135.78 89.46,136.29 T7406.1
  BOTTOM w0.103: U7000.BJ20 89.89,137.1 88.7,135.9 v6(88.7,135.78)
JTAG_TDI: length 7.5
  TOP w0.102: v6(89.33,135.14) 88.93,134.74 88.7,134.74 T7408.1
  BOTTOM w0.103: v6(89.33,135.14) 90.09,135.9 91.27,135.9 91.9,136.54 U7000.BG20
JTAG_TDO: length 6.7
  TOP w0.102: T7409.1 91.62,135.65 89.21,135.65 v6(88.7,135.14)
  BOTTOM w0.103: U7000.BH20 90.79,137.1 90.39,136.7 90.26,136.7 v6(88.7,135.14)
JTAG_TMS: length 2.3
  TOP w0.089: 92.43,136.54 v6(92.3,136.67)
  TOP w0.102: T7407.1 93.07,135.9 92.43,136.54
  BOTTOM w0.102: v6(92.3,136.67) 92.3,136.7 U7000.BF20
JTAG_TRST#: length 9
  TOP w0.102: T7410.1 87.32,134.84 v2(87.76,134.84)
  BOTTOM w0.102: R7425.2 86.69,134.84 v2(87.76,134.84) 88.32,135.4 88.32,135.94 89.94,137.56 92.36,137.56 U7000.BF21
KBL_A_0: length 8.1
  TOP w0.102: U3102.2 143.58,29.79 143.69,29.89 R3141.2 144.63,31.34 R3142.1 145.67,31.69 146.86,32.89 146.86,33.85 v1(147.47,34.46)
KBL_A_1: length 25.4
  TOP w0.102: R3144.1 144.68,28.57 144.68,27.83 144.48,27.63 144.48,26.64 144.03,26.19 v2(143.26,26.19) 142.93,26.52 U3102.3 142.93,29.66 142.8,29.79 R3143.2
  BOTTOM w0.102: v1(129.69,21.81) 130.53,22.65 141.17,22.65 143.26,24.73 v2(143.26,26.19)
KBL_A_2: length 25.5
  TOP w0.102: R3145.2 142.28,30.03 U3102.4 142.28,26.53 v2(142.62,26.19) 143.06,25.75 144.04,25.75 144.75,26.45 144.75,27.51 145.01,27.77 145.01,28.19 145.49,28.67 R3146.1
  BOTTOM w0.102: v1(129.44,23.13) 129.67,22.9 141.14,22.9 142.62,24.39 v2(142.62,26.19)
KBL_A_3: length 11
  TOP w0.102: R3147.2 140.82,30.88 140.82,30.29 v1(140.97,30.14) 141.63,29.48 U3102.5 141.63,26.59 142.72,25.49 144.13,25.49 145.09,26.45 145.09,27.54 145.32,27.78 R3148.1
KBL_B_2: length 6.3
  TOP w0.102: U3102.13 136.43,26.85 136.68,26.6 v2(136.68,26.21) 136.55,26.07 v1(134.25,26.07)
  BOTTOM w0.102: CON3110.8 137.25,26.77 v2(136.68,26.21)
KBL_B_3: length 17.9
  TOP w0.102: v2(140.76,24.21) 140.33,23.78 U3102.22
  BOTTOM w0.102: v1(129.34,25.72) 131.06,25.72 133.32,27.98 135.52,27.98 135.75,27.75 CON3110.11 135.75,25.73 136.46,25.01 136.98,25.01 137.76,24.23 137.76,23.9 138.28,23.39 139.93,23.39 v2(140.76,24.21)
KBL_B_4: length 13.4
  TOP w0.102: U3102.17 137.08,24.2 v2(137.08,24.21) 137.08,24.63 136.96,24.76 135.43,24.76 133.99,23.31 v1(132.74,23.31)
  BOTTOM w0.102: v2(137.08,24.21) 136.47,23.6 135.27,23.6 134.25,24.62 CON3110.14
KBL_G_2: length 7.6
  TOP w0.102: U3102.12 137.08,26.85 137.33,26.6 v2(137.33,26.21) 136.55,25.42 135.39,25.42 v1(134.25,24.28)
  BOTTOM w0.102: CON3110.7 137.75,26.62 v2(137.33,26.21)
KBL_G_3: length 16.5
  TOP w0.102: v2(139.89,24.21) 139.68,24 U3102.21
  BOTTOM w0.102: v1(129.67,27.22) 131.88,27.22 132.87,28.21 135.86,28.21 136.25,27.83 CON3110.10 136.25,26.89 135.98,26.62 135.98,25.83 136.59,25.22 137.15,25.22 137.96,24.4 137.96,23.99 138.36,23.59 139.27,23.59 v2(139.89,24.21)
KBL_G_4: length 11.6
  TOP w0.102: v2(136.47,24.21) 136.43,24.16 U3102.16 136.43,21.8 136.15,21.52 132.75,21.52 v1(132.43,21.83)
  BOTTOM w0.102: CON3110.13 134.75,24.6 135.55,23.8 136.07,23.8 v2(136.47,24.21)
KBL_R_3: length 15.2
  TOP w0.102: v2(139.08,24.21) 139.03,24.16 U3102.20
  BOTTOM w0.102: v2(139.08,24.21) 137.87,25.42 136.69,25.42 136.19,25.91 136.19,26.33 136.75,26.89 CON3110.9 136.75,27.91 136.09,28.57 130.1,28.57 v1(129.67,29)
KBL_R_4: length 7.7
  TOP w0.102: U3102.15 v2(135.78,24.21) 135.47,24.21 134.26,23 v1(134.26,22.43)
  BOTTOM w0.102: CON3110.12 135.25,24.74 v2(135.78,24.21)
KBL_RESET#_R: length 14.9
  TOP w0.102: U3102.25 142.28,23.36 145.29,26.37 145.29,26.84 145.62,27.17 146.63,27.17 147.24,27.79 v1(147.24,32.61) 147.24,33.11 148.08,33.95 R3137.1
KSI0: length 22.9
  TOP w0.102: v2(103.56,25.21) 103.69,25.35 CN5.1 103.69,26.34 103.18,26.85 103.18,29.08 v1(104.78,30.68) 106.73,32.63 108.51,32.63 109.44,33.55 U3001.58
  BOTTOM w0.102: CON3100.8 109.05,28.4 107.61,26.97 105.31,26.97 v2(103.56,25.21)
KSI1: length 22.7
  TOP w0.102: v2(104.2,25.21) CN5.3 104.2,26.63 104.06,26.76 103.56,26.76 103.38,26.94 103.38,28.39 103.63,28.63 103.98,28.63 v1(104.27,28.92) 104.27,29.23 107.46,32.43 108.59,32.43 109.32,33.15 U3001.59
  BOTTOM w0.102: CON3100.7 110.05,29.01 107.68,26.63 105.62,26.63 v2(104.2,25.21)
KSI2: length 21.2
  TOP w0.102: U3001.60 109.24,32.75 108.56,32.07 107.98,32.07 v1(106.81,30.9) 105.51,29.6 105.51,26.94 105.33,26.76 104.83,26.76 104.69,26.63 CN5.5 104.69,25.34 v2(104.83,25.21)
  BOTTOM w0.102: CON3100.6 111.05,29.23 110.29,28.47 109.8,28.47 107.76,26.43 106.05,26.43 v2(104.83,25.21)
KSI3: length 20.9
  TOP w0.102: v2(105.46,25.21) 105.2,25.48 CN5.7 105.2,26.34 105.87,27.01 105.87,29.25 v1(105.97,29.35) 106.39,29.78 106.77,29.78 109.35,32.35 U3001.61
  BOTTOM w0.102: CON3100.5 112.05,28.57 111.56,28.08 109.7,28.08 107.85,26.23 106.48,26.23 v2(105.46,25.21)
KSI4: length 20.1
  TOP w0.102: U3001.62 109.76,31.95 v1(108.62,30.81) 106.22,28.41 106.22,26.26 106.35,26.14 CN6.1 106.87,25.66 v2(106.48,25.26)
  BOTTOM w0.102: CON3100.4 113.05,28.72 112.15,27.83 109.75,27.83 107.93,26 107.22,26 v2(106.48,25.26)
KSI5: length 19.4
  TOP w0.102: U3001.63 110.1,31.55 v1(107.72,29.18) 107.29,28.75 106.91,28.75 106.72,28.56 106.72,28.56 106.56,28.4 106.56,26.94 106.73,26.76 107.07,26.76 107.37,26.46 CN6.3 v2(107.37,25.26)
  BOTTOM w0.102: CON3100.3 114.05,28.9 112.75,27.6 109.91,27.6 108.01,25.7 107.8,25.7 v2(107.37,25.26)
KSI6: length 18.1
  TOP w0.102: v2(108,25.26) 107.87,25.39 CN6.5 107.87,26.63 108,26.76 108.51,26.76 108.76,27.02 108.76,28.11 v1(109.45,28.8) 109.45,30.4 110.21,31.15 U3001.64
  BOTTOM w0.102: CON3100.2 115.05,29.33 113.09,27.37 110.11,27.37 v2(108,25.26)
KSI7: length 17.7
  TOP w0.102: U3001.65 112.72,28.82 112.45,28.54 111.15,28.54 v1(109.5,26.89) 109.18,26.57 108.6,26.57 108.37,26.34 CN6.7 108.37,25.53 v2(108.64,25.26)
  BOTTOM w0.102: v2(108.64,25.26) 110.49,27.12 113.41,27.12 115.01,28.72 115.55,28.72 116.05,29.22 CON3100.1
KSO0: length 47.1
  TOP w0.102: v2(91.95,24.3) 90.83,24.3 v1(90.75,24.38) 90.03,24.38 88.89,25.52 CN1.1 88.89,26.34 88.69,26.54 88.68,26.54 88.21,27.01 88.21,30.29 89.45,31.53 97.66,31.53 101.64,35.51 101.64,39.22 104.77,42.35 U3001.36
  BOTTOM w0.102: v2(91.95,24.3) 90.53,24.3 89.94,24.89 89.94,27.48 91.05,28.59 CON3100.26
KSO1: length 44.7
  TOP w0.102: U3001.37 104.8,41.95 101.88,39.03 101.88,35.46 97.75,31.33 89.86,31.33 v1(88.87,30.35) 88.41,29.88 88.41,27.09 88.77,26.74 89.21,26.74 89.39,26.56 CN1.3 89.39,25.4 89.96,24.83 v2(91.34,24.83)
  BOTTOM w0.102: v2(91.34,24.83) 90.28,24.83 90.14,24.97 90.14,27.13 92.05,29.03 CON3100.25
KSO2: length 39.5
  TOP w0.102: U3001.38 104.76,41.55 102.13,38.93 102.13,35.43 97.83,31.12 91.53,31.12 90.7,30.29 v1(90.7,29.15) 90.7,26.94 90.6,26.84 90.31,26.84 89.89,26.42 CN1.5 89.89,25.5 90.11,25.28 v2(90.6,25.28)
  BOTTOM w0.102: CON3100.24 93.05,29.2 92.48,28.63 92.48,27.76 90.6,25.89 v2(90.6,25.28)
KSO3: length 38.2
  TOP w0.102: v2(91.21,25.59) 91.21,25.8 90.87,26.14 CN1.7 90.39,26.31 90.93,26.85 90.93,28.53 91.32,28.92 91.32,30.3 v1(91.71,30.69) 91.94,30.92 98.08,30.92 102.41,35.25 102.41,38.8 104.76,41.15 U3001.39
  BOTTOM w0.102: v2(91.21,25.59) 93.62,28 93.62,29 94.05,29.43 CON3100.23
KSO4: length 37.8
  TOP w0.102: v2(91.9,25.26) 91.68,25.48 CN2.1 91.68,26.34 91.17,26.85 91.17,28.48 91.61,28.93 92.31,28.93 v1(92.53,29.15) 92.53,30.22 93.03,30.72 98.17,30.72 102.69,35.24 102.69,38.68 104.77,40.75 U3001.40
  BOTTOM w0.102: CON3100.22 95.05,29.38 93.95,28.28 93.95,27.31 v2(91.9,25.26)
KSO5: length 37.7
  TOP w0.102: U3001.41 104.78,40.35 103,38.57 103,35.26 98.25,30.52 94.18,30.52 v1(93.95,30.29) 93.95,29.96 92.63,28.64 91.61,28.64 91.37,28.4 91.37,26.94 91.49,26.81 92,26.81 92.18,26.63 CN2.3 92.18,25.61 v2(92.53,25.26)
  BOTTOM w0.102: CON3100.21 96.05,29.58 95.45,28.98 95.1,28.98 94.41,28.29 94.41,27.14 v2(92.53,25.26)
KSO6: length 35.2
  TOP w0.102: U3001.42 105.22,39.95 103.49,38.22 v1(103.49,38.19) 103.49,35.47 98.34,30.31 95.59,30.31 93.49,28.21 93.49,26.94 93.37,26.81 92.89,26.81 92.68,26.6 CN2.5 92.68,25.75 v2(93.17,25.26)
  BOTTOM w0.102: v2(93.17,25.26) 95.56,27.65 95.56,28.41 95.96,28.82 96.75,28.82 97.05,29.11 CON3100.20
KSO7: length 33.7
  TOP w0.102: U3001.43 107.4,39.55 v1(106.32,38.47) 104.95,38.47 103.84,37.36 103.84,35.52 98.42,30.11 95.68,30.11 93.7,28.13 93.7,26.85 93.19,26.34 93.18,26.34 CN2.7 93.18,25.88 v2(93.8,25.26)
  BOTTOM w0.102: CON3100.19 98.05,29.29 94.48,25.72 94.26,25.72 v2(93.8,25.26)
KSO8: length 32.5
  TOP w0.102: U3001.44 107.75,39.15 106.59,37.99 105.77,37.99 v1(104.9,37.13) 104.14,36.37 104.14,35.54 98.51,29.91 95.76,29.91 94.34,28.48 94.34,26.85 94.86,26.34 CN3.1 94.86,25.63 v2(94.54,25.31)
  BOTTOM w0.102: CON3100.18 99.05,29.54 98.36,28.85 98,28.85 94.54,25.39 v2(94.54,25.31)
KSO9: length 32.5
  TOP w0.102: v2(95.17,25.31) 95.36,25.5 CN3.3 95.36,26.63 95.17,26.81 94.67,26.81 94.54,26.94 94.54,28.4 94.8,28.66 95.15,28.66 v1(95.32,28.83) 96.2,29.7 98.59,29.7 107.64,38.75 U3001.45
  BOTTOM w0.102: v2(95.17,25.31) 97.03,27.17 97.99,27.17 98.78,27.96 98.78,28.38 100.05,29.65 CON3100.17
KSO10: length 30.9
  TOP w0.102: v2(95.94,25.31) 95.86,25.39 CN3.5 95.86,26.6 96.06,26.81 96.54,26.81 96.67,26.94 96.67,29.12 97.05,29.5 99,29.5 v1(99.43,29.93) 103.63,34.13 103.63,34.46 107.53,38.35 U3001.46
  BOTTOM w0.102: CON3100.16 101.05,29.41 98.37,26.74 97.36,26.74 v2(95.94,25.31)
KSO11: length 29.3
  TOP w0.102: v2(96.57,25.31) 96.36,25.53 CN3.7 96.36,26.34 96.87,26.85 96.87,28.59 v1(97.13,28.85) 97.58,29.3 99.62,29.3 105.07,34.74 108.54,34.74 109.72,35.92 110.15,36.35 U3001.51
  BOTTOM w0.102: CON3100.15 102.05,29.5 101.42,28.87 100.96,28.87 98.48,26.38 97.64,26.38 v2(96.57,25.31)
KSO12: length 29
  TOP w0.102: U3001.52 110.04,35.95 108.62,34.54 106.58,34.54 106.35,34.31 v1(105.66,34.31) 104.92,34.31 99.71,29.09 98.1,29.09 97.47,28.46 97.47,26.85 97.98,26.34 CN4.1 97.98,25.66 97.71,25.39 v2(97.71,25.26)
  BOTTOM w0.102: CON3100.14 103.05,28.54 101.88,27.37 99.83,27.37 v2(97.71,25.26)
KSO13: length 28.9
  TOP w0.102: U3001.53 109.93,35.55 108.25,33.88 v1(107.52,33.88) 104.78,33.88 99.67,28.77 98.06,28.77 97.67,28.38 97.67,26.94 97.84,26.76 98.32,26.76 98.48,26.6 CN4.3 v2(98.48,25.26)
  BOTTOM w0.102: v2(98.48,25.26) 100,26.79 101.93,26.79 104.05,28.91 CON3100.13
KSO14: length 27.4
  TOP w0.102: v2(99.11,25.26) 98.98,25.39 CN4.5 98.98,26.63 99.14,26.79 99.64,26.79 99.79,26.94 99.79,28.6 102.48,31.29 103,31.29 v1(103.96,32.25) 105.15,33.44 108.17,33.44 109.88,35.15 U3001.54
  BOTTOM w0.102: v2(99.11,25.26) 100.28,26.43 103.02,26.43 104.52,27.93 104.52,28.87 105.05,29.4 CON3100.12
KSO15: length 27.1
  TOP w0.102: U3001.55 109.77,34.75 108.26,33.24 105.68,33.24 103.27,30.83 v1(102.92,30.83) 101.3,29.2 100.68,29.2 99.99,28.52 99.99,26.3 99.83,26.14 CN4.7 99.48,25.53 v2(99.75,25.26)
  BOTTOM w0.102: v2(99.75,25.26) 100.71,26.23 103.6,26.23 106.05,28.68 CON3100.11
KSO16: length 26.1
  TOP w0.102: v2(100.64,25.28) 100.77,25.41 CN7.1 100.77,26.34 100.77,26.34 100.22,26.89 100.22,28.46 100.76,29 101.73,29 v1(101.98,29.25) 105.76,33.03 108.34,33.03 109.66,34.35 U3001.56
  BOTTOM w0.102: v2(100.64,25.28) 101.38,26.02 103.76,26.02 107.05,29.32 CON3100.10
KSO17: length 26.3
  TOP w0.102: v2(101.27,25.28) CN7.3 101.27,26.68 101.11,26.84 100.56,26.84 100.43,26.97 100.43,28.36 100.81,28.75 102.08,28.75 v1(105.79,32.45) 106.17,32.83 108.43,32.83 109.55,33.95 U3001.57
  BOTTOM w0.102: CON3100.9 108.05,29.56 107.37,28.87 106.93,28.87 103.7,25.65 101.65,25.65 v2(101.27,25.28)
L1+: length 15.5
  BOTTOM w0.114: CON5500.3 261.5,45.43 261.39,45.32 261.17,45.32 260.25,44.4 258.4,44.4 257.88,43.88 257.88,40.17 257.61,39.89 256.24,39.89 256.08,40.05 256.08,40.38 ; v1(256.31,40.38) 256.08,40.38 ; 256.08,40.38 256.08,41.85 D5502.1 255.97,43.06 255.97,43.64 RN5501.4
L1-: length 15.7
  BOTTOM w0.114: CON5500.2 261.5,44.97 261.39,45.08 261.27,45.08 260.35,44.16 258.5,44.16 258.12,43.78 258.12,40.07 257.7,39.66 257.48,39.66 ; 257.48,39.66 256.14,39.66 255.85,39.95 255.85,41.87 D5501.1 255.73,42.81 255.73,43.68 RN5501.2 ; 257.48,39.66 v1(257.48,39.43)
L2+: length 9.6
  TOP w0.114: v7(257.18,72.46) 257.45,72.19 258.64,72.19 259.02,71.81 260.27,71.81 261.19,72.72 261.38,72.72 261.5,72.85 CON5501.3
  BOTTOM w0.114: L5504.2 254.54,73.13 254.84,72.83 255.24,72.83 255.39,72.68 255.8,72.68 255.88,72.76 D5504.1 255.9,73.17 256.62,72.46 256.66,72.41 256.89,72.41 256.9,72.41 257.15,72.41 v7(257.18,72.46)
L2-: length 9.6
  TOP w0.114: CON5501.2 261.5,72.39 261.4,72.49 261.29,72.49 260.37,71.57 258.92,71.57 258.54,71.95 257.37,71.95 v2(257.2,71.78)
  BOTTOM w0.114: v2(257.2,71.78) 256.8,72.18 256.19,72.18 D5503.1 255.88,72.37 255.8,72.45 255.29,72.45 255.14,72.6 254.81,72.6 254.53,72.32 RN5504.2
LAD0_ESPI_IO0: length 10.6
  TOP w0.114: R2219.2 184.23,53.86 183.19,52.83 179.32,52.83 179.02,52.54 177.47,52.54 v2(176.81,53.19) 176.43,52.81 v1(176.43,52.65)
  BOTTOM w0.102: U2000.AT22 176.81,53.08 v2(176.81,53.19)
LAD0_ESPI_IO1: length 12.2
  TOP w0.114: R2220.2 187.18,53.99 v1(186.94,54.22) 186.77,54.39 184.41,54.39 183.09,53.07 179.22,53.07 178.92,52.78 177.89,52.78 v2(177.47,53.2)
  BOTTOM w0.089: v2(177.47,53.2) 177.47,53.18 U2000.AV22
LAD0_ESPI_IO2: length 10.9
  TOP w0.114: R2221.2 184.49,55.13 182.9,53.54 179.03,53.54 178.94,53.62 177.44,53.62 v2(176.75,54.32) 176.49,54.58 v1(176.15,54.58)
  BOTTOM w0.089: v2(176.75,54.32) 176.75,54.25 U2000.AT19
LAD0_ESPI_IO3: length 5.1
  BOTTOM w0.089: 181.55,55.21 181.29,55.21 181.05,55.46 U2000.BD16
  BOTTOM w0.102: v1(184,56.15) 183.06,55.21 181.55,55.21
  BOTTOM w0.114: R2222.2 184.92,56.87 184.71,56.87 v1(184,56.15)
LAN_CLKREQ#: length 131.3
  TOP w0.114: R3304.2 237.16,88.49 236.42,87.74 v2(235.86,87.74) ; v2(178.46,47.41) 178.46,47.39 178.96,46.89 179.19,46.89 179.68,46.4 180.66,46.4 181.71,45.35 182.51,45.35 v1(182.89,44.97) 183.4,44.97 184,45.56 185.19,45.56 185.43,45.8 186.68,45.8 v2(187.25,46.37) 187.5,46.62 R2432.2
  IN1 w0.076: v2(204.64,43.98) 205.12,43.51 205.12,40.72 203.58,39.18 v2(203.58,35.43)
  IN2 w0.114: v2(235.86,87.74) 235.86,88.85 235.9,88.9 235.9,90.27 235.37,90.8 234.55,90.8 234.41,90.67 230.84,90.67 228.37,88.2 228.37,87.29 227.54,86.47 218.6,86.47 217.98,85.84 216.14,85.84 213.46,83.16 213.46,80.36 213.81,80.01 213.81,68.75 217.58,64.99 217.58,62.01 215.53,59.96 215.53,58.14 216.42,57.24 216.42,52.69 213.56,49.82 213.56,49.41 211.58,47.43 211.58,46.33 211.16,45.91 211.16,42.36 210.85,42.05 208.57,39.77 208.57,36.71 208.1,36.24 205.33,36.24 204.64,35.55 203.71,35.55 v2(203.58,35.43)
  IN4 w0.076: v2(187.25,46.37) 187.71,46.83 190.17,46.83 191.69,45.31 192.71,45.31 193.98,46.58 195.06,46.58 196.33,45.31 197.51,45.31 198.22,44.59 202.71,44.59 203.33,43.98 v2(204.64,43.98)
  BOTTOM w0.089: v2(178.46,47.41) 178.63,47.41 178.98,47.76 178.98,47.81 179.33,48.16 179.56,48.16 179.83,47.89 U2000.BB31
LAN_GND:
  vias: v1(258.09,146.35) v2(247.45,145.38) v2(247.57,146.91) v2(247.6,138.37) v2(247.73,142.96) v2(247.73,141.11) v2(247.68,139.97) v2(247.7,136.99) v2(247.76,148.5) v2(247.78,147.82) v2(248.87,136.26) v2(250.19,143.35) v2(250.19,142.71) v2(250.24,140.4) v2(250.24,139.77) v2(250.24,137.74) v2(250.24,137.1) v2(250.24,136.22) v2(250.32,146.43) v2(250.32,145.8) v2(251,136.24) v2(253.99,143.91) v2(254.18,135.02) v2(254.29,142.18) v2(255.17,133.93) v2(256.82,132.36) v2(257.86,131.31) v2(258.7,146.98) v2(258.7,145.92) v2(259.31,146.91) v2(259.28,146.25) v2(260.12,130.24) v2(260.46,146.2) v2(260.55,141.52) v2(260.46,138.58) v2(260.59,143.44) v2(260.59,136.11) v2(260.58,134.08) v2(260.57,132.26) v2(261.64,148.49) v2(262.48,129.8) v2(263.16,148) v2(263.5,129.81) v2(268.55,147.98) v2(269.87,148.92) v2(269.86,129.29)
LAN_MDI0_N: length 61.8
  TOP w0.102: v2(230.63,97.91) 230.86,97.68 230.86,97.47 230.7,97.32 230.1,97.32 229.31,96.52 229.31,96.11 229.29,96.09 U3300.12 ; v2(241.73,145.71) 241.96,145.94 242.09,145.94 242.48,145.54 U3401.3
  IN4 w0.076: v2(241.73,145.71) 241.94,145.92 241.94,146.04 242.01,146.12 242.61,146.12 243.71,145.01 243.71,143.73 244.99,142.45 244.99,124.51 241.41,120.92 240.49,120.92 237.11,117.54 237.11,111.17 235.6,109.66 235.6,107.21 233.97,105.58 233.97,104.55 233.07,103.65 233.07,101.82 230.88,99.63 230.88,98.15 v2(230.63,97.91)
LAN_MDI0_N_C: length 10.3
  BOTTOM w0.102: v1(255.24,145.69) 255.24,145.92 ; 255.24,145.92 253.78,145.92 L3403.3 ; 255.24,145.92 256.81,145.92 256.95,145.77 256.95,145.44 256.06,144.55 256.06,143.43 256.44,143.06 257.65,143.06 258.37,142.34 258.37,141.64 CON3400.2
LAN_MDI0_N_L: length 2.5
  TOP w0.102: v2(251,145.74) 251.2,145.54 U3401.22
  BOTTOM w0.102: v2(251,145.74) 251.16,145.89 251.36,145.89 251.61,145.64 L3403.4
LAN_MDI0_P: length 61.8
  TOP w0.102: v2(241.73,146.4) 241.83,146.3 242.19,146.3 242.44,146.54 U3401.2 ; v7(231.32,97.98) 231.22,97.88 231.22,97.33 230.85,96.96 230.24,96.96 229.69,96.4 U3300.11
  IN4 w0.076: v7(231.32,97.98) 231.16,98.14 231.16,99.51 233.35,101.7 233.35,103.53 234.25,104.44 234.25,105.47 235.88,107.09 235.88,109.54 237.39,111.05 237.39,117.43 240.6,120.64 241.52,120.64 245.27,124.39 245.27,142.57 243.99,143.85 243.99,145.13 242.72,146.4 v2(241.73,146.4)
LAN_MDI0_P_C: length 10.3
  BOTTOM w0.102: L3403.2 253.72,146.27 256.95,146.27 257.31,145.92 257.31,145.3 256.42,144.41 256.42,143.93 ; 256.42,143.93 v1(256.65,143.93) ; 256.42,143.93 256.42,143.58 256.59,143.41 257.8,143.41 258.74,142.47 CON3400.1
LAN_MDI0_P_L: length 2.4
  TOP w0.102: U3401.23 251.2,146.54 v2(251,146.35)
  BOTTOM w0.102: v2(251,146.35) 251.11,146.25 251.36,146.25 251.6,146.49 L3403.1
LAN_MDI1_N: length 62
  TOP w0.102: U3401.6 242.49,142.54 242.11,142.92 241.94,142.92 v2(241.73,142.71) ; 229.17,98.31 228.11,97.25 228.11,96.15 228.09,96.13 U3300.15 ; 229.17,98.31 v1(229.01,98.47) ; 229.17,98.31 229.39,98.53 229.39,98.97 v2(229.29,99.07)
  IN4 w0.076: v2(229.29,99.07) 229.29,99.41 229.41,99.53 229.57,99.53 229.69,99.66 229.69,100.08 231.72,102.11 231.72,104.03 232.84,105.15 232.84,107.24 234.34,108.73 234.34,110.72 235.99,112.38 235.99,119.3 236.23,119.54 236.88,119.54 236.96,119.62 236.96,120.05 236.88,120.13 236.23,120.13 235.99,120.37 235.99,121.71 236.32,122.04 238.71,122.04 239.22,122.55 240.06,122.55 240.56,122.04 240.94,122.04 243.85,124.95 243.85,141.59 242.37,143.07 242.09,143.07 v2(241.73,142.71)
LAN_MDI1_N_C: length 8.8
  IN1 w0.076: v2(254.48,142.78) 254.67,142.96 255.35,142.96 256.39,141.93 256.39,140.15 258.18,138.36 CON3400.6
  BOTTOM w0.102: L3402.3 253.72,142.47 254.04,142.78 v2(254.48,142.78)
LAN_MDI1_N_L: length 2.7
  TOP w0.102: U3401.19 251,142.54 v2(250.85,142.69)
  BOTTOM w0.102: L3402.4 251.08,142.47 v2(250.85,142.69)
LAN_MDI1_P: length 62
  TOP w0.089: v1(228.85,97.17) 228.7,97.33
  TOP w0.102: U3300.14 228.49,96.12 228.47,96.14 228.47,97.1 229.77,98.4 229.77,98.9 v2(229.97,99.1) ; U3401.5 242.43,143.54 242.16,143.27 241.81,143.27 v2(241.73,143.35)
  IN4 w0.076: v2(241.73,143.35) 242.48,143.35 244.13,141.7 244.13,124.83 241.06,121.76 240.45,121.76 239.94,122.27 239.33,122.27 238.82,121.76 236.44,121.76 236.27,121.59 236.27,120.48 236.35,120.41 237,120.41 237.24,120.17 237.24,119.5 237,119.26 236.35,119.26 236.27,119.19 236.27,112.26 234.61,110.61 234.61,108.61 233.12,107.12 233.12,105.03 232,103.91 232,102 229.97,99.96 v2(229.97,99.1)
LAN_MDI1_P_C: length 8.8
  IN1 w0.076: v2(254.49,143.39) 254.59,143.29 254.64,143.24 255.47,143.24 256.67,142.04 256.67,140.26 257.17,139.76 257.47,139.76 257.93,140.22 258.37,140.22 258.58,140.43 CON3400.3
  BOTTOM w0.102: v2(254.49,143.39) 254.24,143.14 253.89,143.14 253.74,143.29 RN3402.4
LAN_MDI1_P_L: length 2.6
  TOP w0.102: v2(250.85,143.3) 251.1,143.54 U3401.20
  BOTTOM w0.102: L3402.1 250.87,143.31 v2(250.85,143.3)
LAN_MDI2_N: length 61.5
  TOP w0.102: U3401.9 242.1,139.54 v2(241.73,139.91) ; v7(227.36,98.77) 227.36,98.46 226.92,98.02 226.92,96.18 226.89,96.16 U3300.18
  IN4 w0.076: v2(241.73,139.91) 242.05,140.23 242.58,140.23 242.73,140.07 242.73,139.41 242.58,139.26 242.3,139.26 241.96,138.92 241.96,138.27 242.27,137.97 242.54,137.97 242.73,137.77 242.73,125.54 241.64,124.45 240.92,124.45 240.77,124.6 240.77,125.16 240.45,125.48 239.69,125.48 239.37,125.16 239.37,124.6 239.22,124.45 238.33,124.45 238.01,124.14 238.01,123.44 237.86,123.28 237.32,123.28 237.17,123.44 237.17,124.14 236.86,124.45 235.83,124.45 234.87,123.5 234.87,112.84 232.95,110.92 232.95,108.94 231.72,107.71 231.72,105.61 230.54,104.43 230.54,103.59 229.92,102.96 229.92,101.98 227.76,99.83 227.76,99.2 227.69,99.13 227.43,99.13 227.36,99.05 v7(227.36,98.77)
LAN_MDI2_N_C: length 10.4
  BOTTOM w0.102: 256.02,139.44 256.02,138.77 256.6,138.19 258.33,138.19 258.53,138.39 CON3400.5 ; 256.02,139.44 256.02,141.42 255.89,141.55 255.39,141.55 255.26,141.42 255.26,140.34 254.84,139.92 254.07,139.92 253.82,139.67 L3401.3 ; 256.02,139.44 v1(255.79,139.44)
LAN_MDI2_N_L: length 2.5
  TOP w0.102: v2(250.9,139.77) 251.13,139.54 U3401.16
  BOTTOM w0.102: v2(250.9,139.77) 251,139.67 L3401.4
LAN_MDI2_P: length 61.5
  TOP w0.102: v2(228.04,98.77) 228.04,98.64 227.27,97.87 227.27,96.22 227.29,96.2 U3300.17 ; v2(241.73,140.54) U3401.8
  IN4 w0.076: v2(241.73,140.54) 242.06,140.54 242.1,140.51 242.7,140.51 243.01,140.19 243.01,139.3 242.7,138.98 242.42,138.98 242.24,138.8 242.24,138.39 242.38,138.24 242.66,138.24 243.01,137.89 243.01,125.43 241.76,124.17 240.8,124.17 240.49,124.49 240.49,125.05 240.34,125.2 239.8,125.2 239.65,125.05 239.65,124.49 239.33,124.17 238.44,124.17 238.29,124.02 238.29,123.32 237.97,123 237.21,123 236.89,123.32 236.89,124.02 236.74,124.17 235.94,124.17 235.15,123.39 235.15,112.73 233.23,110.8 233.23,108.83 232,107.6 232,105.49 230.82,104.31 230.82,103.47 230.2,102.85 230.2,101.87 228.04,99.71 v2(228.04,98.77)
LAN_MDI2_P_C: length 10.5
  BOTTOM w0.102: L3401.2 253.65,140.52 253.9,140.27 254.69,140.27 254.91,140.49 254.91,141.57 255.24,141.9 255.6,141.9 ; 255.6,141.9 v1(255.6,142.13) ; 255.6,141.9 256.04,141.9 256.38,141.57 256.38,138.92 256.74,138.55 258.19,138.55 258.47,138.83 258.47,139.28 258.34,139.41 CON3400.4
LAN_MDI2_P_L: length 2.5
  TOP w0.102: U3401.17 251.07,140.54 v2(250.9,140.38)
  BOTTOM w0.102: v2(250.9,140.38) 251.04,140.52 L3401.1
LAN_MDI3_N: length 61.8
  TOP w0.102: U3300.21 225.52,95.53 225.12,95.94 225.12,97.32 v7(224.97,97.47) ; v2(241.35,136.87) 241.53,137.05 241.91,137.05 241.99,136.97 241.99,136.7 242.14,136.54 U3401.12
  IN4 w0.076: v7(224.97,97.47) 225.28,97.79 225.28,98.96 228.71,102.39 228.71,103.46 229.36,104.11 229.36,105.12 230.61,106.36 230.61,108.18 231.84,109.41 231.84,111.38 233.63,113.18 233.63,124.54 234.66,125.57 235.65,125.57 235.89,125.81 235.89,127.17 236.25,127.53 237.03,127.53 237.41,127.14 237.41,125.81 237.66,125.57 238.09,125.57 238.25,125.74 238.25,128.11 238.58,128.44 239.57,128.44 239.9,128.11 239.9,127.41 239.65,127.16 239.65,126.78 239.82,126.61 241.38,126.61 241.61,126.84 241.61,136.62 v2(241.35,136.87)
LAN_MDI3_N_C: length 10.2
  BOTTOM w0.102: v1(254.56,135.6) 254.79,135.6 ; 254.79,135.6 254.79,137.17 254.61,137.35 254.24,137.35 254.13,137.24 254.13,136.97 254.03,136.88 L3400.3 ; 254.79,135.6 254.79,134.71 255.12,134.37 256.54,134.37 256.87,134.71 256.87,135.97 257.08,136.18 258.06,136.18 258.18,136.07 CON3400.8
LAN_MDI3_N_L: length 2.7
  TOP w0.102: v2(250.88,137.03) 251.26,137.03 251.74,136.54 U3401.13
  BOTTOM w0.102: L3400.4 251.28,136.88 251.13,137.03 v2(250.88,137.03)
LAN_MDI3_P: length 61.7
  TOP w0.102: v2(241.35,137.51) 241.45,137.41 241.94,137.41 242.07,137.54 U3401.11 ; v2(225.66,97.47) 225.47,97.29 225.47,96.08 225.83,95.73 U3300.20
  IN4 w0.076: v2(225.66,97.47) 225.56,97.57 225.56,98.85 228.99,102.28 228.99,103.34 229.64,103.99 229.64,105 230.89,106.25 230.89,108.06 232.12,109.29 232.12,111.27 233.91,113.06 233.91,124.42 234.78,125.29 235.76,125.29 236.17,125.7 236.17,127.05 236.36,127.25 236.92,127.25 237.13,127.03 237.13,125.7 237.54,125.29 238.2,125.29 238.53,125.62 238.53,127.99 238.7,128.16 239.46,128.16 239.62,127.99 239.62,127.53 239.37,127.27 239.37,126.66 239.7,126.33 241.49,126.33 241.88,126.72 241.88,136.97 v2(241.35,137.51)
LAN_MDI3_P_C: length 10.3
  BOTTOM w0.102: v1(256.29,135.27) 256.52,135.27 ; 256.52,135.27 256.52,136.12 256.94,136.54 258.21,136.54 258.4,136.35 259.28,136.35 CON3400.7 ; 256.52,135.27 256.52,134.85 256.39,134.73 255.27,134.73 255.14,134.85 255.14,137.31 254.75,137.7 RN3400.4
LAN_MDI3_P_L: length 2.7
  TOP w0.102: U3401.14 251.38,137.54 251.25,137.41 251.09,137.41 v2(250.87,137.64)
  BOTTOM w0.102: RN3400.3 251.25,137.7 251.19,137.64 v2(250.87,137.64)
LAN_RXN: length 122.8
  TOP w0.114: v2(220.1,90.08) 220.19,90.17 220.19,91.63 220.65,92.09 220.85,92.09 ; 220.85,92.09 221.62,92.09 C3314.2 ; 220.85,92.09 v1(220.85,92.35)
  IN4 w0.089: v2(162.15,54.35) 162.41,54.6 162.41,54.78 162.34,54.85 159.98,54.85 158.72,56.1 156.79,56.1 156.14,55.45 154.86,55.45 154.27,54.86 145.19,54.86 144.65,55.39 144.65,56.97 145.22,57.53 147.41,57.53 148.01,58.13 151.25,58.13 158.47,65.35 162.03,65.35 165.13,68.45 165.13,71.69 165.61,72.18 165.61,72.86 167.29,74.54 174.2,74.54 174.63,74.97 176.63,74.97 177.73,73.87 186.59,73.87 187.31,74.59 188.62,74.59 193.91,79.88 208.76,79.88 209.44,80.55 217.32,80.55 218.44,81.68 218.44,85.67 220.65,87.88 220.65,88.94 220.1,89.49 v2(220.1,90.08)
  BOTTOM w0.114: U2000.E20 162.15,54.11 v2(162.15,54.35)
