# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N126072357: length 2.6
  TOP w0.102: T2408.1 182.18,50.43 v2(182.09,50.52)
  BOTTOM w0.089: v2(182.09,50.52) 181.88,50.31 181.37,50.31 181.14,50.54 180.75,50.54 180.51,50.29 U2000.BC26
N126072385: length 17
  TOP w0.102: T2404.1 193.95,58.79 v2(193.95,58.56)
  BOTTOM w0.089: U2000.BC15 180.86,55.7 182.87,55.7 183.27,56.11 183.27,56.87 184.3,57.9 184.71,57.9
  BOTTOM w0.102: 184.71,57.9 187.75,57.9 187.93,58.08 189.1,58.08 189.15,58.03 189.85,58.03 190.12,57.77 190.12,57.35 190.22,57.25 191.63,57.25 191.74,57.14 192.12,57.14 192.56,57.58 192.56,57.59 193.53,58.56 v2(193.95,58.56)
N126072389: length 5.2
  TOP w0.102: v2(177.86,55.54) 177.85,55.54 177.39,55.08 174.19,55.08 173.91,55.36 T2402.1
  BOTTOM w0.089: v2(177.86,55.54) 178,55.69 U2000.AV15
N126072391: length 6
  BOTTOM w0.089: U2000.BB13 180.23,56.99 180.35,56.87 182.03,56.87 182.31,57.15 182.79,57.15 184.65,59.01 184.71,59.01
  BOTTOM w0.102: 184.71,59.01 T2401.1
N126075660: length 2.5
  BOTTOM w0.508: R2619.1 187.25,39.81 187.25,40.85 186.88,41.22 186.13,41.22 R2616.1
  vias: v1(184.91,41.25)
N126076532: length 33.3
  TOP w0.508: R2617.1 171.45,66.15 v2(171.45,66.08) 171.45,65.73 171.46,65.73 v1(171.46,65.44)
  IN4 w0.254: v2(178.77,50.74) 178.77,50.78 178.31,51.24 174.46,51.24 174.22,51.48 173.91,51.78 173.91,55.34 173.15,56.1 171.63,56.1 171.12,56.61 171.12,61.23 171.45,61.56 171.45,62.88 171.25,62.88 169.95,61.58 169.95,56.5 v2(169.34,55.89)
  IN4 w0.508: 171.45,62.88 v2(171.45,66.08)
  BOTTOM w0.203: U2000.BA24 179.32,51.29 v2(178.77,50.74)
  BOTTOM w0.254: v2(169.34,55.89) 169.22,55.76 U2000.W15
N126076879: length 16
  TOP w0.102: v1(171.28,42.22) 171.04,41.98 C2604.1
  TOP w0.381: C2602.1 174.82,42.08 175.17,42.43 v2(175.17,42.87) ; C2604.1 170.33,42.44 v2(170.62,42.72)
  TOP w0.508: v2(180.38,43.35) 181.03,42.71 C2603.1 181.27,42.36 182.12,41.51 R2615.1
  IN4 w0.508: v2(175.17,42.87) 174.84,42.54 170.8,42.54 v2(170.62,42.72)
  BOTTOM w0.203: v2(170.62,42.72) 170.92,43.02 U2000.AD41 ; U2000.AJ41 173.57,43.26 173.96,43.65 174.34,43.65 174.61,43.38 174.61,43.37 174.62,43.36 174.62,43.16 U2000.AL41 174.97,43.07 v2(175.17,42.87)
  BOTTOM w0.254: U2000.BD40 180.54,43.51 v2(180.38,43.35) 180.77,42.96 U2000.BC42
N126150154: length 8.2
  TOP w0.114: v6(58.19,147.24) 59.25,146.18 v1(59.53,146.18) 60.04,146.18 60.33,145.9 60.33,144.6 60.09,144.37 58.47,144.37 58.34,144.24 R0302.1
  BOTTOM w0.076: v6(58.19,147.24) 58.37,147.24 58.63,146.97 58.63,146.26 U0300.G29
N126154000: length 2.3
  TOP w0.102: R0743.2 55.68,141.6 v1(55.7,141.62) 56.02,141.62 v6(56.43,141.22)
  BOTTOM w0.102: U0300.J23 v6(56.43,141.22)
N126183850: length 7.5
  BOTTOM w0.432: U0300.BN1 23.6,124.96 23.02,124.38 22.86,124.38 21.35,122.86 21.35,122.86 v1(20.6,122.12) 19.76,122.12 18.8,123.08 R0734.2
N126215700: length 6.8
  TOP w0.102: v6(41.9,145.3) 41.66,145.54 v1(41.66,145.86)
  TOP w0.203: R0901.1 41.9,144.67 v6(41.9,145.3)
  BOTTOM w0.178: v6(41.9,145.3) 41.9,149.55 42.1,149.76 U0300.AH35 U0300.AH36
N126273757: length 3.1
  TOP w0.102: R1011.2 23.23,132.62 22.79,132.18 v1(22.24,132.18)
  BOTTOM w0.203: v6(24.51,133.5) 24.84,133.83 U0300.BL14 ; v6(23.86,133.5) 24.19,133.83 U0300.BM14
N126273866: length 1.9
  TOP w0.102: v1(33.05,133.67) 33.05,133.65 v6(33.48,133.22)
  TOP w0.254: v6(33.48,133.22) 33.66,133.04 R1013.1
  BOTTOM w0.254: v6(33.48,133.22) 33.16,132.9 U0300.AY13
N126273877: length 1.7
  TOP w0.254: v6(35.32,133.22) 34.7,132.6 R1013.2
  BOTTOM w0.254: U0300.AU13 35,132.9 v6(35.32,133.22)
N126385512: length 12.8
  BOTTOM w0.102: R5706.2 152.7,140.55 152.93,140.78 152.93,141.32 153.44,141.83 154.56,141.83 155.35,142.62 156.98,142.62 157.13,142.77 157.13,145.83 156.35,146.61 v1(155.7,146.61)
  BOTTOM w0.254: Q5704.1 151.76,139.04 152.45,139.74 R5706.2
N126462372: length 27.7
  IN3 w0.254: v6(49.02,131.92) 49.1,131.92 49.5,131.51 49.5,130.82 49.5,130.81 49.5,130.21 49.5,130.2 49.5,129.82 49.5,129.81 49.5,129.13 50.06,128.56 56.83,128.56 57.11,128.28 57.11,127.1 59.11,125.11 63.75,125.11 v6(64.26,125.62)
  BOTTOM w0.254: U0300.Y12 48.91,131.92 v6(49.02,131.92) ; R1001.1 68.91,125.47 69.52,124.86 v1(69.52,124.73)
  BOTTOM w0.305: R1001.1 68.55,125.62 68.24,125.94 C1000.1 67.87,126.46 67.37,125.96 64.61,125.96 v6(64.26,125.62)
N126463138: length 2.9
  TOP w0.102: v6(57.98,132.96) 57.98,133.84 T1003.1
  BOTTOM w0.102: U0300.H14 57.98,133.77 v6(57.98,132.96)
N126463140: length 1.8
  TOP w0.102: v6(56.46,134.36) 56.03,133.92 T1002.1
  BOTTOM w0.102: v6(56.46,134.36) 56.69,134.13 U0300.J14
N126612066: length 7.4
  TOP w0.102: R5301.1 R5302.1 v1(240.34,83.02) 239.95,83.02 239.45,83.53 Q5301.3 Q5302.3
N126612078: length 5.1
  TOP w0.254: Q5300.1 244.01,87.46 v1(242.49,85.95) 242.37,85.82 C5302.1 R5301.2
N126612092:
  vias: v1(239.88,88.56)
N126721657: length 4.7
  TOP w0.254: v6(24.51,135.08) 24.51,135.4 25.38,136.26 26.38,136.26 26.46,136.18 26.96,136.18 R1003.2
  BOTTOM w0.254: U0300.BL15 24.51,135.01 v6(24.51,135.08) 24.19,135.41 U0300.BM16
N126721746: length 8.3
  TOP w0.254: R1006.2 26.98,137.81 26.26,138.52 25.54,138.52 24.94,137.93 24.94,136.33 23.36,134.75 23.03,134.75 23.02,134.74 v1(22.42,134.74) 22.25,134.74 v6(21.91,135.08)
N126721910: length 9.6
  BOTTOM w0.381: R1007.2 14.69,130.95 16.46,130.95 17.08,131.57 17.34,131.57 19.52,133.75 v1(19.56,133.75) 20.34,134.53 20.34,134.82 20.83,135.31
N126721980: length 4.9
  TOP w0.254: v6(23.86,134.29) 24.37,134.29 24.98,134.9 26.96,134.9 R1008.2
  BOTTOM w0.254: U0300.BN15 23.54,134.63 23.86,134.31 v6(23.86,134.29) 24.19,134.62 U0300.BM15
N126722847: length 5.2
  TOP w0.102: R1012.2 22.62,149.91 22.89,150.17 v1(24.34,150.17) 25.08,149.44 v6(25.36,149.44)
  BOTTOM w0.102: v6(25.36,149.44) 25.43,149.44 U0300.BJ35 U0300.BJ36
N127662539: length 12.7
  TOP w0.102: R3612.2 26.62,76.19 v1(26.82,76.4)
  TOP w0.203: v2(22.91,70.51) U3600.9
  TOP w0.457: R3612.2 R3609.2 24.31,76.11 C3631.1 24.31,74.6 24.27,74.56 C3642.1 C3630.1 24.27,72.48 24.83,71.93 v2(26.03,71.93)
  BOTTOM w0.508: v2(26.03,71.93) 25.27,71.93 23.85,70.51 v2(22.91,70.51)
N127663036: length 2.9
  TOP w0.102: U3600.7 23.44,69.71 v1(23.6,69.87) 23.76,70.03 C3616.1
N129068465: length 2.6
  TOP w0.102: v1(76.81,124.14) 76.81,124.86 R7403.2 U7401.6
N129068468: length 3.5
  TOP w0.102: U7401.5 R7402.2 76.61,125.93 v1(75.27,125.93)
N129069433: length 15.5
  BOTTOM w0.102: v1(82.48,126.41) 82.63,126.26 83.28,126.26 83.57,126.55 85.23,126.55 R7404.2 85.78,126.36 85.89,126.47 88.59,126.47 89.97,127.84 94.44,127.84 94.67,127.62 94.67,127.22 95.19,126.7 U7000.BB7
N129069925: length 3.6
  TOP w0.102: U7401.1 85.73,122.57 v1(85.93,122.37) 86.11,122.55 R7400.1 R7401.2
N129582425: length 12.1
  TOP w0.102: v6(97.07,123.1) 96.72,123.1 94.45,125.36 89.97,125.36 89.23,124.63 v1(89.03,124.63) 87.38,124.63 R7401.1
  BOTTOM w0.102: U7000.BA3 97.07,123.13 v6(97.07,123.1)
N129589225: length 12.4
  BOTTOM w0.102: v1(127.63,164.53) 126.77,164.53 R7503.1
  BOTTOM w0.203: U7000.R49 117.5,160.88 117.88,161.25 122.3,161.25 123.8,162.75 125.25,162.75 126.16,163.66 126.16,163.92 R7503.1
N129589246: length 8.5
  BOTTOM w0.102: R7502.1 94.59,166.13 94.41,165.96 94.41,164.74 v1(93.7,164.03) 93.7,162.07 94.41,161.36 94.82,161.36 95.51,160.67 95.51,160.16 95.9,159.77 U7000.BB48
N129596305: length 1.7
  TOP w0.089: v6(116.89,151.4) 116.89,150.97 T7501.1
  BOTTOM w0.102: U7000.R39 116.89,151.49 v6(116.89,151.4)
N129596308: length 3.8
  TOP w0.089: v6(107.9,130.7) 108.48,131.28 108.48,132.83 108.08,133.24 T7502.1
  BOTTOM w0.102: U7000.AG11 v6(107.9,130.7)
N129596311: length 1.7
  TOP w0.089: v6(109.03,129.61) 108.6,130.04 T7500.1
  BOTTOM w0.102: U7000.AF10 108.9,129.1 109.03,129.23 v6(109.03,129.61)
N129596314: length 6.2
  TOP w0.089: R7501.1 118.75,149.64 v1(118.15,150.24) 117.56,150.24 117.27,150.54 117.27,153.15 117.65,153.53 v6(117.91,153.53)
  BOTTOM w0.102: U7000.P40 118.11,153.29 118.11,153.33 v6(117.91,153.53)
N129596317: length 10.7
  BOTTOM w0.102: U7000.R48 117.5,159.72 117.13,160.09 117.13,161.04 117.65,161.56 121.79,161.56 123.42,163.18 v1(123.42,163.85) 123.8,164.23 R7506.1
N129596320: length 12.3
  BOTTOM w0.102: R7500.1 123.92,165.24 121.69,163.01 v1(121.69,162.76) 120.96,162.02 117.61,162.02 116.83,161.25 116.83,160.02 117.1,159.75 117.1,159.1 U7000.R47
N129616581: length 34.6
  TOP w0.305: C7208.1 81.05,151.96 v2(81.23,151.78) ; C7208.1 80.57,152.29 80.6,152.32 C7207.1 C7206.1 C7209.1 ; C7208.1 R7206.2 ; C7209.1 82.08,153.4 81.55,152.87 L7201.2 ; C7209.1 82.08,155.1 81.83,155.35 v1(80.92,155.35)
  IN1 w0.305: v6(98.86,143.08) 98.37,142.59 98.37,141.26 97.97,140.86 90.54,140.86 81.23,150.17 v2(81.23,151.78)
  BOTTOM w0.254: U7000.AW27 98.86,143.06 v6(98.86,143.08)
N129616961: length 32
  TOP w0.305: C7210.1 78.36,151.09 78.08,150.82 v1(77.78,150.82) ; C7210.1 R7206.1 ; C7210.1 78.79,150.71 v2(79.03,150.47)
  IN1 w0.305: v6(98.86,143.91) 99.42,143.35 99.42,141.12 98.75,140.45 90.37,140.45 80.76,150.07 80.76,150.61 80.27,151.1 79.51,151.1 79.03,150.62 v2(79.03,150.47)
  BOTTOM w0.254: v6(98.86,143.91) 98.86,143.86 U7000.AW28
N129618256: length 6.6
  BOTTOM w0.102: R7210.2 94.23,118.44 v1(94.23,118.79) 94.24,118.94 94.24,119.98 95.5,121.25 95.5,123.1 U7000.BB3
N129618265: length 11.2
  BOTTOM w0.102: 96.29,118.79 96.29,122.3 95.9,122.7 U7000.BB2
  BOTTOM w0.114: 96.29,118.79 95.99,118.49 C7215.1 96.44,117.54 96.44,115.21 X7200.1 94.88,113.64 94.19,113.64 v1(93.99,113.44)
N129618849: length 8.5
  BOTTOM w0.102: R7208.2 R7211.1 v1(93.75,116.1) 94.8,117.14 94.8,117.62 94.69,117.72 94.69,120.04 95.9,121.25 U7000.BB1
N129619906: length 5.9
  BOTTOM w0.102: U7000.BA1 96.57,121.77 96.57,119.85 v1(96.85,119.58) 96.57,119.3 96.57,118.38
  BOTTOM w0.114: 96.57,118.38 96.57,118.2 C7216.1 97.29,117.48 X7200.3
N129634919:
  vias: v1(155.76,108.62)
N129635970:
  vias: v1(146.91,92.94)
N129637628:
  vias: v1(145.27,97.86)
N129637680:
  vias: v1(146.52,99.15)
N129797271: length 4.8
  TOP w0.102: Q7600.3 135.73,174.89 135,174.16 R7608.1 134.09,173.7 v1(133.99,173.6) 134.47,173.12 R7609.1
N129798096: length 6.7
  BOTTOM w0.102: R7709.1 R7708.1 157.4,164.65 Q7700.3 157.15,165.57 157.53,165.96 157.53,166.59 157.15,166.97 157.15,168.75 v1(157.28,168.88)
N129799839: length 4.1
  BOTTOM w0.102: Q7800.3 157.2,125.79 157.55,125.44 R7808.1 157.81,124.31 157.83,124.31 R7809.1 158.44,123.07 v1(158.14,122.78)
N129800921: length 4.5
  TOP w0.102: Q7900.3 135.91,116.25 135.94,116.27 R7909.1 135.94,118.04 R7908.1 v1(134.77,118.97)
N129948629: length 3.1
  TOP w0.102: U3300.10 230.26,95.58 230.56,95.88 v2(230.56,96.49)
  BOTTOM w0.102: v2(230.56,96.49) 230.51,96.44 v1(230.51,95.85) 230.64,95.72 R3306.2
N129953010: length 2.9
  TOP w0.102: R3305.1 223.35,93.92 v1(224.28,93.92) 224.32,93.96 U3300.24
N129953281: length 5.3
  TOP w0.102: R3305.2 220.9,93.44 217.98,90.52 T3303.1
N129960916: length 6.4
  TOP w0.102: U3600.12 22.47,71.71 22.68,71.92 22.68,75.83 22.27,76.24 v1(22.27,76.57) C3617.1
N129960923: length 4.1
  TOP w0.102: C3617.2 22.27,79.27 v1(22.32,79.32) 22.23,79.42 C3618.1 R3607.1 21.34,80 R3606.1
N129962294: length 4.5
  TOP w0.203: 22.01,74 R3623.1 R3624.1 ; 22.01,74 21.74,73.72 v2(21.74,73.25) 21.74,72.93 21.5,72.7 U3600.13 ; 22.01,74 R3603.1
  BOTTOM w0.203: v2(21.74,73.25) 21.45,72.96 v1(21.45,72.59)
N129962321: length 2.9
  TOP w0.203: U3600.19 19.1,72.86 19.36,73.11 19.36,73.77 v1(19.18,73.94) 18.96,74.16 18.96,74.63 R3620.2
N129962530: length 2.1
  TOP w0.203: R3600.1 15.04,71.59 15.42,71.59 16.1,70.91 U3600.27
  vias: v1(12.02,73.43)
N129962745: length 5.8
  TOP w0.203: U3600.34 15.16,68.11 14.83,67.78 v2(14.83,67.66)
  BOTTOM w0.203: v1(16.46,69.95) 16.64,69.78 C3604.1 16.34,68.85 16.33,68.85 15.27,68.85 14.83,68.41 v2(14.83,67.66)
N129962763: length 3.2
  TOP w0.102: v1(15.66,65.5) 15.66,65.66 v2(16.56,66.56)
  TOP w0.203: U3600.37 17.1,66.82 16.95,66.97 16.71,66.97 16.56,66.82 v2(16.56,66.56)
  BOTTOM w0.203: v2(16.56,66.56) 16.43,66.69 C3603.2
N129963384: length 23.5
  TOP w0.203: U3600.40 18.3,66.04 18.05,65.78 18.05,65.16 17.69,64.8 17.23,64.8 v2(17.05,64.98)
  IN2 w0.508: v2(16.7,80.35) 16.7,79.48 15.32,78.1 15.32,72.03 16.31,71.04 16.31,67.66 15.94,67.28
  BOTTOM w0.508: v2(17.05,64.98) 17.29,65.22 C3613.1 ; v2(16.7,80.35) 18.31,81.96 18.83,81.96 v1(19.76,82.89) 19.83,82.96 L3600.2
N129963392:
  vias: v1(19.1,62.43)
N130075477: length 4.7
  TOP w0.203: C3600.1 15.23,70.32 v6(15.53,70.62) 15.95,70.62 16.06,70.51 U3600.28
  TOP w0.254: C3600.1 14.79,70.32 13.5,71.61 12.61,71.61 v1(12.51,71.71)
N130157386: length 238.1
  TOP w0.254: v1(18.72,79.34) v2(18.72,80.1)
  IN4 w0.254: v2(18.72,80.1) 18.72,80.71 19.03,81.02 20.85,81.02 23.93,77.94 23.93,75.18 23.65,74.9 23.65,70.56 23.01,69.93 23.01,69.19 24.51,67.69 24.51,64.06 24.59,63.98 24.59,63.05 24.59,62.76 31.93,55.41 31.93,36.3 34.7,33.53 50.02,33.53 51.43,34.94 67.39,34.94 69.91,32.43 110.94,32.43 113.13,30.23 123.55,30.23 126.12,27.67 153.5,27.67 156.67,24.5 193.16,24.5 195.58,26.92 200,26.92 200.74,27.65 200.74,30.27 201.3,30.83 202.87,30.83 203.12,31.08 203.12,31.57 202.72,31.97 v2(202.62,31.97)
  BOTTOM w0.254: C3702.1 18.59,79.7 18.72,79.82 v2(18.72,80.1) ; U3700.9 202.52,32.07 v2(202.62,31.97)
N130157404: length 237.7
  TOP w0.254: v2(18.09,80.1) 17.83,80.36 v1(17.83,80.87)
  IN4 w0.254: v2(18.09,80.1) 18.09,80.96 18.5,81.37 21.01,81.37 24.28,78.1 24.28,74.79 24.13,74.64 24.13,70.54 23.37,69.78 23.37,69.34 24.87,67.84 24.87,64.21 24.94,64.13 24.94,62.9 32.28,55.56 32.28,36.44 34.85,33.88 49.87,33.88 51.29,35.29 67.54,35.29 70.05,32.78 111.22,32.78 113.41,30.59 123.81,30.59 126.37,28.02 153.78,28.02 156.95,24.85 192.97,24.85 195.41,27.3 199.87,27.3 200.36,27.78 200.36,30.45 201.12,31.21 202.49,31.21 v2(202.62,31.34)
  BOTTOM w0.254: v2(202.62,31.34) 202.52,31.34 202.24,31.62 U3700.10 ; v2(18.09,80.1) 17.58,79.6 C3703.1
N130159038: length 2.9
  BOTTOM w0.102: C3709.1 202.49,33.84 203,33.33 v1(203.01,32.84) 202.69,32.52 U3700.8
N130159071: length 3.8
  BOTTOM w0.102: R3702.2 200.58,34.49 v1(200.61,34.46) 200.87,34.2 201.39,34.2 202.23,33.36 202.23,33.15 202.05,32.97 U3700.7
N130819139: length 6.8
  TOP w0.102: U3101.3 R3116.2 195.96,42.76 v1(195.7,43.02) 196.01,43.33 196.01,44.16 196.27,44.42 196.27,45.56 196.57,45.86 R3159.2
N130819371: length 3.3
  TOP w0.102: v1(198.82,42.38) 198.44,42.76 R3160.2 197.87,42.01 197.92,41.96 U3101.2
N130819511: length 9.9
  TOP w0.102: v1(195.07,27.3) 195.1,27.32 R3124.2 196.62,27.32 196.77,27.48 R3158.1 196.82,27.93 196.82,30.53 197.43,31.13 198.16,31.13 198.5,31.47 198.5,32.08 198.35,32.23 198.04,32.23 197.92,32.36 U3101.7
N131133476: length 9.4
  TOP w0.102: R5127.2 R5124.1 R5108.1 25.25,30.19 25.12,30.07 21.82,30.07 21.69,29.94 v1(21.69,29.46) 21.69,28.6 22.38,27.91 CON5101.P1
N131133514: length 13.7
  TOP w0.102: R5109.1 24.36,27.98 23.47,28.87 v1(23.47,29.15) 23.92,29.61 R5132.2 ; R5109.1 25.4,27.98 25.58,28.16 25.58,28.33 25.71,28.45 27.49,28.45 27.74,28.2 R5125.1 ; R5109.1 25.07,27.26 v2(25.17,27.16)
  BOTTOM w0.102: v2(25.17,27.16) 25.17,26.08 22.59,23.5 CON5101.P4
N131225266: length 2.9
  TOP w0.102: v6(111.91,176.67) 111.1,176.67 v1(110.8,176.37) 111.14,176.03 R7614.1
  BOTTOM w0.102: U7601.J10 v6(111.91,176.67)
N131225824: length 2.6
  TOP w0.254: v1(147.44,173.72) 147.54,173.82 148.38,173.82 v6(148.55,173.98)
  TOP w0.305: v6(148.55,173.98) 148.34,174.2 R7714.1
  BOTTOM w0.254: U7701.J10 148.77,173.76 v6(148.55,173.98)
N131226392: length 2.4
  TOP w0.102: v1(147.68,148.4) R7814.1 v6(147.68,146.85)
  BOTTOM w0.089: v6(147.68,146.85) 147.68,146.55 147.48,146.35 U7801.J10
N131226956: length 2.8
  TOP w0.102: v6(131.45,106.44) 132.13,106.44 v1(132.39,106.71) 132.02,107.08 R7914.1
  BOTTOM w0.102: U7901.J10 131.32,106.57 v6(131.45,106.44)
N131250324: length 5.5
  BOTTOM w0.102: v1(157.84,78.47) 155.61,78.47 R8720.2
  BOTTOM w0.203: U8700.13 152.94,79.15 153.08,79.01 R8720.2
N131250337: length 3
  BOTTOM w0.102: R8719.2 153.23,78.27 v1(153.7,78.27)
  BOTTOM w0.254: U8700.14 152.44,78.01 R8719.2
N131250344: length 2.2
  BOTTOM w0.254: 151.94,78.6 U8700.15
  BOTTOM w0.305: 151.94,78.6 v1(151.64,78.3) 151.82,78.13 R8718.2
N131316400: length 6.1
  TOP w0.102: v2(234.26,61.21) 234.39,61.08 U9103.5 ; v2(234.24,62.24) 234.42,62.24 234.78,61.88 U9103.3
  BOTTOM w0.102: v1(234.52,60.6) 233.86,60.6 233.6,60.85 C9128.1 ; C9128.1 R9109.2 234.14,62.14 v2(234.24,62.24) ; C9128.1 234.22,61.25 v2(234.26,61.21)
N131316575: length 2.8
  TOP w0.102: v1(239.07,62.98) 238.89,62.81 C9129.1 238.61,62.27 238.24,62.27 237.86,61.88 U9103.12
N131316591: length 2.5
  TOP w0.102: U9103.10 C9127.1 238.89,60.32 v1(239.09,60.11)
N131317511: length 15.8
  BOTTOM w0.102: U4502.1 58.28,174.53 58.95,175.2 R4526.2 ; R4526.2 60.17,174.77 60.17,172.72 R4590.2 60.43,172.28 60.59,172.12 60.59,172.09 60.62,172.06 60.64,172.06 60.7,172.01 61.7,172.01 v1(62.2,172.51) ; R4526.2 R4588.1 57.81,175.94 57.08,175.21 55.93,175.21 55.62,175.51 55.62,178.42 R4591.1
N131362545: length 1.3
  TOP w0.102: U3300.39 229.29,90.55 229.59,90.25 T3301.1
N131362585: length 3.3
  TOP w0.102: U3300.38 228.89,90.56 229.01,90.43 229.01,89.47 229.65,88.83 T3302.1
N131411654: length 4.7
  TOP w0.102: v1(200.94,82.5) 199.86,82.5 R9111.1 C9134.1 198.21,81.66 Q9105.1
N131411656: length 2.8
  BOTTOM w0.102: Q9104.2 212.51,84.53 212.89,84.15 212.89,83.83 v1(213.18,83.53) 213.28,83.43 SR9104.2
N131411685: length 20.5
  TOP w0.102: v2(209.74,87.21) 207.37,87.21 206.51,86.34 206.51,84.76 204.68,82.94 200.77,82.94 200.68,82.85 199.34,82.85 R9111.2
  BOTTOM w0.102: R9110.1 211.99,82.62 211.38,83.23 210.84,83.23 210.19,83.88 Q9104.4 209.56,83.88 209.42,84.02 209.42,85.69 209.89,86.16 T9113.1 209.89,87.05 v2(209.74,87.21)
N131439778: length 5
  TOP w0.076: U1101.N16 241.8,31.8 v4(241.47,31.47)
  BOTTOM w0.102: v4(241.47,31.47) 241.7,31.24 R1101.1 241.7,29.5 241.26,29.06 241.26,28.51 241.45,28.31 241.45,27.83 v1(241.05,27.42)
N131441491: length 17.4
  TOP w0.102: v4(242.12,36.67) 241.8,36.35 U1101.N6
  IN4 w0.102: v4(242.12,36.67) 242.44,36.99 242.44,37.48 241.96,37.96 241.13,37.96 239.91,39.18 237.52,39.18 234.39,42.31 234.39,43.23 233.7,43.92 232.77,43.92 232.32,44.37 v2(232.32,44.37)
  BOTTOM w0.102: v1(233.55,43.71) 232.99,43.71 v2(232.32,44.37) 232.24,44.29 R1102.1
N131445423: length 4.2
  TOP w0.102: U1101.Y18 238.55,31.15 238.55,31.14 v4(238.86,30.83)
  BOTTOM w0.102: R1108.1 235.88,29.89 236.19,29.58 237.03,29.58 237.45,30 v1(237.45,30.22) 238.25,30.22 v4(238.86,30.83)
N131647000: length 15.8
  TOP w0.102: U1101.M4 242.58,37.52 242.62,37.52 v4(242.81,37.32)
  IN4 w0.102: v4(242.81,37.32) 242.81,37.4 242.03,38.18 241.21,38.18 239.1,40.3 237.73,40.3 237.71,40.28 236.73,40.28 234.81,42.2 234.81,43.1 233.56,44.35 v2(232.95,44.35)
  BOTTOM w0.102: v2(232.95,44.35) 232.95,44.36 v1(232.26,45.05) 232.13,45.18 R1121.2
N131715858: length 6.1
  TOP w0.076: 241.71,48.42 U1201.F1
  TOP w0.102: R1211.2 238.02,46.11 239.93,46.11 v1(240.67,46.85) 240.96,47.14 241.27,47.14 241.66,47.53 241.66,48.37 241.71,48.42
N131716225: length 5.5
  TOP w0.076: U1201.G2 242.24,48.95 242.24,48.6 241.99,48.35
  TOP w0.102: 241.99,48.35 241.86,48.22 241.86,47.41 240.79,46.34 v1(240.79,45.41) 240.51,45.69 R1218.2
N131716263: length 8.3
  TOP w0.102: v1(232.74,48.63) 232.74,48.52 233.38,47.88 233.65,47.88 233.94,47.59 C1208.1 234.53,47.46 234.68,47.61 234.68,48.02 234.79,48.13 236.55,48.13 236.79,48.38 237.9,48.38 238.31,48.79 239.08,48.79 U1201.A2
N131716280: length 4.5
  TOP w0.102: C1207.1 245.86,45.34 245.67,45.53 245.67,46.6 244.4,47.87 244.4,48.16 243.99,48.57 U1201.K1
N131716387: length 11.4
  TOP w0.102: v1(232.64,46.91) 233.05,46.91 233.94,46.01 C1221.1 234.61,46.48 235.62,46.48 235.9,46.19 237.8,46.19 237.93,46.33 239.54,46.33 240.56,47.36 241.17,47.36 241.45,47.64 241.45,48.46 241.49,48.49 U1201.E1
N135192727: length 5.9
  TOP w0.114: U3001.7 122.72,45.98 124.21,47.46 v1(124.21,47.72) 124.21,49.68 R3020.2
N135192730: length 5.7
  TOP w0.114: R3014.2 123.5,49.8 v1(123.5,49.32) 123.5,47.13 122.32,45.96 U3001.8
N135192733: length 8.5
  TOP w0.114: v2(122.86,49.66) 123.06,49.86 R3015.2 ; v2(121.64,44.03) 121.92,44.31 U3001.9
  BOTTOM w0.114: v2(121.64,44.03) 122.75,45.14 122.75,45.15 122.74,45.15 v1(122.74,47.34) 122.74,48.39 122.38,48.75 122.38,49.31 122.73,49.66 v2(122.86,49.66)
N135192736: length 8.7
  TOP w0.114: v2(120.96,44.08) 121.11,44.08 121.52,44.5 U3001.10 ; R3016.2 122.2,49.86 122,49.66 v2(121.97,49.66)
  BOTTOM w0.114: v2(120.96,44.08) 120.79,44.25 120.79,45.6 120.29,46.09 120.29,47.26 v1(121.19,48.16) 121.46,48.43 121.46,49.15 v2(121.97,49.66)
N135193082: length 3.7
  TOP w0.178: C3015.2 121.54,47.16 121.25,47.16 120.97,46.89 v2(120.97,46.57) 120.72,46.32 U3001.12
  BOTTOM w0.102: v1(121.42,46.12) v2(120.97,46.57)
N135194518: length 9.2
  TOP w0.114: U3001.6 123.12,46 124.66,47.54 124.66,48.51 124.49,48.68 124.49,49.55 124.77,49.83 125.21,49.83 R3018.2 126.03,50.26 126.31,50.54 126.31,51.88 v1(125.93,52.27)
N135195707: length 5.3
  TOP w0.102: U3001.15 119.52,48.47 119.41,48.58 v1(119.41,48.96) 119.41,49.14 119.66,49.4 119.66,49.92 119.69,49.94 R3069.2
N135532945: length 5.4
  TOP w0.102: R5201.1 256.34,59.66 255.07,58.39 v1(253.8,58.39) 253.11,58.39 252.26,57.53 U5200.16
N135533052: length 5.5
  TOP w0.102: R5200.1 256.11,58.77 v1(255.78,58.44) 255.19,57.85 252.89,57.85 252.58,57.55 252.58,57.24 252.37,57.03 U5200.15
N135533327: length 10.1
  TOP w0.102: U5200.6 249.13,57.03 248.66,57.5 246.52,57.5 246.05,57.03 242.76,57.03 242.26,56.53 241.36,56.53 v1(241.24,56.66) 240.64,57.25 R5202.2
N135533333: length 12.9
  TOP w0.102: R5203.2 v1(238.39,56.74) 238.79,56.34 240.8,56.34 240.92,56.23 242.24,56.23 242.82,56.8 246.14,56.8 246.62,57.29 248.34,57.29 249.1,56.53 U5200.7
N135533339: length 19
  TOP w0.102: v1(232.64,57.68) R5204.2 233.24,56.14 240.72,56.14 240.84,56.02 242.33,56.02 242.87,56.57 246.26,56.57 246.77,57.07 248.13,57.07 248.83,56.37 248.83,56.18 248.97,56.03 U5200.8
N135596235: length 3.4
  TOP w0.102: U3001.33 110.19,43.55 110.01,43.73 110.01,44.42 109.91,44.52 v1(109.45,44.52) R3076.2
N135676971: length 2.9
  TOP w0.203: v2(15.44,67.65) 15.5,67.71 U3600.35
  BOTTOM w0.203: C3603.1 16.16,68.28 v1(15.38,68.28) 15.38,67.71 v2(15.44,67.65)
N135678655: length 3.5
  TOP w0.203: v2(16.55,65.34) 16.73,65.52 17.47,65.52 v1(17.55,65.44) 17.74,65.63 17.74,65.94 17.9,66.11 U3600.39
  BOTTOM w0.203: v2(16.55,65.34) 16.21,65 C3612.1
N135704866: length 6.1
  TOP w0.102: R3622.1 4.55,71.72 v1(4.65,71.82) 4.12,72.36 3.48,72.36 3.37,72.24 Q3601.1 3.37,70.85 3.23,70.71 2.21,70.71 2.07,70.85 Q3601.3
N135705316: length 18
  TOP w0.102: Q3601.6 3.37,69.83 3.56,70.02 R3622.2 4.71,69.86 v1(4.71,68.82) 3.67,67.78 Q3602.1 3.67,66.32 3.35,66.01 2.34,66.01 1.96,65.63 1.96,64.36 2.21,64.1 3.2,64.1 3.63,64.53 8.88,64.53 9.83,65.49 R3604.2
N135714980: length 2
  TOP w0.203: v2(20.52,73.12) 20.73,73.12 21.1,72.74 U3600.14
  BOTTOM w0.254: v2(20.52,73.12) 20.52,73.84 T3602.1
N135717456: length 3.6
  TOP w0.203: C3640.1 17.76,75.25 17.76,74.91 v1(18.07,74.6) 18.3,74.37 U3600.21
N135717474: length 4.1
  TOP w0.203: C3639.1 16.71,74.59 v1(16.7,74.58) 17.33,74.58 17.9,74 U3600.22
N135719021: length 2.3
  TOP w0.203: v1(20.75,76.52) 20.59,76.69 C3607.1 19.23,76.31 R3620.1
N135719044: length 8.4
  TOP w0.203: U3600.20 18.7,73.28 v2(18.81,73.39)
  BOTTOM w0.254: R3621.2 v1(15.09,76.03) 15.09,74.58 16.24,73.42 16.59,73.42 16.78,73.23 16.78,73 17.1,72.68 18.11,72.68 v2(18.81,73.39)
N136259619: length 1.1
  TOP w0.254: v4(244.09,31.46) 244.08,31.46 U1101.J16
  BOTTOM w0.254: C1184.1 243.75,31.46 v4(244.09,31.46)
N136259621: length 1.1
  TOP w0.254: v4(243.39,32.11) 243.39,32.11 243.1,31.82 U1101.L16
  BOTTOM w0.305: C1183.1 243.2,31.92 v4(243.39,32.11)
N136630757: length 12
  TOP w0.254: R2618.1 173.66,65.88 173.33,65.55 172.26,65.55 171.88,65.17 171.88,62.75 172.34,62.29 v1(172.34,62.11) 172.34,58 v2(171.76,57.42)
  BOTTOM w0.254: v2(171.76,57.42) 171.42,57.09 U2000.AD13
N136634176: length 3.6
  TOP w0.102: R1317.2 213.98,48.45 R1321.1 214.68,48.66 v1(213.97,49.37) 214.17,49.57 214.2,49.57 214.91,50.28 U1301.10
N136643265: length 2.5
  TOP w0.102: R1417.1 214.68,34.94 v1(214.25,35.37) 214.02,35.61 U1401.10
N136787184: length 10.8
  BOTTOM w0.102: 242.67,25.93 244.43,25.93 245,25.36 245,24.19 244.64,23.83 244.13,23.83 244,23.7 CON6000.6 ; 242.67,25.93 237.94,25.93 R6003.1 ; 242.67,25.93 v1(242.67,25.67)
N136787191: length 11.4
  BOTTOM w0.102: CON6000.7 246,23.66 245.71,23.95 245.5,23.95 245.26,24.19 245.26,25.41 244.84,25.83 ; v1(245.01,26) 244.84,25.83 ; 244.84,25.83 244.53,26.14 238.99,26.14 R6004.1
N137103573: length 3.9
  TOP w0.102: R2159.1 R2151.2 180.32,69.81 180.06,70.07 180.06,70.38 180.05,70.39 180.05,70.96 180.29,71.2 180.29,71.75 v1(179.73,72.31)
N137103692: length 2.2
  TOP w0.102: v1(178.66,70.81) 179.14,70.33 179.14,70.3 R2153.2 R2158.1
N137103866: length 2.6
  BOTTOM w0.102: R2160.1 182.09,68.37 v1(182.04,68.42) 181.8,68.66 181.8,69.32 R2154.2
N137103874: length 2.7
  BOTTOM w0.102: R2161.1 182.98,68.19 v1(183.36,68.57) 183.03,68.9 183.03,69.66 R2155.2
N137154023: length 17.3
  TOP w0.102: v2(231.96,45.9) 232.31,45.55 v1(232.31,45.33) ; U1101.L4 242.81,37.94 v4(242.77,37.94)
  IN4 w0.102: v4(242.77,37.94) 242.31,38.4 241.42,38.4 240.97,38.85 240.97,39.55 240.86,39.66 240.07,39.66 239.22,40.51 237.65,40.51 237.62,40.48 236.83,40.48 235.13,42.18 235.13,43.11 233.43,44.81 232.39,44.81 231.96,45.24 v2(231.96,45.9)
  BOTTOM w0.102: v2(231.96,45.9) 231.79,46.07 R1150.1
N137261398:
  vias: v1(250.64,80.95)
N137261420: length 4.4
  TOP w0.102: Q4801.2 245.92,77.55 245.86,77.61 R4816.2 245.34,76.4 244.95,76.01 244.58,76.01 v1(244.09,76.5)
N137346808: length 5.2
  BOTTOM w0.102: CON5300.55 249.25,83.73 249.38,83.61 250.65,83.61 251.26,83 T5302.1
N137531212: length 5.2
  TOP w0.102: v1(248.06,92.78) 248.06,93.33 v2(247.48,93.91) 247.27,94.12 R5311.1
  BOTTOM w0.102: v2(247.48,93.91) 246.56,93.91 245.5,92.85 CON5300.40
N137531214: length 4.4
  TOP w0.102: R5310.1 245.55,94.96 v2(245.43,94.84) 245.06,95.2 v1(245.06,95.57)
  BOTTOM w0.102: CON5300.38 245,92.3 245,93.31 245,94.41 v2(245.43,94.84)
N137531216: length 6.3
  TOP w0.102: R5312.1 247.45,93.29 v2(247.47,93.31) 247.47,92.52 247.93,92.07 v1(249.76,92.07)
  BOTTOM w0.102: CON5300.42 246,93.01 246.3,93.31 v2(247.47,93.31)
N137531334: length 15
  BOTTOM w0.102: T5301.1 233.02,86.99 234.65,88.61 235.76,88.61 236.27,89.12 236.27,90.14 237.29,91.15 239.32,91.15 239.5,91.33 CON5300.16
N137827968: length 15.4
  TOP w0.102: v1(171.16,46.72) 171.4,46.72 v2(171.74,46.38) 172.23,45.89 172.23,44.46 172.43,44.26 172.43,41.87 171.65,41.1 171.65,40.09 169.14,37.57 169.14,34.53 R2144.2
  BOTTOM w0.089: U2000.AD35 v2(171.74,46.38)
N137828322: length 21.3
  TOP w0.102: R2143.1 165.61,34.1 R2162.2 165.05,34.59 165.35,34.89 165.35,37.04 165.79,37.48 166.72,37.48 169.04,39.79 169.04,42.64 169.21,42.81 169.55,42.81 169.79,43.05 169.79,48.66 v1(170.01,48.88) 170.65,48.88 171.66,47.87 v2(171.83,47.87)
  BOTTOM w0.089: U2000.AD31 171.56,47.87 v2(171.83,47.87)
N138090086: length 14.5
  BOTTOM w0.102: R7409.2 83.26,120.49 82.86,120.82 Q7401.2 ; R7409.2 84.45,120.49 v1(84.62,120.32) ; R7409.2 83.67,120.95 83.54,121.07 83.54,121.76 83.84,122.06 84,122.21 84.34,122.21 84.81,122.68 87.3,122.68 87.5,122.48 88.79,122.48 89.21,122.9 89.21,123.66 89.43,123.88 92.32,123.88 U7000.BF3
N138090091: length 23.6
  BOTTOM w0.102: U7000.BE3 93.08,123.08 93.08,121.69 92.83,121.44 89.39,121.44 88.67,122.16 87.52,122.16 87.2,122.48 84.89,122.48 84.42,122.01 84.13,122.01 83.85,121.72 83.85,121.39 84.14,121.09 84.46,121.09 85.05,120.5 85.05,120.14 84.8,119.89 84.25,119.89 84.13,120 83.35,120 83.03,119.69 83.03,118.61 R7410.2 82.6,117.97 82.41,117.78 Q7402.2 82.41,115.49 82.62,115.28 v1(83.67,115.28)
N138223875: length 9.4
  TOP w0.203: R2376.2 172.36,38.92 172.6,39.16 173.06,39.16 173.43,39.53 173.43,40.4 173.13,40.7 173.13,44.21 173.69,44.77 v1(173.69,44.98) 173.69,45.72 174.04,46.07 v2(174.15,46.07)
  BOTTOM w0.203: U2000.AJ35 v2(174.15,46.07)
N138223878: length 4.5
  TOP w0.203: R2375.1 172.24,39.34 v1(172.24,39.49) 172.38,39.63 v2(172.88,39.63)
  BOTTOM w0.089: U2000.AH44 172.98,41.44 173.13,41.29 173.13,40.55 173.34,40.34
  BOTTOM w0.203: 173.34,40.34 173.34,39.77 173.19,39.63 v2(172.88,39.63)
N138274096: length 3.4
  BOTTOM w0.102: U2404.1 200.44,46.74 200.08,46.37 v1(199.52,46.37) 198.98,46.37 R2497.2 R2496.1
N138274106: length 2.6
  BOTTOM w0.102: R2498.2 202.11,49.5 v1(202.24,49.37) 202.55,49.06 U2404.4
N138275716: length 12.8
  BOTTOM w0.102: U7000.BB5 95.77,125.1 95.43,125.44 90.05,125.44 88.55,123.94 88.4,123.8 86.07,123.8 R7407.2 84.76,123.33 v1(84.28,122.85)
N138275758: length 8
  BOTTOM w0.102: U7000.BB4 95.9,124.03 94.67,122.79 94.67,121.67 92.46,119.46 v1(92.46,118.79) 92.84,118.41 R7408.2
N138278798: length 12.4
  BOTTOM w0.254: R3163.2 170.93,29.7 171.44,29.19 v1(171.44,28.91) 171.86,28.49 174.6,28.49 175.2,27.9 176.95,27.9 177.24,28.19 179.81,28.19 180.95,29.33 CON3104.3
N138282438: length 3.6
  TOP w0.102: v6(122.58,177) 122.58,177.39 v1(123.24,178.05) 122.85,178.05 122.68,177.87 R7619.1
  BOTTOM w0.102: U7600.J10 122.38,176.67 122.58,176.88 v6(122.58,177)
N138285036: length 2.5
  TOP w0.102: 148.29,163.54 v1(148.29,163.57) ; 148.29,163.54 148.27,163.57 v6(147.63,163.57) ; 148.29,163.54 148.29,163.24 R7719.1
  BOTTOM w0.089: v6(147.63,163.57) 147.25,163.94 U7700.J10
N138285332: length 15.9
  TOP w0.102: v1(250.32,115.89) 250.32,115.23 v2(250.42,115.13) R4610.1
  IN1 w0.102: v2(250.42,115.13) 250.42,114.65 251.97,113.1 259.06,113.1 259.3,112.87 259.78,112.87 260.2,113.28 260.2,115.11 CON4601.14
N138286203: length 2.1
  TOP w0.102: R7819.1 147.24,123.6 v6(147.24,124.02) 147.07,124.19 v1(146.54,124.19)
  BOTTOM w0.089: U7800.J10 v6(147.24,124.02)
N138322414: length 2.1
  TOP w0.102: R7919.1 120.75,106.03 120.67,106.11 v6(120.55,106.11) v1(120.03,105.6)
  BOTTOM w0.102: U7900.J10 120.95,106.52 v6(120.55,106.11)
N138336439: length 35.2
  TOP w0.102: v2(49.84,39.9) 49.84,37.79 47.6,35.55 47.6,33.71 45.03,31.15 v1(45.03,30.54) 44.81,30.32 R5123.2
  IN1 w0.102: v2(66.93,39.21) 65.46,37.74 51.99,37.74 v2(49.84,39.9)
  BOTTOM w0.102: v2(66.93,39.21) 66.93,39.64 66.47,40.1 CON5102.50
N138342270: length 2
  TOP w0.102: U7002.2 97.88,113.04 97.94,113.1 R7002.2 99.03,113.1 v1(99.21,113.28)
N138434716: length 4.9
  TOP w0.102: R5015.2 C5005.1 28.42,112.66 28.35,112.59 v1(27.89,112.59) 27.89,113.76 27.58,114.06 U5001.4
N138434827: length 3.5
  TOP w0.254: U5001.1 26.09,118.38 25.96,118.51 v1(24.36,118.51) 24.36,118.84 R5012.2
N138435027: length 4
  TOP w0.102: U5002.4 185.19,75.58 185.02,75.76 C5006.1 R5016.2 182.8,75.76 v1(182.43,75.39)
N138435047:
  vias: v1(185.27,80.92)
N138566355: length 2.8
  BOTTOM w0.102: v1(105.98,113.79) 105.78,113.59 R7446.2 105.78,112.18 105.97,111.99 Q7404.3
N138569296: length 19.7
  TOP w0.102: v1(95.54,176.44) v2(95.54,177.17)
  IN1 w0.102: v2(95.54,177.17) 95.56,177.17 95.96,177.58 98.89,177.58 101.05,179.74 101.05,182.43 v2(100.25,183.23)
  BOTTOM w0.102: U4301.13 95.39,178.03 95.25,178.17 95.02,178.17 C4308.1 95.09,177.65 95.29,177.65 95.54,177.4 v2(95.54,177.17) ; U4301.1 99.75,180.53 99.87,180.65 99.87,181.45 100.35,181.92 100.8,181.92 R4308.2 100.84,182.47 100.84,182.64 v2(100.25,183.23) 100.25,184.29 C4309.1
N138687814: length 38.7
  TOP w0.102: v2(24.6,172.26) 24.6,172.88 R8039.2 24.36,173.59 24.54,173.77 v1(24.54,174.34)
  IN3 w0.102: v2(24.6,172.26) 24.11,172.75 23.16,172.75 22.62,173.29 15.49,173.29 14.4,174.39 12.24,174.39 8.05,178.58 5.95,178.58 5.49,179.04 5.49,180.65 6.94,182.11 13.62,182.11 14.57,183.06 15.59,183.06 v2(16.11,183.58)
  BOTTOM w0.102: R8031.1 16.11,183.51 v2(16.11,183.58)
N138711426: length 3.9
  BOTTOM w0.102: R8030.1 16.64,182.31 16.64,184.04 C8016.2 16.83,184.89 v1(17.26,184.89)
N138717346: length 2.8
  BOTTOM w0.102: v1(17.92,179.8) 17.77,179.65 16.58,179.65 C8009.2
  BOTTOM w0.203: R8023.1 C8009.2
N138728527: length 2.4
  BOTTOM w0.102: v1(18.68,178.22) 17.89,178.22 C8021.2
  BOTTOM w0.203: C8021.2 17.69,179.01 17.48,179.21 R8037.1
N138728530: length 4.8
  BOTTOM w0.102: v1(20.43,178.27) 19.99,177.83 R8020.2
  BOTTOM w0.203: R8020.2 19.64,177.36 19.28,177.72 17.85,177.72 C8021.1 17.67,177.56 R8015.1
N138743980: length 3.7
  TOP w0.102: v2(24.57,175.27) v1(24.57,176.38)
  BOTTOM w0.102: v2(24.57,175.27) C8036.2
  BOTTOM w0.152: R8040.1 C80110.2 C8036.2
N138751836: length 38.2
  TOP w0.102: v2(1.61,154.45) 1.89,154.45 2.21,154.13 2.21,153.75 2.46,153.51 R8088.1
  IN4 w0.102: v2(12.34,166.24) 12.37,166.27 12.37,168.25 17.42,173.3 19.71,173.3 23.83,177.41 23.83,178.1 23.55,178.38 23.09,178.38 22.66,177.94 v2(22.66,177.93)
  BOTTOM w0.102: v2(1.61,154.45) 3.84,156.68 v1(4.24,156.68) 4.24,157.07 6.15,158.97 6.15,160.05 v2(12.34,166.24)
  BOTTOM w0.152: R8094.2 v2(22.66,177.93)
N138766947: length 4.2
  BOTTOM w0.102: R8043.2 26.51,174.27 26.51,172.7 26.08,172.28 25.87,172.28 v1(25.63,172.04)
  BOTTOM w0.152: C8034.2 26.14,175.1 26.09,175.05 R8043.2
N138776862: length 2.9
  BOTTOM w0.102: C8031.2 17.07,169.77 v1(16.66,169.36) 15.85,169.36 15.55,169.66 R8096.1
N138776940: length 25.1
  TOP w0.102: v1(35.87,175.18) 35.65,175.18 v2(35.29,175.53) 35.27,175.56 35.27,176.31 R8084.2
  IN4 w0.102: v2(35.29,175.53) 34.6,176.22 33.21,176.22 30.73,178.71 19.24,178.71 17.88,177.35 17.88,175.55 v2(16.97,174.64)
  BOTTOM w0.102: R8081.1 16.94,174.34 16.97,174.36 v2(16.97,174.64)
N138776976: length 2.3
  TOP w0.152: C8024.2 10.97,176.47 v1(10.97,176.47) 11.03,176.42 R8049.1
N138776978: length 3
  TOP w0.102: v1(10.44,174.57) 10.03,174.98 C8024.1
  TOP w0.152: R8004.2 C8024.1 10.39,175.61 10.47,175.53 R80100.1
N138777029: length 2.1
  TOP w0.152: C8033.2 11.99,178.15 v1(11.84,178) 12.53,177.31 R8080.1
N138809198: length 1.9
  BOTTOM w0.102: C8018.2 10.72,170.53 10.64,170.45 R80102.1 11.53,170.12 v1(11.63,170.02)
N138810104: length 48.5
  TOP w0.102: v1(6.52,173.47) 6.04,173.47 v2(5.74,173.17) ; R8082.2 48.61,170.76 48.48,170.89 48.48,171.92 48.61,172.05 v2(48.64,172.05)
  IN1 w0.102: v2(5.74,173.17) 6.05,173.17 6.71,172.51 13.89,172.51 14.56,173.18 34.91,173.18 35.26,173.52 41.96,173.52 44.48,171.01 47.85,171.01 48.64,171.8 v2(48.64,172.05)
  BOTTOM w0.102: v2(5.74,173.17) 5.74,172.76 R80101.1
N138810209: length 3.1
  BOTTOM w0.102: R8097.2 2.59,171.77 2.59,172.28 v1(2.74,172.43) 2.82,172.35 C80133.1 C80109.1
N138844949: length 2.2
  BOTTOM w0.203: v1(2.46,174.44) 2.46,174.97 C8012.1 3.37,175.53 3.39,175.55 R8093.2
N138848079: length 5.1
  TOP w0.102: C8008.1 3.02,179.82 2.77,180.08 v1(2.77,180.79) 4.12,180.79 4.88,180.03 R8047.2
N138852434: length 2.2
  TOP w0.203: v1(117.92,72.2) 117.92,73 R8740.2 118.32,73.12 118.57,72.87 U8702.5
N138852479: length 4.3
  TOP w0.203: R8731.1 127.46,70.75 127.98,70.23 R8730.2 127.47,70.13 126.67,69.33 v1(126.67,68.09)
N138852481: length 2.3
  TOP w0.203: R8730.3 127.41,71.88 127.17,71.64 R8732.1 126.85,72.22 v1(126.48,72.59)
N138852483: length 2.8
  TOP w0.203: R8733.2 126.89,74.4 v1(126.47,74.4) 126.1,74.4 R8734.1
N138853955: length 9
  BOTTOM w0.254: D8802.2 218.62,39.08 219.05,38.65 R8819.1 220.14,37.68 220.65,37.17 220.65,36.12 220.29,35.77 U8801.4 219.32,35.77 219.02,35.47 217.72,35.47 v1(217.35,35.1)
N138853957: length 13.5
  BOTTOM w0.254: Q8806.1 220.33,46.13 219.84,45.63 219.26,45.63 218.35,44.72 C8828.1 217.35,44.42 217.14,44.21 v1(217.14,43.53) 217.14,42.79 217.39,42.54 D8802.1 218.62,42.04 220.14,40.52 R8819.2 C8829.1 221.26,39.74 Q8807.1
N138853973: length 7.4
  BOTTOM w0.102: v1(221.26,31.54) 221.26,32.96 C8832.1
  BOTTOM w0.254: R8820.1 R8818.2 C8832.1 222.43,34.13 222.43,35.4 222.06,35.77 U8801.3
N138854040: length 7.4
  BOTTOM w0.102: T8812.1 219.68,53.52 R8822.1 219.68,52.12 219.62,52.05 218.27,52.05 217.65,51.44 217.65,50.43 218.29,49.79 218.66,49.79 219.38,49.07 Q8806.3
N138861884: length 2.2
  TOP w0.102: v1(4.29,179.82) 3.99,179.52 R8079.2 3.45,178.88 C8007.1
N138861972: length 2.8
  TOP w0.102: v1(1.52,176.6) 1.96,176.6 2.03,176.67 R8048.1 2.41,177.23 2.16,177.49 R8099.2 C8007.2
N138873252: length 2.8
  BOTTOM w0.102: C80106.2 3.14,178.56 2.88,178.82 v1(2.88,179.65) 2.99,179.75 R8036.1
N138873268: length 79.1
  TOP w0.102: v1(7.81,180.62) 7.81,181.34 v2(7.65,181.5) R8024.1
  IN1 w0.102: v2(7.65,181.5) 7.74,181.59 13.95,181.59 15.7,179.84 18.95,179.84 20.34,178.45 35.22,178.45 36.01,177.66 71.9,177.66 74.24,180 74.52,180 74.85,179.67 74.85,179.22 73.3,177.67 73.3,173.64 v2(73.26,173.6)
  BOTTOM w0.102: R8026.2 73.26,173.27 v2(73.26,173.6)
N138873283: length 3.7
  TOP w0.102: C80111.1 C80103.1 4.42,183.28 4.5,183.2 R80124.2 4.88,183.85 v1(5.8,184.77)
N138947971: length 2.3
  BOTTOM w0.102: C8054.1 43.09,173.08 v1(43.68,173.08)
  BOTTOM w0.457: R8050.1 C8054.1
N138948723: length 3.1
  TOP w0.102: v1(42.08,176.28) 42.73,175.63 v2(42.73,175.53)
  TOP w0.305: U8001.5 v2(42.73,175.53)
  BOTTOM w0.457: v2(42.73,175.53) 42.73,175.4 42.72,175.4 C8054.2
N138948726: length 4.8
  TOP w0.279: U8001.7 41.73,175.17 42.09,175.53 v2(42.09,175.53)
  BOTTOM w0.102: v1(41.7,172.52) 41.04,173.18 41.04,173.87 41.48,174.31 R8050.2
  BOTTOM w0.457: R8050.2 41.58,175.02 v2(42.09,175.53)
N138949600: length 48
  TOP w0.152: JP8050.1 v2(44.5,165.5)
  IN1 w0.152: v2(44.5,165.5) 43.92,165.5 43.74,165.68 43.74,167.93 39.6,172.07 33.23,172.07 32.86,172.44 25.68,172.44 24.17,170.93 13.97,170.93 11.74,168.7 11.74,167.4 v2(11.61,167.27)
  BOTTOM w0.102: R8056.2 13.74,169.71 v1(13.74,169.28) 13.74,168.7 12.32,167.27 v2(11.61,167.27) 11.1,167.27 10.64,167.73 R80125.2
N138949602: length 47.3
  TOP w0.152: JP8051.1 v2(42.72,165.5)
  IN1 w0.152: v2(9.45,167.65) 10.69,167.65 11.07,167.28 11.07,167 11.23,166.84 11.91,166.84 12.09,167.02 12.09,168.7 14.07,170.68 24.28,170.68 25.78,172.19 32.73,172.19 33.1,171.81 39.49,171.81 43.49,167.82 43.49,165.7 43.28,165.5 v2(42.72,165.5)
  BOTTOM w0.102: v2(9.45,167.65) 9.7,167.91 9.96,167.91 10.21,168.16 10.21,169.18 10.31,169.28 R8057.2 10.93,169.28 v1(11.91,168.29)
N138949618:
  vias: v1(44.58,171.37)
N138973068: length 42.1
  TOP w0.152: v2(32.18,166) 31.69,166 JP8052.1
  IN1 w0.152: v2(32.18,166) 32.74,166 32.94,166.21 32.94,167.84 29.4,171.39 26.01,171.39 24.41,169.79 17.93,169.79 13.7,165.55 7.69,165.55 6.27,166.97 6.27,169.51 5.85,169.94 v2(5.6,169.94)
  BOTTOM w0.102: v1(5.03,167.33) 4.5,167.86 R8058.2 4.93,168.8 5.61,168.8 5.75,168.95 5.75,169.79 v2(5.6,169.94) 5.73,170.07 R80130.2
N138973117: length 2.1
  BOTTOM w0.102: C8055.1 31.8,173.02 v1(31.57,172.79)
  BOTTOM w0.457: R8051.1 C8055.1
N138973148: length 3.4
  TOP w0.305: v2(31.82,175.61) 31.81,175.59 U8002.5
  BOTTOM w0.102: v1(32.99,173.8) 32.72,173.8 31.96,174.56 C8055.2
  BOTTOM w0.457: C8055.2 31.8,175.58 31.78,175.61 v2(31.82,175.61)
N138973150: length 3.3
  TOP w0.279: U8002.7 30.81,175.24 v2(31.17,175.61)
  BOTTOM w0.102: v1(29.69,174.79) 30.26,174.79 30.48,174.56 R8051.2
  BOTTOM w0.457: v2(31.17,175.61) 31.17,175.6 31.17,175.17 30.66,174.67 R8051.2
N138973254: length 42
  IN1 w0.152: v2(34.09,166.13) 33.44,166.13 33.2,166.37 33.2,167.95 29.51,171.64 25.9,171.64 24.3,170.04 17.83,170.04 13.59,165.81 7.83,165.81 6.53,167.11 6.53,169.63 5.78,170.37 5.42,170.37 4.33,169.28 3.56,169.28 v2(3.47,169.19)
  BOTTOM w0.102: v1(3.4,167.96) 3.4,168.42 R8059.2 3.2,168.92 v2(3.47,169.19)
N138973270:
  vias: v1(30.89,169.18)
N138993706: length 79.1
  TOP w0.203: JP8054.1 v2(63.42,159.4)
  IN1 w0.152: v2(63.42,159.4) 62.61,158.59 62.28,158.59 61.8,159.07 61.8,161.49 60.87,162.42 58.67,162.42 56.92,164.18 52.4,164.18 50.47,166.11 50.47,167.94 48.44,169.97 42.95,169.97 40.31,172.6 33.93,172.6 33.59,172.95 14.66,172.95 13.73,172.02 6.36,172.02 4.34,170.01 v2(4.08,170.01)
  BOTTOM w0.102: R80135.2 R8060.2 5.61,168.09 5.61,166.26 4.93,165.58 v1(4.59,165.58) 4.59,166.86 3.91,167.53 3.91,169.85 v2(4.08,170.01)
N138993779: length 2.2
  BOTTOM w0.102: C8060.1 66.07,169.02 v1(66.87,169.02)
  BOTTOM w0.457: R8052.1 C8060.1
N138993809: length 2.6
  TOP w0.305: U8003.5 v2(65.71,171.19)
  BOTTOM w0.102: v1(66.53,171.31) 66.4,171.19 v2(65.71,171.19)
  BOTTOM w0.457: v2(65.71,171.19) 65.71,171.21 65.71,171.21 C8060.2
N138993811: length 4
  TOP w0.305: U8003.7 v2(64.71,171.21)
  BOTTOM w0.102: v1(63.81,168.5) 64.06,168.75 64.06,169.64 64.67,170.25 R8052.2
  BOTTOM w0.457: R8052.2 64.82,171.1 v2(64.71,171.21)
N138993926: length 72.4
  TOP w0.203: JP8055.1 v2(63.17,157.37)
  IN1 w0.152: v2(63.17,157.37) 63.17,158.08 62.96,158.3 62.19,158.3 61.54,158.95 61.54,161.38 60.76,162.17 58.57,162.17 56.86,163.87 52.34,163.87 50.22,166 50.22,167.81 48.36,169.67 42.89,169.67 40.21,172.35 33.31,172.35 32.96,172.69 14.76,172.69 13.84,171.77 6.46,171.77 4.23,169.53 3.92,169.53 v2(3.47,169.98)
  BOTTOM w0.102: v1(63.6,157.9) 63.6,157.8 v2(63.17,157.37) ; v2(3.47,169.98) 3.3,169.81 R8061.2
N138993942:
  vias: v1(62.05,163.57)
N139012019: length 4.2
  BOTTOM w0.102: CON3104.10 177.45,30.2 176.82,30.83 176.36,30.83 176.3,30.88 176.3,31.08 176.18,31.21 R3151.1 174.93,31.21 174.6,31.54 v1(174.6,31.84)
N139012023: length 2.3
  BOTTOM w0.102: CON3104.9 177.95,30.3 177.8,30.44 177.49,30.44 177.34,30.59 177.34,30.95 177.09,31.21 R3150.1
N139012387: length 24.4
  TOP w0.152: v2(8.23,156.63) 7.44,155.84 JP8058.1
  BOTTOM w0.152: R80140.2 18.47,172.56 18.52,172.51 R8062.2 18.85,171.77 18.85,169.84 14.58,165.57 12.38,165.57 8.74,161.93 8.74,160.29 ; 8.74,160.29 8.74,159.64 8.05,158.95 8.05,157.09 8.23,156.91 v2(8.23,156.63) ; 8.74,160.29 v1(8.48,160.29)
N139012436: length 2.5
  BOTTOM w0.102: R8071.1 7.34,165.24 7.34,164.69 v1(7.85,164.18)
  BOTTOM w0.457: R8071.1 C80052.1
N139012467: length 3.3
  TOP w0.305: U8006.5 8.44,166.99 v2(8.22,167.2)
  BOTTOM w0.102: C80052.2 9.27,165.47 v1(9.5,165.47)
  BOTTOM w0.457: C80052.2 8.56,166.57 8.22,166.9 v2(8.22,167.2)
N139012469: length 4.5
  TOP w0.305: U8006.7 7.44,167.28 v2(7.84,167.68)
  BOTTOM w0.102: R8071.2 6.76,165.52 v1(6.35,165.52)
  BOTTOM w0.457: v2(7.84,167.68) 7.42,167.26 R8071.2
N139012573: length 25.2
  TOP w0.152: JP8057.1 8.61,155.59 v2(8.23,155.97)
  BOTTOM w0.152: v2(8.23,155.97) 8.66,156.41 8.66,156.84 8.31,157.19 8.31,157.78 ; 8.31,157.78 v1(8.56,157.78) ; 8.31,157.78 8.31,158.82 8.99,159.5 8.99,161.83 12.48,165.32 14.69,165.32 19.1,169.73 19.1,172.73 R8064.2
N139012589:
  vias: v1(1.45,157.16)
N139027518: length 24
  TOP w0.152: JP8059.1 23.04,161.81 v2(23.55,161.3)
  BOTTOM w0.152: v2(23.55,161.3) 23.55,166.46 v1(23.8,166.72) 23.55,166.97 23.55,169.27 26.74,172.46 26.74,177.62 25.73,178.63 24.66,178.63 24.31,178.27 R80145.2 R8063.2
N139027567: length 2
  BOTTOM w0.457: R8065.1 C80042.1 v1(21.95,170.4)
N139027598: length 3.8
  TOP w0.102: v2(20.93,172.22) 20.88,172.27 v1(20.88,174.21)
  TOP w0.305: v2(20.93,172.22) 20.9,172.22 20.92,172.2 20.93,172.2 20.88,172.16 U8004.5
  BOTTOM w0.457: v2(20.93,172.22) 20.93,171.87 20.88,171.82 C80042.2
N139027600: length 2.5
  TOP w0.089: 19.61,172.55 19.61,172.52 v2(19.91,172.22)
  TOP w0.102: 19.61,172.55 v1(19.61,172.86)
  TOP w0.279: U8004.7 19.88,172.19 v2(19.91,172.22)
  BOTTOM w0.457: v2(19.91,172.22) 19.99,172.13 R8065.2
N139027694: length 14.8
  TOP w0.152: JP8060.1 23.04,161.18 v2(22.91,161.3)
  BOTTOM w0.152: v2(22.91,161.3) 23.24,161.64 23.24,168.17 v1(23.04,168.37) 23.24,168.57 23.24,169.38 25.15,171.29 R8066.2
N139027720:
  vias: v1(20.19,165.91)
N139084693:
  vias: v1(68.12,170.5)
N139090790: length 92.5
  TOP w0.102: R8067.2 v1(4.04,185.26) 6.25,185.26 6.4,185.11 6.4,184.5 6.11,184.21 v2(6.11,183.52)
  IN1 w0.102: v2(77.01,169.05) 75.63,169.05 75.25,169.43 75.25,174.2 73.94,175.51 73.94,177.33 75.49,178.89 75.49,179.96 74.42,181.03 62.75,181.03 60.01,178.28 37.25,178.28 36.27,179.26 20.72,179.26 19.39,180.6 15.8,180.6 13.4,183 6.63,183 v2(6.11,183.52)
  BOTTOM w0.102: JP8056.1 v2(77.01,169.05)
N139090792: length 90.2
  TOP w0.102: v1(7.42,184.06) 7,184.06 6.73,183.79 6.73,182.54 R8069.2 6.41,182.55 6.41,182.78 6.1,183.09 5.91,183.09 v2(5.49,183.52)
  IN1 w0.102: v2(74.98,168.92) 74.98,174.15 73.73,175.4 73.73,177.47 75.28,179.01 75.28,179.86 74.31,180.83 62.91,180.83 60.15,178.06 37.09,178.06 36.15,179.01 20.69,179.01 19.36,180.34 15.77,180.34 13.32,182.79 6.21,182.79 v2(5.49,183.52)
  BOTTOM w0.102: JP8061.1 v2(74.98,168.92)
N139090834: length 1.2
  BOTTOM w0.102: C80041.1 v1(89.99,169.6)
N139235634: length 4.3
  TOP w0.102: U5200.9 v1(250,54.29) 249.35,54.94 249.35,55.22 248.09,56.48 R5208.2
N139244830: length 208.5
  IN2 w0.102: v2(71.15,45.95) 70.71,45.52 68.13,45.52 67.53,46.12 60.83,46.12 60.03,46.92 49.45,46.92 47.35,49.02 47.35,50.07 46.42,51 43.79,51 42.11,52.67 40.04,52.67 34.16,58.55 34.16,61.84 33.17,62.83 32.47,62.83 29.95,65.35 29.95,68.23 27.46,70.72 27.46,81.87 19.25,90.08 19.25,119.35 16.61,121.99 16.61,122.85 15.15,124.31 15.15,130.65 17.63,133.13 17.63,137.43 18.08,137.88 18.08,143.08 16.59,144.57 16.59,146.33 17.65,147.4 17.65,151.82 24.16,158.32 24.16,166.75 23.53,167.38 23.53,169.74 26.28,172.49 26.28,175.7 27.42,176.84 32.15,176.84 32.53,177.21 34.74,177.21 36.05,178.53 38.48,178.53 39.19,179.24 39.19,179.87 39.54,180.21 40.23,180.21 40.43,180.42 43.35,180.42 43.56,180.2 v2(43.56,179.77)
  BOTTOM w0.102: R5126.2 45.97,176.17 44.68,177.46 44.68,178.12 43.56,179.24 v2(43.56,179.77) ; v2(71.15,45.95) 70.84,46.26 v1(70.84,46.63) 69.77,47.69 69.19,47.69 66.78,50.1 CON5102.10
N139245224: length 24.9
  TOP w0.102: v2(60.66,43.2) 60.22,42.77 60.22,39.31 60.31,39.23 60.31,32.11 v1(58.67,30.47) 58.6,30.39 57.66,30.39 56.62,29.36 R5106.2
  IN2 w0.102: v2(66.42,43.2) v2(60.66,43.2)
  BOTTOM w0.102: CON5102.38 66.32,43.1 v2(66.42,43.2)
N139245248: length 31.5
  TOP w0.102: R5122.2 46.14,27.86 46.14,30.15 v1(46.88,30.89) 48.75,32.76 48.75,35.64 52.5,39.39 v2(52.5,39.88)
  IN1 w0.102: v2(52.5,39.88) 54.44,37.94 65.05,37.94 v2(66.32,39.21)
  BOTTOM w0.102: CON5102.52 66.12,39.6 66.32,39.4 v2(66.32,39.21)
N139696030: length 143
  TOP w0.102: v2(183.95,41.5) 183.72,41.27 v1(183.72,40.86) ; R3079.1 121.11,27.63 120.57,28.16 120.18,28.16 119.92,28.42 U3001.83 119.92,30.33 118.84,31.41 v2(118.42,31.41) ; v2(229.67,53.37) 229.67,53.54 229.88,53.74 R3077.1
  IN1 w0.102: v2(118.42,31.41) 119.2,31.41 119.87,30.74 129.59,30.74 130.44,31.59 145.47,31.59 146.24,32.36 147.36,32.36 147.42,32.3 150.91,32.3 151.87,33.26 174.44,33.26 174.83,33.66 177.23,33.66 177.65,34.07 182.85,34.07 183.12,34.34 183.12,36.6 184.28,37.76 184.28,38.11 184.04,38.35 183.7,38.35 183.6,38.24 182.92,38.24 182.45,38.72 182.45,39.57 183.15,40.27 183.15,40.7 v2(183.95,41.5)
  IN2 w0.102: v2(229.67,53.37) 229.58,53.37 228.9,52.7 225.47,52.7 225.47,52.7 225.27,52.7 219.44,46.87 219.44,45.14 218.98,44.68 218.98,39.97 v2(219.23,39.72)
  IN4 w0.102: v2(219.23,39.72) 219.23,40.86 216.97,43.12 211.74,43.12 210.49,41.88 204.74,41.88 204.13,42.49 200.72,42.49 199.14,40.92 191.89,40.92 191.31,41.5 v2(183.95,41.5)
N139696058: length 4.5
  TOP w0.102: U3001.82 119.52,28.49 119.41,28.38 118.84,28.38 v1(118.35,27.9) 118.88,27.37 R3092.1 R3080.1
N139696517: length 5.4
  TOP w0.102: R3156.1 195.63,29.1 195.51,29.22 195.51,31.11 v1(195.06,31.56) 195.38,31.87 U3101.5
N139696523: length 9.3
  TOP w0.102: R3157.1 193.72,30.45 v1(193.72,30.45) 193.72,31.55 194.74,32.58 194.74,34.64 195,34.89 196.37,34.89 196.65,34.61 U3101.6
N139703251: length 30.8
  IN3 w0.102: v2(172.85,31.06) 173.46,31.67 174.44,31.67 174.86,31.25 181.88,31.25 182.79,32.16 182.79,32.61 183.48,33.3 189.81,33.3 v2(190.09,33.01)
  BOTTOM w0.102: v2(190.09,33.01) 189.59,33.52 v1(189.59,37.58) 191.08,39.08 Q3107.3 ; CON3104.13 175.95,30.29 175.83,30.41 173.06,30.41 172.85,30.62 v2(172.85,31.06)
N139978690: length 16.5
  TOP w0.076: U1201.F10 241.73,53.45 241.73,54.37 241.73,54.37
  TOP w0.102: 241.73,54.37 241.73,54.84 240.64,55.94 232.34,55.94 232.23,56.05 R1223.2 R1239.2 230.73,57.34 230.45,57.62 v1(228.89,57.62)
N139982576: length 9.8
  TOP w0.076: U1201.E4 241.49,49.81 241.36,49.68 v4(241.36,49.7)
  TOP w0.102: R1225.2 237.98,49.45 v2(238.14,49.45)
  BOTTOM w0.102: v4(241.36,49.7) 240.96,49.3 238.29,49.3 v2(238.14,49.45) 237.82,49.12 234.15,49.12 v1(233.53,49.74)
N139982579: length 10.7
  TOP w0.076: U1201.D5 240.99,50.28 241.04,50.23 v4(241.04,50.09)
  TOP w0.102: v2(237.97,50.46) 237.97,50.31 R1224.2
  BOTTOM w0.102: v4(241.04,50.09) 240.98,50.03 239.62,50.03 239.09,50.56 238.07,50.56 v2(237.97,50.46) 237.89,50.55 232.28,50.55 v1(232.1,50.37)
N139982678: length 6.2
  TOP w0.076: 241.23,48.51 241.23,49.05 241.38,49.2 U1201.E2 U1201.F2
  TOP w0.102: 241.23,48.51 241.23,47.73 241.07,47.56 240.48,47.56 239.75,46.83 v1(238.53,46.83) 238.4,46.7 R1226.2
N140034678: length 3.9
  TOP w0.508: C4638.1 259.51,110.46 261.04,111.98
  vias: v1(255.47,108.7)
N140129525: length 5.7
  TOP w0.102: v1(145.82,26.74) 145.67,26.59 R3138.1 145.29,25.75 142.93,23.39 U3102.26
N140129527: length 6.8
  TOP w0.102: v1(145.8,21.72) 145.58,21.51 143.76,21.51 143.58,21.69 U3102.27 143.58,23.35 145.09,24.86 R3139.1
N140129538: length 4.6
  TOP w0.254: v1(146.96,23.03) 146.13,23.03 145.67,23.49 R3149.2 144.75,23.97 144.23,23.45 U3102.28
N140129583: length 3.2
  TOP w0.102: U3102.1 144.23,30.07 v1(144.73,30.57) 145.54,30.57 R3140.2
N140177504: length 348.1
  IN2 w0.102: v2(26.21,43.2) 25.81,42.79 25.81,40.13 26.66,39.27 27.8,39.27 28.75,40.23 28.75,41.2 29.03,41.48 29.03,41.7 30.02,42.69 34.3,42.69 37.52,39.47 37.52,38.47 40.52,35.47 48.69,35.47 49.6,36.38 97.06,36.38 97.8,35.64 101.29,35.64 101.98,34.94 106.63,34.94 106.68,34.99 114.81,34.99 115.62,34.19 115.62,33.76 115.85,33.52 116.19,33.52 116.61,33.94 116.61,33.96 116.96,34.32 124.58,34.32 125.92,35.65 134.58,35.65 136.83,33.41 137.97,33.41 138.84,34.27 140.57,34.27 140.92,33.93 143.5,33.93 143.88,34.3 147.92,34.3 149.26,35.64 151.18,35.64 152.54,34.28 166.17,34.28 167.36,33.09 167.36,31.88 167.61,31.63 167.95,31.63 168.47,32.15 172.99,32.15 173.24,31.9 174.38,31.9 175.02,31.26 176.53,31.26 177.55,30.24 190.13,30.24 190.92,31.03 194.31,31.03 196.37,33.09 200.77,33.09 201.35,33.67 202.4,33.67 203.1,34.37 204.84,34.37 205.55,35.08 207.98,35.08 208.32,35.08 209.54,36.3 209.54,39.33 210.27,40.06 210.27,40.96 211.21,41.9 211.52,42.21 211.52,45.57 212.32,46.37 212.32,47.66 213.92,49.26 213.92,49.65 216.79,52.52 216.79,56.69 218.56,58.46 218.56,60.22 218.47,60.31 218.47,60.97 219.38,61.88 219.38,69.23 219.33,69.28 219.33,70.11 218.1,71.34 216.88,71.34 216.3,70.76 215.96,70.76 214.51,72.21 214.51,75.99 214.66,76.14 214.66,79.67 213.82,80.51 213.82,83.01 216.27,85.46 218.11,85.46 218.75,86.1 227.69,86.1 228.74,87.15 228.74,88.05 230.99,90.3 233.81,90.3 234.05,90.06 234.05,89.53 235.37,88.21 235.37,87.66 235.91,87.12 240.63,87.12 243.05,84.7 245.08,84.7 248.77,81.02 249.14,81.02 250.64,79.52 250.64,69.61 v2(252.17,68.09)
  BOTTOM w0.102: CON6003.2 CON6003.1 29.16,58.05 29.87,58.05 30.53,57.4 30.53,55.7 32.92,53.31 32.92,49.14 29.85,46.07 29.85,45.51 28.09,43.76 26.8,43.76 26.24,43.2 v2(26.21,43.2) ; v2(252.17,68.09) 252.17,66.95 252.49,66.62 Q6001.2 253.93,66.62 254.52,67.21 R6005.1 254.52,69.15 v1(254.56,69.18)
