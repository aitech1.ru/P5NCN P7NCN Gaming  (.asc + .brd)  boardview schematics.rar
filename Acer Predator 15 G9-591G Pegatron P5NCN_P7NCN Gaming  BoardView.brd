# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CK_100M_85OHM_CPUXDP: length 8.5
  BOTTOM w0.102: 164.51,63.52 164.58,63.45 164.58,62.52 U2000.L2
  BOTTOM w0.114: 163.67,67.37 163.12,67.91 R2507.1 ; 163.67,67.37 163.72,67.31 163.72,64.31 164.51,63.52 ; 163.67,67.37 v1(163.47,67.18)
CK_100M_85OHM_CPUXDP#: length 8.5
  BOTTOM w0.102: U2000.L1 164.79,62.83 164.79,63.55 164.69,63.65 164.69,63.68 164.68,63.68
  BOTTOM w0.114: R2508.1 164.01,69.44 163.96,69.39 163.41,69.39 163.35,69.33 163.35,68.77 ; 164.68,63.68 163.96,64.41 163.96,67.41 163.35,68.01 163.35,68.77 ; v1(163.58,68.77) 163.35,68.77
CK_100M_85OHM_PCIE: length 10
  BOTTOM w0.102: U2000.J2 163.5,62.39 163.5,63.18
  BOTTOM w0.114: 162.17,67.7 162.17,68.96 161.34,69.79 R2510.1 ; 162.17,67.7 162.17,66.72 162.68,66.21 162.68,64.38 163.5,63.56 163.5,63.18 ; 162.17,67.7 v1(161.95,67.7)
CK_100M_85OHM_PCIE#: length 10
  BOTTOM w0.114: R2511.1 162.23,70.6 162.18,70.55 161.67,70.55 161.58,70.46 161.58,69.89 161.8,69.66 ; U2000.J1 163.75,62.79 163.75,63.64 162.92,64.48 162.92,66.31 162.41,66.82 162.41,69.05 161.8,69.66 ; 161.8,69.66 v1(161.96,69.82)
CK_100M_BCK: length 185.8
  IN4 w0.089: v2(63.46,146.93) 63.68,146.71 63.68,146.42 62.27,145.02 62.27,143.29 62.54,143.02 64.21,143.02 64.89,142.34 66.37,142.34 67.05,143.02 69.92,143.02 71.2,141.75 71.2,140.71 71.91,140 73.66,140 74.93,141.27 76.94,141.27 79.76,138.45 79.76,124.05 84.03,119.78 84.03,113.42 106.53,90.92 106.53,84.32 108.52,82.33 108.52,79.87 109.7,78.68 109.7,76.13 108.74,75.16 108.74,57.54 110.36,55.92 111.59,55.92 112.46,55.05 113.68,55.05 114.83,56.2 118.64,56.2 119.72,57.28 130.01,57.28 131.83,59.1 140.27,59.1 142.68,61.51 146.69,61.51 150.36,65.19 154.65,65.19 155.06,65.6 155.06,69.66 157.2,71.8 159.62,71.8 160.1,71.32 160.1,71.16 159.82,70.88 v2(159.77,70.88)
  BOTTOM w0.076: U0300.B31 62.18,147.51 62.33,147.36 63.4,147.36 63.46,147.3 v2(63.46,146.93)
  BOTTOM w0.114: R2500.2 159.94,70.3 159.94,70.75 159.82,70.88 v2(159.77,70.88)
CK_100M_BCK#: length 185.8
  IN4 w0.089: v2(64.08,146.95) 63.86,146.73 63.86,146.35 62.45,144.94 62.45,143.36 62.61,143.2 64.29,143.2 64.97,142.52 66.29,142.52 66.97,143.2 70,143.2 71.37,141.83 71.37,140.78 71.98,140.17 73.58,140.17 74.85,141.44 77.01,141.44 79.93,138.52 79.93,124.12 84.2,119.85 84.2,113.49 106.71,90.99 106.71,84.4 108.7,82.41 108.7,79.94 109.88,78.76 109.88,76.05 108.92,75.09 108.92,57.62 110.44,56.1 111.66,56.1 112.53,55.22 113.6,55.22 114.75,56.38 118.56,56.38 119.64,57.46 129.93,57.46 131.75,59.28 140.2,59.28 142.61,61.69 146.61,61.69 150.29,65.36 154.58,65.36 154.89,65.67 154.89,69.74 157.13,71.98 159.69,71.98 160.27,71.39 160.27,71.06 v7(160.45,70.88)
  BOTTOM w0.076: U0300.A32 62.22,147.71 62.4,147.53 63.51,147.53 63.69,147.35 v2(64.08,146.95)
  BOTTOM w0.114: R2501.2 160.18,70.19 160.18,70.61 v7(160.45,70.88)
CK_100M_CPUXDP: length 248.6
  IN4 w0.089: v7(163.09,72.7) 163.09,72.7 163.35,72.44 163.35,68.7 161.43,66.78 158.18,66.78 150.95,59.56 142.34,59.56 139.32,56.53 131.93,56.53 131.24,55.85 120.07,55.85 119.15,54.93 116.83,54.93 115.78,53.89 109.45,53.89 107.62,55.72 107.62,75.63 108.59,76.59 108.59,78.02 107.35,79.26 107.35,81.74 105.41,83.68 105.41,90.45 82.84,113.02 82.84,119.36 78.61,123.59 78.61,137.79 77.75,138.65 74.83,138.65 73.56,137.38 68.49,137.38 63.23,132.12 59.89,132.12 59.54,131.77 58.88,131.77 58.73,131.92 58.73,133.04 57.5,134.26 56.9,134.26 56.44,133.8 25.91,133.8 25.02,134.69 24.28,134.69 23.67,135.3 23.24,135.3 22.88,135.65 21.49,135.65 21.08,135.24 19.05,135.24 14.55,130.74 8.81,130.74 8.32,131.23 6.48,131.23 6.43,131.28 6.43,131.4 v2(6.68,131.66)
  BOTTOM w0.114: v2(6.68,131.66) 6.11,132.22 5.56,132.22 5.04,131.7 4.72,131.7 4.56,131.85 XDP4400.40 ; v7(163.09,72.7) 163.35,72.45 163.35,71.97 163.44,71.88 163.44,71 R2507.2
CK_100M_CPUXDP#: length 248.8
  IN4 w0.089: v2(6.07,131.63) 6.25,131.45 6.25,131.21 6.41,131.05 8.25,131.05 8.74,130.57 14.63,130.57 19.13,135.07 21.16,135.07 21.56,135.47 22.81,135.47 23.16,135.12 23.6,135.12 24.21,134.51 24.95,134.51 25.83,133.62 56.51,133.62 56.97,134.08 57.43,134.08 58.55,132.96 58.55,131.85 58.8,131.59 59.62,131.59 59.97,131.94 63.31,131.94 68.57,137.2 73.63,137.2 74.9,138.47 77.68,138.47 78.44,137.71 78.44,123.51 82.66,119.29 82.66,112.95 105.23,90.38 105.23,83.6 107.17,81.67 107.17,79.19 108.41,77.95 108.41,76.67 107.44,75.7 107.44,55.65 109.38,53.71 115.86,53.71 116.9,54.75 119.23,54.75 120.14,55.67 131.32,55.67 132,56.35 139.39,56.35 142.41,59.38 151.02,59.38 158.25,66.61 161.51,66.61 163.53,68.63 163.53,72.45 v2(163.78,72.7)
  BOTTOM w0.114: v2(6.07,131.63) 6.07,131.93 6.02,131.99 5.66,131.99 5.13,131.46 4.67,131.46 4.56,131.35 XDP4400.42 ; 163.68,71.59 163.68,71.01 R2508.2 ; 163.68,71.59 v1(163.91,71.59) ; 163.68,71.59 163.68,71.98 163.59,72.06 163.59,72.51 v2(163.78,72.7)
CK_100M_LAN: length 76.1
  TOP w0.114: 226.46,89.94 v1(226.62,89.78) ; 226.46,89.94 225.13,88.61 223.7,88.61 223.46,88.85 223.46,89.02 v2(223.19,89.3) ; 226.46,89.94 226.78,90.27 226.78,90.52 226.89,90.64 U3300.33
  IN4 w0.089: v2(223.19,89.3) 223.37,89.47 223.37,89.81 223.2,89.98 222.56,89.98 221.67,89.09 221.67,84.58 219.35,82.27 219.35,81.07 217.98,79.7 209.75,79.7 209.1,79.05 194.25,79.05 188.95,73.75 187.64,73.75 186.93,73.05 171.35,73.05 170.8,73.6 167.84,73.6 166.51,72.27 166.51,71.68 v2(166.68,71.52)
  BOTTOM w0.114: R2520.2 166.47,71.13 166.47,71.32 v2(166.68,71.52)
CK_100M_LAN#: length 75.9
  TOP w0.114: 225.35,89.17 226.54,90.36 226.54,90.54 226.49,90.59 U3300.32 ; 225.35,89.17 v1(225.2,89.32) ; 225.35,89.17 225.03,88.85 223.8,88.85 223.7,88.95 223.7,89.11 v2(223.86,89.28)
  IN4 w0.089: v2(166.04,71.52) 166.33,71.81 166.33,72.34 167.76,73.77 170.87,73.77 171.42,73.22 186.86,73.22 187.56,73.93 188.88,73.93 194.18,79.23 209.03,79.23 209.67,79.88 217.91,79.88 219.18,81.15 219.18,82.34 221.49,84.65 221.49,89.17 222.48,90.16 223.27,90.16 223.55,89.88 223.55,89.59 v2(223.86,89.28)
  BOTTOM w0.114: R2521.2 166.24,71.13 166.24,71.32 v2(166.04,71.52)
CK_100M_LAN#_R: length 9
  BOTTOM w0.089: 166.21,63.8 166.21,63.72 165.62,63.12 165.62,62.57 165.72,62.47 165.72,61.94 U2000.P3
  BOTTOM w0.114: 166.21,65.83 166.21,63.8 ; 166.21,65.83 v1(165.96,65.83) ; 166.21,65.83 166.21,68.91 165.91,69.21 R2521.1
CK_100M_LAN_R: length 8.9
  BOTTOM w0.089: 166.45,63.8 166.45,63.68 165.81,63.04 165.81,62.65 165.93,62.53 165.93,62.24 U2000.P2
  BOTTOM w0.114: R2520.1 166.8,69.74 166.63,69.56 166.29,69.56 166.15,69.42 166.15,69.3 166.45,69 166.45,68.88 ; v1(166.7,68.88) 166.45,68.88 ; 166.45,68.88 166.45,63.8
CK_100M_PCIE: length 174.2
  IN1 w0.089: v2(161.72,76.21) 161.72,75.89 161.77,75.84 162.14,75.84 162.18,75.8 162.18,75.63 161.87,75.33 155,75.33 153.47,73.8 146.95,73.8 146.29,73.15 142.62,73.15 141.82,72.35 129.46,72.35 127.33,70.22 121.32,70.22 116.47,65.37 111.05,65.37 107.87,68.55 107.87,69.56 101.27,76.17 101.27,89.93 79.84,111.36 79.84,116.16 73.36,122.65 73.36,146.99 70.23,150.11 62.2,150.11 61.59,150.72 60.59,150.72 v6(60.07,150.2)
  BOTTOM w0.114: U0300.D35 60.35,149.92 v6(60.07,150.2) ; 162.13,75.43 162.13,73.48 161.67,73.03 161.67,72.22 R2510.2 ; 162.13,75.43 v1(161.9,75.43) ; 162.13,75.43 162.13,75.81 v2(161.72,76.21)
CK_100M_PCIE#: length 174.2
  IN1 w0.089: v2(162.36,76.21) 162.36,75.56 161.95,75.15 155.07,75.15 153.54,73.62 147.02,73.62 146.37,72.97 142.69,72.97 141.9,72.17 129.53,72.17 127.4,70.05 121.39,70.05 116.54,65.19 110.98,65.19 107.7,68.47 107.7,69.49 101.09,76.09 101.09,89.86 79.66,111.29 79.66,116.09 73.18,122.57 73.18,146.91 70.16,149.93 62.13,149.93 61.52,150.54 60.66,150.54 60.45,150.33 60.45,150.11 v6(60.86,149.7)
  BOTTOM w0.076: v6(60.86,149.7) 60.83,149.73 U0300.C36
  BOTTOM w0.114: 162.36,73.83 v1(162.58,73.83) ; 162.36,73.83 162.36,76.21 v2(162.36,76.21) ; 162.36,73.83 162.36,73.39 161.9,72.93 161.9,72.22 R2511.2
CK_100M_PE0: length 121.3
  TOP w0.114: v2(167.95,71.52) 167.56,71.14 167.56,70.08 ; 167.56,70.08 167.56,69.85 165.97,68.26 165.97,65.01 166.04,64.94 166.19,64.94 R2509.2 ; 167.56,70.08 v1(167.8,70.08)
  IN4 w0.089: v2(240.82,81.02) 240.54,80.74 240.54,80.38 240.24,80.09 239.84,80.09 238.2,78.45 238.2,62.53 237.87,62.19 235.15,62.19 234.61,61.65 233.4,61.65 232.78,62.27 230.98,62.27 228.16,59.45 223.9,59.45 222.67,60.69 219.64,60.69 219.08,61.25 215.85,61.25 213.2,58.6 208.98,58.6 208.51,58.13 203.23,58.13 201.96,59.41 201.96,61.46 194.11,69.3 190.96,69.3 187.86,72.4 171.05,72.4 170.52,72.93 168.44,72.93 167.67,72.16 167.67,71.8 v2(167.95,71.52)
  BOTTOM w0.114: v2(240.82,81.02) 240.57,80.77 240.57,80.61 240.64,80.54 241.03,80.54 242.4,81.91 246.97,81.91 247.51,82.46 247.51,83.61 247.44,83.69 247.31,83.69 247.25,83.74 CON5300.47
CK_100M_PE0#: length 121.5
  TOP w0.114: 165.74,67.42 165.74,64.91 R2502.2 ; 165.74,67.42 v1(165.5,67.42) ; 165.74,67.42 165.74,68.35 167.33,69.95 v2(167.33,71.54)
  IN4 w0.089: v2(240.18,81.02) 240.36,80.84 240.36,80.46 240.17,80.27 239.77,80.27 238.02,78.52 238.02,62.6 237.79,62.37 235.08,62.37 234.53,61.83 233.48,61.83 232.85,62.45 230.91,62.45 228.09,59.63 223.98,59.63 222.75,60.86 219.72,60.86 219.15,61.43 215.78,61.43 213.13,58.78 208.91,58.78 208.44,58.31 203.3,58.31 202.13,59.48 202.13,61.53 194.18,69.48 191.03,69.48 187.94,72.58 171.13,72.58 170.6,73.11 168.36,73.11 167.49,72.23 167.49,71.69 v2(167.33,71.54)
  BOTTOM w0.114: CON5300.49 247.75,82.36 247.07,81.68 242.5,81.68 241.13,80.31 240.54,80.31 240.34,80.51 240.34,80.86 v2(240.18,81.02)
CK_100M_PE0#_R: length 6.7
  TOP w0.114: 165.96,62.93 v1(165.73,62.93) ; 165.96,62.93 165.96,63.42 R2502.1 ; 165.96,62.93 165.96,62.38 166.49,61.84 166.49,59.3 166.4,59.21 166.24,59.21 165.94,59.51 v2(165.94,59.52)
  BOTTOM w0.102: U2000.N7 165.53,59.61 165.62,59.52 v2(165.94,59.52)
CK_100M_PE0_R: length 6.7
  TOP w0.114: 166.73,61.61 166.73,59.2 166.5,58.97 166.16,58.97 v2(165.97,58.78) ; 166.73,61.61 166.73,61.94 166.19,62.47 166.19,63.62 R2509.1 ; 166.73,61.61 v1(166.95,61.61)
  BOTTOM w0.102: U2000.N8 165.93,58.78 v2(165.97,58.78)
CK_100M_PE8: length 136.8
  TOP w0.114: v2(166.88,67.32) 167.21,66.99 167.21,66.64 R2515.2
  IN1 w0.089: v2(55.4,53.56) 55.58,53.74 55.58,54.27 55.85,54.55 78.08,54.55 78.98,53.65 90.9,53.65 92.09,54.85 98.24,54.85 99.54,56.15 107.78,56.15 109.6,57.97 114.09,57.97 116.31,57.97 117.22,57.06 122.42,57.06 122.94,57.58 132.1,57.58 133.26,58.75 138.32,58.75 140.4,60.83 142.26,60.83 143.2,61.78 146.32,61.78 149.81,65.26 152.74,65.26 154.09,66.61 157.64,66.61 157.92,66.89 166.67,66.89 166.88,67.1 v2(166.88,67.32)
  BOTTOM w0.114: v2(55.4,53.56) 55.57,53.39 55.57,39.44 56.06,38.96 56.64,38.96 56.75,38.85 CON5102.55
CK_100M_PE8#: length 136.8
  TOP w0.114: v2(167.55,67.32) 167.44,67.22 167.44,66.73 R2517.2
  IN1 w0.089: v2(56.01,53.56) 55.75,53.81 55.75,54.2 55.93,54.37 78.01,54.37 78.9,53.47 90.97,53.47 92.17,54.67 98.31,54.67 99.62,55.98 107.85,55.98 109.67,57.8 114.16,57.8 116.24,57.8 117.15,56.88 122.49,56.88 123.01,57.4 132.17,57.4 133.33,58.57 138.39,58.57 140.48,60.65 142.33,60.65 143.28,61.6 146.4,61.6 149.88,65.08 152.82,65.08 154.17,66.44 157.72,66.44 157.99,66.71 166.74,66.71 166.95,66.92 167.14,66.92 v2(167.55,67.32)
  BOTTOM w0.114: CON5102.53 56.71,39.35 56.55,39.19 56.16,39.19 55.8,39.54 55.8,53.36 v2(56.01,53.56)
CK_100M_PE8#_R: length 9.4
  TOP w0.114: v1(168.63,62.7) 168.4,62.7 ; 168.4,62.7 168.4,63.72 167.42,64.71 167.42,65.1 R2517.1 ; 168.4,62.7 167.79,62.1 167.79,58.8 167.9,58.69 168.17,58.69 168.25,58.77 v2(168.25,59.08)
  BOTTOM w0.102: v2(168.25,59.08) 168.73,58.61 U2000.W10
CK_100M_PE8_R: length 9.4
  TOP w0.114: v1(167.36,64.1) 167.52,64.27 ; 167.52,64.27 167.18,64.61 167.18,65.24 R2515.1 ; 167.52,64.27 168.17,63.62 168.17,62.8 167.56,62.19 167.56,58.7 167.8,58.46 168.07,58.46 v2(168.25,58.27)
  BOTTOM w0.102: v2(168.25,58.27) 168.42,58.27 U2000.W11
CL_CLK: length 122.3
  TOP w0.114: v2(245.41,93.33) 245.45,93.29 R5312.2 246.01,92.59 v1(246.3,92.3)
  IN4 w0.076: v2(245.41,93.33) 245.41,92.93 244.32,91.85 244.32,84.85 245.33,83.84 245.33,81.03 246.39,79.97 246.39,77.79 246.02,77.42 246.02,75.14 247.08,74.08 247.08,73.43 247.29,73.22 247.29,66.65 246.82,66.19 246.82,63.82 246.44,63.44 246.44,61.08 242.55,57.19 242.55,56.97 242.33,56.74 241.61,56.74 240.45,55.58 236.28,55.58 232.21,51.51 232.21,51.09 231.7,50.58 230.35,50.58 230.04,50.89 227.08,50.89 226.36,50.18 221.6,50.18 221.57,50.14 221.55,50.14 221.53,50.12 221.52,50.12 219.15,47.75 211.46,47.75 210.45,46.74 208.25,46.74 207.88,47.11 204.55,47.11 204.42,47.24 198.31,47.24 193.62,51.94 192.73,51.94 191.94,52.72 191.33,52.72 190.54,53.51 187.77,53.51 186.14,55.14 186.14,55.73 183.96,57.9 182.54,57.9 181.62,58.82 181.62,59.88 181.89,60.15 181.89,61.55 180.45,62.99 179.66,62.99 v2(178.56,64.1)
  BOTTOM w0.089: v2(178.56,64.1) 178.56,64.1 178.16,63.7 178.16,63.06 177.98,62.88 177.98,62.49 U2000.AV2
CL_DATA: length 124.3
  TOP w0.114: v1(244.5,92.7) 244.83,93.03 244.83,93.37 v2(245.41,93.95) 245.58,94.12 R5311.2
  IN4 w0.076: v2(245.41,93.95) 245.8,93.56 245.8,90.24 244.65,89.09 244.65,85.03 245.77,83.92 245.77,81.06 246.72,80.11 246.72,77.65 246.35,77.29 246.35,75.27 247.41,74.21 247.41,73.57 247.62,73.36 247.62,64.14 246.77,63.3 246.77,60.92 242.9,57.05 242.9,56.79 242.51,56.4 241.85,56.4 240.67,55.22 236.39,55.22 232.54,51.37 232.54,50.95 231.84,50.25 230.17,50.25 229.87,50.55 227.28,50.55 226.57,49.84 221.74,49.84 221.7,49.81 221.69,49.81 219.31,47.42 211.6,47.42 210.58,46.41 208.11,46.41 207.74,46.78 204.41,46.78 204.28,46.91 198.18,46.91 196.24,48.85 194.73,48.85 193.03,50.55 193.03,51.09 191.72,52.39 191.19,52.39 190.41,53.18 187.63,53.18 185.81,55 185.81,55.59 183.83,57.57 182.4,57.57 181.29,58.69 181.29,60.02 181.56,60.29 181.56,61.41 180.31,62.66 179.38,62.66 v2(178.56,63.49)
  BOTTOM w0.089: v2(178.56,63.49) 178.56,63.2 178.26,62.9 178.26,62.36 177.97,62.07 U2000.AV3
CL_RST#: length 123.6
  TOP w0.114: v1(177.76,61.98) 178,61.74 v2(178.48,61.74) ; v2(247.48,94.77) 247.28,94.96 R5310.2
  IN4 w0.076: v2(178.48,61.74) 178.86,62.12 180.57,62.12 181.36,61.32 181.36,60.37 181.09,60.1 181.09,58.6 183.89,55.8 184.73,55.8 187.55,52.98 190.32,52.98 191.11,52.19 191.64,52.19 192.61,51.22 192.61,50.68 196.58,46.71 204.19,46.71 204.33,46.57 207.66,46.57 208.02,46.21 210.67,46.21 211.05,46.59 214.84,46.59 215.48,47.22 219.4,47.22 221.82,49.64 226.74,49.64 227.44,50.35 229.72,50.35 230.05,50.01 231.88,50.01 232.74,50.87 232.74,51.28 236.36,54.9 240.73,54.9 242.02,56.2 242.6,56.2 243.34,56.94 244.02,56.94 246.98,59.9 246.98,63.22 247.82,64.06 247.82,73.44 247.61,73.65 247.61,74.3 246.55,75.36 246.55,77.2 246.92,77.57 246.92,80.2 245.97,81.15 245.97,84 244.86,85.12 244.86,88.92 246.38,90.44 246.38,93.67 v2(247.48,94.77)
  BOTTOM w0.102: U2000.AW2 178.56,61.81
  BOTTOM w0.114: 178.56,61.81 v2(178.48,61.74)
CLK_KBCPCI_DEBUG: length 156.8
  IN1 w0.076: v2(74.32,39.97) 89.11,39.97 90.8,41.66 96.53,41.66 97.11,41.08 111.57,41.08 111.64,41 111.71,40.94 112.54,40.94 113.52,39.96 134.65,39.96 135.84,38.77 144.77,38.77 146.37,37.16 159.7,37.16 160.29,37.75 172.53,37.75 173.48,38.7 179.2,38.7 179.65,38.25 180.83,38.25 182.94,40.36 182.94,41.37 184.35,42.79 184.35,43.52 185.25,44.42 187.38,44.42 187.76,44.8 187.76,54.75 v2(189.92,56.91)
  BOTTOM w0.114: v2(189.92,56.91) 189.79,56.91 189.41,56.53 R2227.1 ; v2(74.32,39.97) 74.32,38.55 70.84,35.07 v1(70.84,33.75) 70.84,32.81 69.25,31.21 69.25,28.94 70.32,27.87 74.79,27.87 75.13,28.21 CON4400.1
CLK_KBCPCI_PCH: length 153.5
  TOP w0.102: v2(193.29,57.02) 193.31,57 193.31,55.58 v1(193.17,55.44) 191.62,55.44 R2265.1
  TOP w0.114: v2(120.95,49.67) 121.46,49.15 121.46,48.1 C3022.1 120.5,47.13 120.5,46.74 120.32,46.56 U3001.13
  IN1 w0.102: v2(193.29,57.02) 194.01,56.3 194.01,52.43 195.38,51.05 195.38,48.93 195.25,48.8 195.25,46.84 195.35,46.73 195.35,44.53 194.26,43.44 194.26,42.46 192.56,40.76 192.56,29.16 192.54,29.14 192.54,27.6 193.55,26.59 193.55,25.28 192.84,24.57 178.76,24.57 175.9,27.43 157.68,27.43 157.05,28.06 135.09,28.06 134.44,27.41 116.14,27.41 v2(115.34,28.21)
  BOTTOM w0.102: v2(120.95,49.67) 120.52,49.24 120.52,48.65 120,48.13 120,45.9 120.52,45.38 120.52,43.82 118.11,41.41 118.11,37.47 117.77,37.13 117.77,36.45 118.31,35.91 118.31,33.65 117.2,32.53 117.2,28.92 117.48,28.64 117.48,28.06 117.24,27.82 115.73,27.82 v2(115.34,28.21) ; v2(193.29,57.02) 192.78,56.5 191.82,56.5 191.68,56.36 190.92,56.36 C2203.1
CLKOUT_LPC0_ESPI_CLK: length 13.8
  TOP w0.114: v2(187.22,56.2) 187.4,56.02 188.8,56.02 189.36,55.46 190.07,55.46 R2265.2 190.58,55.97 v1(190.58,56.74)
  BOTTOM w0.089: U2000.BC17 180.81,55.15 181.08,55.15 181.2,55.02 183.23,55.02 183.9,55.69 184.28,55.69 184.48,55.9 184.48,56.23 184.71,56.46
  BOTTOM w0.114: v2(187.22,56.2) 187.5,56.2 R2227.2 187.47,56.53 187.38,56.63 184.88,56.63 184.71,56.46
CLKOUT_LPC1_CLK: length 49.2
  TOP w0.114: v2(189.28,57.04) 189.23,56.99 188.29,56.99 C2202.1 187.48,56.53 187.39,56.63 186.33,56.63 186.03,56.33 R2264.1 ; v2(182.11,25.93) 182.11,25.3 183.47,23.94 U6200.21 183.47,20.44 v1(183.31,20.29)
  IN1 w0.076: v2(189.28,57.04) 189.55,57.3 190.08,57.3 190.86,56.53 190.86,51.99 190.77,51.9 190.77,51.41 190.83,51.34 190.83,42.22 190.51,41.91 190.51,30.91 189.62,30.03 189.62,28.73 187.55,26.66 182.85,26.66 v2(182.11,25.93)
CLKOUT_LPC1_CLK_R: length 10.2
  TOP w0.114: R2264.2 184.48,56.02 v1(184.19,55.73) 183.9,55.45 183.9,54.89 182.8,53.78 179.13,53.78 179.04,53.86 177.85,53.86 v2(177.38,54.33)
  BOTTOM w0.114: v2(177.38,54.33) 177.98,53.73 U2000.AV19
CLKREQ0_WLAN#: length 111.4
  TOP w0.114: v2(229.03,61.69) 228.21,62.51 227.6,62.51 225.64,64.47 213.96,64.47 213.42,63.94 207.33,63.94 206.7,63.31 202.15,63.31 199.14,60.3 199.14,59.48 v1(198.68,59.03) 198.42,58.77 v2(195.81,58.77)
  IN4 w0.076: v2(229.03,61.69) 228.23,62.49 224.73,62.49 224.61,62.61 224.61,79.8 226.34,81.53 235.93,81.53 236.76,82.35 241.06,82.35 241.45,81.96 v2(241.45,79.92)
  BOTTOM w0.089: 184.7,52.5 184.52,52.32 184.15,52.32 184.04,52.21 184.04,51.7 183.62,51.28 180.84,51.28 180.64,51.47 U2000.BC24
  BOTTOM w0.114: v2(195.81,58.77) 193.6,56.56 193.6,54.3 192.36,53.05 191.93,53.05 R2421.2 190.33,51.46 188.96,51.46 R2425.1 188.27,51.62 187.58,51.62 187.1,52.11 187.1,52.22 186.69,52.62 184.83,52.62 184.7,52.5 ; v2(241.45,79.92) 241.73,79.92 242.93,81.12 247.93,81.12 248.41,81.59 248.41,83.17 248.69,83.46 248.75,83.52 CON5300.53
CLKREQ#: length 8.3
  TOP w0.114: U3300.4 230.97,92.76 231.88,91.86 235.29,91.86 v1(236.32,90.82) 236.63,90.52 236.63,90.26 R3304.1
CLKREQ#_MSATA: length 164.2
  TOP w0.114: v2(51.87,39.88) 51.87,39.3 48.07,35.5 48.07,32.92 45.48,30.33 v1(45.49,28.8) 45.48,27.42 R2490.1 45.17,26.78 R5122.1
  IN1 w0.076: v2(184.54,46.6) 184.72,46.42 184.72,44.47 184.02,43.77 184.02,42.92 182.61,41.51 182.61,40.5 180.69,38.58 179.78,38.58 179.34,39.03 173.34,39.03 172.39,38.08 160.15,38.08 159.57,37.49 146.51,37.49 144.91,39.1 135.98,39.1 134.79,40.29 113.65,40.29 112.67,41.27 111.84,41.27 111.7,41.41 97.25,41.41 96.66,41.99 90.66,41.99 89.7,41.03 62.27,41.03 61.69,40.44 60.68,40.44 60.1,39.87 58.31,39.87 57.73,40.44 52.43,40.44 v2(51.87,39.88)
  BOTTOM w0.089: 181.46,47.14 181.3,47.14 181.17,47.27 181.08,47.27 U2000.BD32
  BOTTOM w0.102: 181.46,47.14 181.53,47.14 181.87,46.81 184.33,46.81 v2(184.54,46.6)
  BOTTOM w0.114: v2(184.54,46.6) 184.77,46.37 R2430.2
CMSRC: length 3.4
  TOP w0.279: v1(221.88,30.66) 221.67,30.44 U8800.3
  TOP w0.508: v1(221.88,30.66) 222.17,30.95 R8804.1
COMP_A: length 7.7
  BOTTOM w0.203: U8000.16 11.47,173.67 11.81,173.32 11.81,172.84 12.28,172.37 12.4,172.26 12.88,172.26 12.98,172.15 12.98,171.54 13.42,171.1 v1(14.61,171.1) 14.99,171.49 14.99,171.65 15.31,171.97 C8032.2 15.49,171.64 15.55,171.59 R8096.2
COMP_B: length 7
  BOTTOM w0.102: R8030.2 15.81,181.48 16.81,181.48 v1(17.25,181.92)
  BOTTOM w0.203: U8000.4 13.69,178.18 14.91,179.4 14.91,180.42 15.38,180.89 C8015.2 R8030.2
COMP_C: length 6
  BOTTOM w0.102: v1(3.02,177.37) C8005.1
  BOTTOM w0.203: U8000.29 7.13,176.58 6.77,176.94 6.27,176.94 5.61,176.28 4,176.28 R8093.1 C8005.1
CPU_PECI: length 12.6
  BOTTOM w0.102: U0300.BT34 20.87,148.78 20.86,148.8 20.31,148.8 19.93,149.18 19.93,151.78 19.81,151.89 19.81,153.45
  BOTTOM w0.114: v1(15.95,153.18) 16.28,153.5 16.28,153.7 R0733.2 18.03,155.46 R0746.2 18.97,154.28 19.81,153.45
CPU_PM_DOWN: length 9.5
  BOTTOM w0.102: R0731.2 18.19,153.3 18.62,152.87 v1(18.62,152.47) 18.62,152.15 19.12,151.65 19.39,151.65 19.74,151.3 19.74,149.11 20.23,148.61 20.78,148.61 21.05,148.34 21.72,148.34 21.92,148.14 21.92,147.94 22.18,147.68 22.49,147.68 U0300.BP31
CPU_THERM#: length 147.1
  TOP w0.102: v2(141.12,48.05) 141.55,48.48 142.61,48.48 142.71,48.58 SR9205.2 ; R5011.2 172.59,72.98 v1(171.78,72.98) 171.78,73.3 v2(172.36,73.88) 173.38,74.9 173.38,76.73 173.03,77.08 172.62,77.08 172.29,76.75 172.29,75.15 172.08,74.94 U5000.4
  IN2 w0.102: v2(178.79,69.89) 178.5,70.18 178.22,70.18 177.51,69.46 177.51,67.81 176.66,66.97 170.08,66.97 168.11,64.99 158.99,64.99 157.74,63.74 157.74,62.92 154.82,60 152.75,60 150.21,57.47 150.21,55.64 149.66,55.08 146.43,55.08 145.59,54.25 144.56,54.25 143.73,53.41 143.73,51.05 141.12,48.45 v2(141.12,48.05) ; v2(186.43,84.1) 186.77,84.43 190.84,84.43 192.47,82.81 204.85,82.81 206.65,84.62 206.65,86.21 207.55,87.1 208.67,87.1 209.42,87.85 210.98,87.85 212.24,89.12 214.83,89.12 215.47,89.75 216.24,89.75 218.75,92.27 221.66,92.27 224.69,95.3 224.69,95.89 226.57,97.77 226.57,98.31 226.25,98.63 226.25,99.17 226.75,99.66 v2(227.25,99.66)
  BOTTOM w0.102: v2(227.25,99.66) 227.25,100.12 227.38,100.25 R5018.2 227.89,99.92 228.26,99.54 229.04,99.54 229.25,99.75 U5003.3 ; v2(186.43,84.1) 186.43,83.84 185.77,83.18 185.77,79.25 186.71,78.31 186.71,73.39 185.95,72.63 183.51,72.63 182.76,71.88 181.16,71.88 180.17,70.88 179.38,70.88 178.79,70.3 v2(178.79,69.89) 178.41,70.27 178.41,70.98 176.82,72.57 174.38,72.57 174.14,72.82 174.08,72.88 173.48,72.88 172.48,73.88 v2(172.36,73.88)
CPU_VIDALERT#: length 9.5
  TOP w0.102: v6(26.15,147.49) 26.15,146 v1(26.01,145.86) 25.63,145.86 25.48,146.01
  TOP w0.114: 25.48,146.01 22.83,146.01 21,147.84 19.86,147.84 R0717.1
  BOTTOM w0.102: v6(26.15,147.49) 26.47,147.16 U0300.BH31
CPU_VRON: length 270.8
  TOP w0.102: R0750.2 113.31,54.36 113.78,54.36 114.01,54.13 114.01,53.46 113.79,53.24 112.48,53.24 112.38,53.14 112.38,52.58 111.91,52.11 110.21,52.11 109.96,51.86 109.96,51.29 107.77,49.1 104.84,49.1 104.72,48.99 104.72,46.06 99.07,40.4 96.65,40.4 93.44,37.2 v2(93.44,33.81) ; v1(11.93,184.3) 12.71,184.3 13.08,183.93 v2(13.08,183.58) 13.08,183.13 12.78,182.83 11.92,182.83 11.64,182.55 R80151.2 ; v2(84.1,29.18) 84.1,29.18 83.38,29.9 83.38,38.38 73.65,48.12 v2(73.65,48.25)
  IN1 w0.102: v2(93.44,33.81) 92.48,32.85 85.4,32.85 84.1,31.55 v2(84.1,29.18)
  IN2 w0.102: v2(73.65,48.25) 72.02,49.88 62.49,49.88 62.02,50.34 v2(60.01,50.34)
  IN4 w0.102: v2(60.01,50.34) 60.01,50.67 59.57,51.11 50.76,51.11 47.27,54.6 33.99,54.6 27.7,60.89 27.7,63.65 26.61,64.74 25.85,64.74 25.35,65.24 25.35,68.39 24.62,69.13 24.62,74.42 24.77,74.57 24.77,78.41 21.19,81.98 18.75,81.98 13.79,86.94 12.87,86.94 12.32,87.49 12.32,88.33 11.98,88.67 10.59,88.67 7.83,91.43 7.83,116.09 4.54,119.38 4.54,124.48 3.43,125.6 3.43,139.72 7.95,144.24 7.95,146.42 8.24,146.71 8.24,155.24 8.66,155.66 8.66,163.59 5.7,166.55 5.7,168.33 7.39,170.02 7.39,172.35 14.45,179.41 14.45,181.75 13.08,183.13 v2(13.08,183.58)
CPU_VRON_PWR: length 2.8
  TOP w0.102: JP9300.2 13.54,183.27 v2(13.65,183.38) 13.97,183.69 T9300.1
  BOTTOM w0.102: v2(13.65,183.38) 13.61,183.34 R8017.2
CPU_VTT_CNTL: length 8.6
  BOTTOM w0.102: R0728.1 15.67,129.98 v1(15.29,130.37) 15.51,130.6 16.6,130.6 16.91,130.91 17.11,131.11 17.48,131.11 19.49,133.11 U0300.BT13
CPU_XDP_HOOK0: length 18.7
  BOTTOM w0.102: v1(11.06,132.64) 10.57,132.15 10.47,132.15 10.18,131.85 XDP4400.39 7.95,131.85 7.7,131.6 7.7,131.5 7.41,131.2 7.05,131.2 6.55,130.7 6.55,130.09 6.39,129.93 6.39,129.31 6.55,129.16 6.55,125.64 7.34,124.85 7.34,121.81 R4404.1 R4405.1 7.59,119.85 7.59,119.11 7.95,118.76 R4406.1
CPU_XDP_HOOK2: length 14.7
  BOTTOM w0.102: R4416.1 R4409.2 8.46,121.86 8.46,123.1 7.75,123.81 7.75,125.02 6.95,125.81 6.95,129.32 6.83,129.45 6.83,129.8 7.17,130.14 7.71,130.14 7.92,130.35 XDP4400.45 10.22,130.35 10.52,130.65 v1(11.03,130.65)
CPUFAN_PWM_C_L: length 34.8
  BOTTOM w0.102: v1(42.75,113.3) 42.29,113.3 42.24,113.35 R5006.2 41.45,113.35 40.14,112.03 38.97,112.03 38.71,112.3 38.71,113.16 38.53,113.33 D5000.2 36.71,113.33 33.37,109.99 21.48,109.99 21.15,110.31 21.15,115.37 21.71,115.93 24.29,115.93 25.14,115.08 CON5000.1
CPUFAN_PWM_C_R: length 25.3
  BOTTOM w0.102: R5010.2 191.39,86.04 190.9,86.53 189.44,86.53 189.14,86.83 187.91,86.83 187.42,86.34 D5002.2 185.7,85.37 184.32,83.99 v1(184.32,81.59) 184.32,79.56 185.78,78.09 185.78,75.75 186.25,75.29 186.25,73.5 185.79,73.05 CON5001.1
CPUFAN_TACH_C_L: length 38.1
  BOTTOM w0.102: D5001.2 D5001.1 ; D5001.2 37.7,110.66 R5005.2 37.47,111.27 37.7,111.5 D5000.1 ; D5001.2 37.69,109.79 21.36,109.79 20.92,110.22 20.92,116.21 v1(21.96,117.25) 23.9,117.25 24.77,116.38 25.29,116.38 25.59,116.68 28.46,116.68 28.7,116.44 28.7,116.1 28.44,115.84 27.83,115.84 27.64,115.65 CON5000.3
CPUFAN_TACH_C_R: length 37.2
  BOTTOM w0.102: D5002.1 186.88,84.62 185.89,84.62 v1(185.3,84.02) 184.89,83.62 184.89,79.39 185.99,78.3 185.99,75.9 186.51,75.37 186.51,73.48 185.87,72.83 183.35,72.83 182.6,72.08 181.07,72.08 180.12,71.14 179.35,71.14 178.87,71.62 178.87,72.1 179.38,72.61 CON5001.3 ; D5002.1 187.42,83.6 186.36,82.54 186.36,81.22 186.52,81.07 187.22,81.07 187.65,80.65 D5003.1 D5003.2 ; D5002.1 188.15,84.07 188.47,84.4 188.47,85.68 188.29,85.86 v2(188.29,86.31) 188.3,86.33 190.32,86.33 190.53,86.12 R5009.2
CPUPWRGD: length 277.3
  TOP w0.114: v2(6.9,124.71) 6.6,125 6.6,126.16 6.05,125.6 6.05,125.49 v1(5.63,125.07)
  IN1 w0.076: v2(20.52,147.21) 20.46,147.21 19.09,145.83 19.09,138.27 17.96,137.14 17.96,134.28 12.34,128.67 9.67,128.67 6.9,125.89 v2(6.9,124.71)
  IN2 w0.114: v2(172.95,69.09) 172.35,69.7 169.7,69.7 168.78,68.78 168.78,67.89 167.27,66.38 158.37,66.38 156.35,64.36 156.35,63.5 154.52,61.67 152.22,61.67 148.71,58.16 144.35,58.16 142.41,56.22 142.41,54.35 142.06,54 142.06,51.89 141.23,51.07 138.52,51.07 138.41,51.17 125.58,51.17 125.1,50.69 106.65,50.69 104.13,53.22 98.28,53.22 v2(97.86,52.8)
  IN4 w0.076: v2(97.86,52.8) 96.9,51.84 51.06,51.84 50.12,52.78 50.12,55.62 48.96,56.78 32.87,56.78 29.11,60.55 29.11,60.92 29.1,60.97 28.5,61.57 28.5,68.47 26.51,70.47 26.51,78.88 22.01,83.37 20.61,83.37 19.41,84.58 19.41,85.09 16.52,87.97 16.52,88.31 15.08,89.76 10.99,89.76 9.89,90.86 9.89,121.94 7.13,124.71 v2(6.9,124.71)
  BOTTOM w0.102: v2(20.52,147.21) 20.57,147.26 U0300.BT31
  BOTTOM w0.114: R4404.2 6.91,124.67 6.9,124.68 v2(6.9,124.71) ; R2462.2 173.18,70.68 172.95,70.45 v2(172.95,69.09)
CRITICAL: length 2.6
  TOP w0.203: U8702.9 119.98,69.86 119.58,69.46 T8715.1 119.89,68.52 R8737.1
CSBU_1_R: length 7.5
  TOP w0.076: U1201.K8 244.23,52.44 244.65,52.44
  TOP w0.102: R1219.1 249.22,50.7 249.22,50.95 v1(248.93,51.24) 248.71,51.46 248.71,52.12 247.97,52.86 245.15,52.86 244.73,52.44 244.65,52.44
CSBU_2_R: length 6.5
  TOP w0.102: R1220.1 248.47,50.55 248.47,52.05 247.87,52.66 246.96,52.66 v1(246.74,52.43) 246.51,52.66 245.2,52.66 244.74,52.2 U1201.L8
DCPRTC: length 16.4
  TOP w0.102: v1(192.05,52.02) 191.57,52.02 191.53,52.06 191.2,52.06 190.96,51.82 190.96,51.4 C2623.1 190.03,50.47 186.12,50.47 185.64,49.99 184.86,49.99 184.72,49.85 184.72,49.44 184.07,48.79 183.49,48.79 183.21,49.06 182.91,49.06 182.46,48.61 181.65,48.61 180.96,49.29 179.5,49.29 179.32,49.48 179.25,49.48 v2(179.02,49.71)
  BOTTOM w0.102: U2000.BA26 179.02,49.76 v2(179.02,49.71)
DDI1_BKLT_CTL: length 365.6
  TOP w0.102: R2140.2 158.27,35.5 158.27,32.99 v1(157.94,32.66) 158.25,32.35 v2(158.55,32.35) ; R4587.1 45.06,180.81 45.06,181.82 v2(44.89,181.99) 44.89,183.21 45.11,183.43 46.33,183.43 46.85,183.95 56.97,183.95 57.75,183.18 CON4500.26
  IN1 w0.102: v2(28.63,41.65) 28.25,41.65 27.31,40.71 27.31,38.63 30.01,35.93 39.02,35.93 39.24,36.15 76.04,36.15 77.72,34.46 82.43,34.46 84.89,36.92 106.05,36.92 110.36,32.61 115.21,32.61 117.69,30.13 129.84,30.13 130.69,30.98 151.33,30.98 152.09,31.74 157.94,31.74 v2(158.55,32.35)
  IN2 w0.102: v2(17.1,183.18) 14.67,180.74 14.67,179.78 11.35,176.46 11.35,173.69 12.22,172.83 12.22,167.02 11.86,166.66 10.95,166.66 7.18,162.9 7.18,151.57 8.38,150.38 8.38,144.08 7.31,143.01 7.31,142.74 4.06,139.49 4.06,125.87 5.15,124.78 5.15,119.83 7.25,117.73 7.25,105.55 6.71,105.01 6.71,92.56 5.21,91.07 5.21,85.13 5.73,84.61 5.73,80.35 4.83,79.45 4.83,65.72 6.91,63.64 6.91,62.62 7.38,62.15 12.08,62.15 12.33,61.89 17.57,61.89 18.09,61.38 21.62,61.38 23.5,59.5 23.5,57.62 27.18,53.93 27.18,49.62 29.12,47.69 29.12,42.14 v2(28.63,41.65)
  IN3 w0.102: v2(17.1,183.18) 19.84,180.44 19.84,180.33 19.92,180.25 26.59,180.25 27.11,179.73 36.3,179.73 37.52,180.95 37.52,181.66 37.99,182.13 41.87,182.13 42.57,181.43 44.1,181.43 44.65,181.99 v2(44.89,181.99)
DDI1_BKLT_EN: length 303.9
  TOP w0.102: v2(38.56,181.35) 38.56,180.84 38.81,180.59 R4518.2 39.73,180.59 v1(40.69,179.62) 41.44,180.37 D4502.1 ; v2(154.74,41.47) 154.74,40.94 153.23,39.43 153.23,34.87 154.38,33.72 155.79,33.72 156.4,33.11 157.36,33.11 R2150.2
  IN2 w0.102: v2(38.56,181.35) 38.56,181.04 37.06,179.54 35.63,179.54 34.32,178.23 32.11,178.23 31.73,177.85 26.57,177.85 21.36,172.64 21.36,168.11 23.01,166.46 23.01,165.45 21.7,164.13 21.7,157.3 16.64,152.24 16.64,148.94 16.27,148.58 15.93,148.58 15.37,148.02 15.37,147.59 14.94,147.16 14.94,146.27 13.96,145.3 13.96,143.58 14.28,143.27 14.28,141.05 13.92,140.7 13.92,138.19 12.25,136.53 12.25,133.14 14,131.4 14,125.38 12.65,124.04 12.65,118.48 18.23,112.9 18.23,89.62 26.44,81.42 26.44,70.3 28.94,67.8 28.94,62.22 29.01,62.15 29.01,60.04 35.94,53.11 37.62,53.11 39.2,51.54 40.65,51.54 45.6,46.59 47.59,46.59 49.08,45.1 67.11,45.1 67.92,44.29 69.12,44.29 69.85,43.57 90.4,43.57 90.9,44.07 99.89,44.07 102.02,41.94 113.17,41.94 114.61,40.5 115.83,40.5 116.3,40.97 116.3,40.99 118.21,42.91 130.52,42.91 133.17,40.26 134.93,40.26 135.75,39.44 147.47,39.44 149.05,41.01 149.05,41.96 149.88,42.79 153.42,42.79 v2(154.74,41.47)
DDI1_VDD_EN: length 385.2
  TOP w0.102: v2(25.71,47.1) 26.85,47.1 27.99,48.24 27.99,53.55 25.72,55.83 22.89,55.83 19.69,59.02 7.54,59.02 4.5,62.07 v2(4.5,64.03)
  IN1 w0.102: v2(28.88,39.72) 29.39,39.21 34.24,39.21 35.16,40.13 41,40.13 41.86,39.27 48.9,39.27 50.84,37.33 77.13,37.33 78.86,39.06 95.91,39.06 96.31,39.46 110.9,39.46 113.18,37.18 114.98,37.18 116.02,36.14 120.02,36.14 120.09,36.21 126.46,36.21 126.75,35.93 165.75,35.93 166.21,35.48 166.21,35.16 v2(166.68,34.69)
  IN2 w0.102: v2(6.6,180.46) 6.6,179.79 9.48,176.9 9.48,171.76 12.01,169.24 12.01,167.11 11.78,166.87 10.87,166.87 6.98,162.98 6.98,151.49 8.17,150.29 8.17,144.16 7.11,143.09 7.11,142.82 3.86,139.58 3.86,125.79 4.95,124.7 4.95,119.75 7.05,117.65 7.05,105.64 6.5,105.09 6.5,92.65 5,91.15 5,84.52 5.52,84 5.52,80.44 4.5,79.41 v2(4.5,64.03)
  IN3 w0.102: v2(6.6,180.46) 7.08,180.94 8.53,180.94 9.22,180.26 13.4,180.26 13.64,180.02 13.64,179.31 13.94,179.01 25.88,179.01 26.77,178.12 48.69,178.12 50.13,176.69 57.52,176.69 60.21,174 60.21,173.51 v2(60.58,173.13)
  IN4 w0.102: v2(28.88,39.72) 28.63,39.46 27.61,39.46 27.17,39.9 27.17,43.26 26.02,44.42 26.02,46.79 v2(25.71,47.1)
  BOTTOM w0.089: U2000.W42 168.85,42.55 169.35,42.05 169.55,42.05 169.79,41.81 169.79,41.37 169.81,41.34 169.81,41.02 169.46,40.66 169.46,38.94 168.46,37.94 168.12,37.94 167.92,37.73
  BOTTOM w0.102: v2(60.58,173.13) 60.9,173.13 61.29,172.74 R4590.1 ; 167.92,37.73 167.87,37.69 v1(167.67,37.69) 167.54,37.69 167.14,37.29 167.14,35.16 v2(166.68,34.69)
DDR0_DQ_RC: length 1.8
  TOP w0.305: C0500.2 R0509.1 16.94,128.01 v1(17.02,127.93)
DDR_BST: length 2.6
  TOP w0.203: U8300.18 132.26,61.99
  TOP w0.381: v1(128.75,63.75) 128.75,63.52 129.3,62.97 SR8301.2
DDR_BST_R:
  vias: v1(130.05,66.56)
DDR_CS: length 2.2
  TOP w0.203: U8300.13 134.54,64.42 v1(134.61,64.48) 134.47,64.62 R8302.1
DDR_FB: length 4.8
  TOP w0.203: v1(137.67,57.93) C8320.2 R8306.2 R8308.1 137.04,60.72 136.57,61.19 U8300.6
DDR_FB_R: length 30.9
  TOP w0.203: v2(122.48,64.23) 122.48,64.74 122.4,64.81 122.4,64.81 120.56,66.65 v1(120.19,66.65) 119.93,66.92 119.93,66.99 118.5,68.43 118.26,68.43 117.88,68.8 JP8304.2 ; v2(139.12,60.11) 139.45,59.78 C8321.1 C8320.1 R8306.1
  IN4 w0.203: v2(122.48,64.23) 122.48,64.02 122.84,63.65 122.84,62.92 124.68,61.09 125.82,61.09 127.96,58.95 129.97,58.95 131.8,60.77 136.6,60.77 137.26,60.11 v2(139.12,60.11)
DDR_HG: length 18.2
  TOP w0.203: 132.52,62.39 U8300.17
  IN4 w0.762: v3(122.61,77.1) 122.61,76.51 126.82,72.29 126.82,68.71 127.89,67.65 127.89,67.02 v3(131.6,63.31)
  vias: v1(131.14,63.92)
DDR_LG: length 7.4
  IN2 w0.762: v3(125.78,63.64) 127.05,63.64 127.68,64.28 132.38,64.28 v3(132.79,64.69)
  vias: v1(132.65,65.46)
DDR_LX: length 15.5
  IN2 w0.762: 131.06,65.67 130.13,65.67 125.36,70.45 122.61,70.45 v3(119.05,74.01)
  vias: v2(131.96,65.74) v2(131.96,65.13)
DDR_PWRGD: length 44.7
  TOP w0.102: U8300.10 136.41,62.79 v2(136.58,62.96) ; R9211.1 127.23,53 T9202.1 126.19,54.52 125.47,55.24 117.1,55.24 116.43,55.91 116.1,55.91 v2(115.62,55.43)
  IN1 w0.102: v2(118,58.55) 118.01,58.55 118.88,59.43 121.81,59.43 122.21,59.83 127.12,59.83 127.7,60.42 132.45,60.42 132.85,60.82 136.29,60.82 136.58,61.1 v2(136.58,62.96)
  BOTTOM w0.102: v2(115.62,55.43) 115.62,56.19 117.98,58.55 v2(118,58.55) ; v2(136.58,62.96) 137.29,62.96 T8300.1
DDR_RC:
  vias: v1(122.43,70.58)
DDR_VDD: length 6.5
  TOP w0.203: 134.94,63.92 U8300.12 ; SR8302.2 136.58,67.45 v1(137.1,67.98)
  TOP w0.381: SR8302.2 135.34,66.58 C8318.1 135.36,65.33 SR8303.1 135.65,64.62 134.94,63.92
DDR_VDDQ: length 25.9
  TOP w0.203: U8300.5 135.34,60.33 v2(135.69,59.98) ; v2(121.82,64.24) 121.82,64.96 120.74,66.05 119.98,66.05 119.58,66.45 119.58,66.9 118.82,67.66 v1(118.26,67.66) 118.26,67.99 117.5,68.75 JP8303.2
  IN4 w0.203: v2(135.69,59.98) 135.22,60.45 131.91,60.45 130.1,58.64 126.69,58.64 122.53,62.8 122.53,63.53 v2(121.82,64.24)
DDR_VID: length 4.2
  TOP w0.102: R8303.1 137.36,65.85 v1(137.67,66.16)
  TOP w0.203: R8303.1 136.7,65.25 SR8303.2 136.49,64.62 135.34,63.48 U8300.11
DDR_VTT_CNTL_R: length 3.3
  BOTTOM w0.102: v1(13.06,128.74) 13.67,128.74 14.32,129.4 R0728.2 14.81,128.97 14.91,128.87 U0701.2
DDR_VTT_CNTRL: length 205
  TOP w0.102: D8300.2 142.04,62.73 141.87,62.56 141.13,62.56 141.02,62.45 R8304.2 R8305.1 140.9,61.71 141.12,61.5 142.44,61.5 142.66,61.29 142.66,60.15 141.03,58.52 139,58.52 137.97,57.5 137.72,57.5 134.54,54.32 v2(134.54,54.2)
  IN2 w0.102: v2(133.23,49.1) 132.79,48.66 131.72,48.66 131.44,48.38 123.91,48.38 123.36,47.82 118.44,47.82 118.24,48.02 113.1,48.02 112.42,47.34 112.42,46.46 112.05,46.09 103.1,46.09 98.9,50.28 76.4,50.28 75.77,50.92 65.58,50.92 64.7,51.8 55.27,51.8 53.57,53.5 53.57,56.11 52.99,56.69 40.84,56.69 39.6,57.92 39.6,60.7 39.19,61.1 39.19,62.99 35.33,66.85 35.33,68.21 34.58,68.96 34.58,76.29 31.9,78.97 31.9,94.5 v2(32.51,95.11)
  BOTTOM w0.102: v2(133.23,49.1) 133.25,49.11 133.25,51.63 134.54,52.93 v2(134.54,54.2)
  BOTTOM w0.127: v2(32.51,95.11) 32.51,101.95 24.89,109.57 21.26,109.57 20.6,110.23 20.6,116.76 v1(19.79,117.57) 16.15,121.2 16.15,122.59 15.34,123.4 R0704.2 15.56,124.82 U0701.4
DDR_VTTSNS: length 3.6
  TOP w0.203: U8300.2 134.14,60.29 133.91,60.06 v1(133.91,59.38) 133.35,59.38 133.25,59.28 132.56,59.28 132.31,59.02 JP8300.2
DDRA_VREF_CA_R: length 4.2
  BOTTOM w0.305: R1610.2 R1612.1 R1620.1 R1621.1 v1(78.28,84.45)
DDRA_VREF_CA_R_W10S12: length 16.5
  TOP w0.305: R0505.1 14.81,122.57 15.21,122.98 C0501.1 15.21,124.4 v1(15.49,124.68) 15.81,125 16.76,125 17.78,126.02 17.78,127.03 19.8,129.05 20.47,129.05 22.08,130.66 22.08,131.34 22.39,131.65 22.8,131.65 v6(23.86,132.72)
  BOTTOM w0.254: U0300.BN13 23.54,133.05 v6(23.86,132.72)
DDRA_VREF_CA_W10S12: length 118
  TOP w0.254: v2(75.11,72.82) 75.28,72.82 76.59,74.13 76.59,76.02 76.38,76.23 CON1600.164 76.38,78.35 76.17,78.55 76.17,79.77 76.41,80.01 v2(78.51,80.01)
  TOP w0.305: v2(79.43,84.39) 77.35,84.39 72.15,89.6 v2(32.72,89.6) ; v2(15.14,121.68) 13.51,121.68 12.62,122.57 R0505.2 11.41,122.57 v1(11.28,122.7)
  BOTTOM w0.254: v2(75.11,72.82) 74.94,72.82 74.14,72.03 74.14,71.25 74.57,70.82 74.57,70.19 74.38,69.99 CON1601.164 ; v2(78.51,80.01) 77.85,80.67 C1615.2
  BOTTOM w0.305: v2(32.72,89.6) 31.06,91.26 31.06,94.55 26.23,99.39 26.23,107.22 24.19,109.25 20.92,109.25 19.82,110.36 19.82,115.25 15.14,119.93 v2(15.14,121.68) ; R1620.2 C1612.1 75.95,82.16 C1613.2 C1615.2 79.15,82.59 C1614.1 R1621.2 79.15,84.11 v2(79.43,84.39)
DDRB_VREF_CA_R: length 3.7
  BOTTOM w0.305: v1(36.58,88.1) R1721.1 R1720.1 R1714.1 R1710.2
DDRB_VREF_CA_R_W10S12: length 12.9
  TOP w0.254: v6(20.88,133.61) 20.44,133.16 v1(20.07,133.16)
  TOP w0.305: v6(20.88,133.61) 21.13,133.36 21.13,131.97 19.74,130.57 18.88,130.57 17.69,129.38 16.11,129.38 C0502.1 15.37,130.05 15.37,129.47 R0508.1
  BOTTOM w0.229: v6(20.88,133.61) 20.99,133.51 21.84,133.51 U0300.BR13
DDRB_VREF_CA_W10S12: length 145.7
  TOP w0.305: v2(74.47,59.66) 74.78,59.66 75.16,60.04 75.16,61.23 75.45,61.52 75.45,63.02 76.38,63.95 CON1700.164 ; v2(11.28,129.4) 11.68,129 v1(12.01,129) 12.6,129 12.75,128.84 R0508.2
  IN2 w0.305: v2(34.37,80.74) 34.47,80.74 35.23,79.98 35.23,78.33 37.26,76.29 37.26,71.85 37.39,71.72 37.39,70.45 36.54,69.6 36.54,66.65 39.62,63.57 40.79,63.57 41.66,62.7 41.66,61.54 40.31,60.19 40.31,58.32 41.16,57.47 54.02,57.47 54.69,56.8 57.22,56.8 57.82,56.2 57.82,54.61 58.19,54.24 63.58,54.24 65.13,52.69 73.51,52.69 73.89,53.07 v2(73.89,53.97)
  BOTTOM w0.305: R1721.2 37.44,86.73 C1714.1 ; C1714.1 C1712.1 34.8,86.73 R1720.2 34.09,87.14 30.47,90.75 30.47,94.41 25.72,99.16 25.72,107.15 24.02,108.85 20.75,108.85 19.41,110.19 19.41,115.07 13.58,120.9 13.58,124.8 13.03,125.36 13.03,127.79 11.42,129.4 v2(11.28,129.4) ; C1714.1 36.83,83.68 35.52,82.38 35.52,82.38 34.37,81.22 v2(34.37,80.74) ; v2(73.89,53.97) C80135.1 C1713.1 74.68,54.91 74.38,55.21 CON1701.164 74.38,59.58 74.45,59.66 v2(74.47,59.66)
DEBUG1: length 6
  TOP w0.102: R1234.1 247.19,46.32 246.81,46.7 246.81,46.84 245.37,48.28 245.37,48.55 244.73,49.2 U1201.L2
DEBUG2: length 7
  TOP w0.076: U1201.K2 244.24,48.94 244.24,48.56 244.56,48.24 244.56,48.08 244.77,47.87 244.78,47.87
  TOP w0.102: R1233.1 248.72,45.31 247.96,46.07 246.98,46.07 v1(246.17,46.87) 245.34,47.71 244.95,47.71 244.78,47.87
DEBUG3: length 8.4
  TOP w0.102: v1(251.26,46.22) 250.7,46.78 250.11,46.78 R1236.1 249.44,47.45 246.79,47.45 245.82,48.43 245.82,48.66 245.82,48.66 245.65,48.83 245.59,48.83 244.73,49.7 U1201.L3
DEBUG4: length 4.7
  TOP w0.076: 244.8,49.37 244.72,49.45 244.23,49.45 U1201.K3
  TOP w0.102: 244.8,49.37 245.58,48.6 245.58,48.37 246.99,46.96 R1235.1
DEBUGMODE: length 9.4
  TOP w0.102: R3301.1 235.56,92.22 232.06,92.22 231.62,92.65 v1(231.62,93.03) 231.5,93.16 U3300.5
DELAY_ALL_SYSTEM_PWRGD: length 135
  TOP w0.102: v2(191.86,64.91) 191.64,64.69 v1(191.64,64.25) ; v2(116.76,49.37) 116.76,50.08 R0748.1 ; U3001.84 120.32,30.22 118.69,31.84 117.64,31.84 116.66,32.82 116.66,34.78 113.49,37.95 113.49,39.21 114.18,39.91 115.78,39.91 v2(116.79,40.91)
  IN1 w0.102: v2(116.79,40.91) 118.82,40.91 119.1,40.63 134.93,40.63 136.12,39.44 145.05,39.44 146.65,37.84 159.43,37.84 160.01,38.42 172.25,38.42 173.2,39.37 179.48,39.37 179.93,38.93 180.55,38.93 182.26,40.64 182.26,41.65 183.64,43.03 183.64,48.82 185.65,50.82 185.65,57.42 186.56,58.33 190.1,58.33 191.64,59.88 191.64,64.69 v2(191.86,64.91)
  BOTTOM w0.102: R2494.1 197.03,65.71 195.6,64.28 194.84,64.28 194.63,64.5 ; U2402.2 194.26,65.45 194.63,65.08 194.63,64.5 ; v2(116.79,40.91) 117.45,41.57 117.45,44.47 117.95,44.97 117.95,47.48 116.79,48.64 116.79,49.34 v2(116.76,49.37) ; v2(191.86,64.91) 192.28,64.5 194.63,64.5
DGPU_EN_PWR: length 372.1
  TOP w0.102: SR9100.1 147.71,48.11 148.03,48.43 148.03,48.81 149.86,50.64 149.86,56.2 149.45,56.61 v2(148.55,56.61) 147.23,57.93 147.23,58.83 146.53,59.53 146.53,64.28 147.07,64.82 147.07,72.09 151.77,76.78 151.77,78.05 151.55,78.26 148.18,78.26 146.81,79.62 146.81,86.43 145.7,87.55 144.3,87.55 143.05,88.8 v2(141.99,88.8)
  IN2 w0.102: v2(74.74,176.27) 73.49,177.52 55.4,177.52 54.79,178.12 41.01,178.12 40.53,177.64 40.21,177.64 39.25,176.69 36.92,176.69 36.14,175.91 36.14,174.36 35.07,173.28 35.07,170.41 35.59,169.89 35.59,168.6 36.47,167.71 36.47,159.9 34.4,157.83 30.05,157.83 28.91,156.68 25.96,156.68 21.8,152.52 21.8,151.94 22,151.73 22,145.79 21.72,145.5 21.72,135.91 21.33,135.52 21.33,132.07 19.78,130.52 19.11,130.52 17.2,128.6 17.2,125.77 21.59,121.38 21.59,96.16 30.89,86.86 30.89,79.17 34.18,75.87 34.18,69.18 34.06,69.05 34.06,66.53 34.86,65.73 35.87,65.73 38.79,62.81 38.79,60.93 39.19,60.53 39.19,57.33 41.35,55.16 48.18,55.16 51.96,51.39 64.54,51.39 65.41,50.51 75.6,50.51 76.34,49.78 98.61,49.78 102.72,45.66 112.67,45.66 113.39,46.38 113.39,47.34 113.66,47.61 118.07,47.61 118.27,47.41 123.52,47.41 124.08,47.97 131.61,47.97 131.89,48.25 137.88,48.25 138.42,48.79 140.61,48.79 143.05,51.23 143.05,53.59 143.4,53.95 143.4,55.81 144.2,56.61 v2(148.55,56.61)
  BOTTOM w0.102: R9602.1 76.12,177.08 76.12,176.12 75.62,175.61 D9600.2 74.22,175.61 74.09,175.73 74.09,175.99 74.37,176.27 v2(74.74,176.27) ; R8710.1 144.49,87.85 SR9102.2 144.23,88.66 144.62,89.04 144.62,90.57 T9109.1 144.02,90.5 144.02,89.42 143.85,89.25 D8700.2 142.45,89.25 v2(141.99,88.8)
DGPU_PWROK: length 185.6
  TOP w0.102: v2(146.38,85.05) 146.38,79.57 142.97,76.16 v2(142.97,75.51) 142.97,75.21 143.24,74.95 143.24,72.92 142.97,72.65 142.97,68.2 142.73,67.95 142.73,66.44 142.47,66.19 142.47,64.84 143.27,64.04 143.27,57.61 T9204.1 142.32,56.66 139.18,56.66 137.85,55.33 137.85,53.61 137.64,53.41 137.01,53.41 136.79,53.62 136.79,53.94 136.53,54.21 135.78,54.21 134.95,53.38 R9206.1 ; R7411.2 86.11,131.59 v2(86.03,131.67) ; v6(97.59,120.21) 97.59,120.87 98.14,121.43 v6(104.7,121.43)
  IN1 w0.102: v2(86.03,131.67) 86.54,132.17 86.54,135.5 88.85,137.81 95.61,137.81 95.92,138.12 95.92,139.3 96.26,139.64 98.04,139.64 98.4,139.28 98.4,136.62 96.57,134.8 96.57,133.59 96.99,133.16 99.28,133.16 99.67,132.77 99.67,128.46 98.73,127.52 98.73,121.35 v6(97.59,120.21) 97.91,119.88 97.91,118.02 97.05,117.16 97.05,112.14 v2(97.36,111.83) 96.93,111.39 96.93,102.1 107.13,91.89 107.13,85.27 108.86,83.54 111.88,83.54 112.93,82.48 117.02,82.48 117.9,81.61 121.01,81.61 123.97,84.56 138.5,84.56 139.36,85.43 146,85.43 v2(146.38,85.05)
  BOTTOM w0.102: D7402.2 106.51,120.13 105.22,121.43 v6(104.7,121.43) ; SR8702.1 144.45,77.06 142.97,75.58 v2(142.97,75.51)
DISPA_BCLK_L200MIL: length 5.1
  BOTTOM w0.089: 175.15,63.73 175.41,63.47 175.41,62.64 175.06,62.29 U2000.AM2
  BOTTOM w0.114: R2311.2 174.93,66.21 174.93,65.6 174.83,65.5 v1(174.83,64.84) 175.15,64.51 175.15,63.73
DISPA_SDO_L200MIL: length 4.6
  BOTTOM w0.089: 174.91,63.03 U2000.AM1
  BOTTOM w0.102: 174.91,63.03 174.91,64.13 174.08,64.96 174.08,65.05 173.99,65.14
  BOTTOM w0.114: 173.99,65.14 173.81,65.32 v1(173.81,65.75) 173.58,65.98 R2307.2
DMI_RXN0: length 159.7
  IN4 w0.089: v2(157.79,50.29) 155.41,50.29 154.94,49.82 148.71,49.82 148,49.12 145.9,49.12 144.46,50.56 140.14,50.56 139.81,50.9 138.03,50.9 137.75,51.17 125.92,51.17 125.78,51.03 118.23,51.03 117.77,50.58 107.04,50.58 104.04,53.57 104.04,74.29 102.3,76.03 102.3,88.95 79.56,111.69 79.56,116.01 76.05,119.52 76.05,121.68 70.19,127.54 65.11,127.54 64.43,128.22 62.12,128.22 61.22,129.12 60.38,129.12 60.15,129.35 60.15,129.59 v6(59.94,129.8)
  BOTTOM w0.076: U0300.E8 59.94,129.73 v6(59.94,129.8)
  BOTTOM w0.102: U2000.C27 160.49,50.17 160.21,50.45 159.25,50.45 159,50.7 158.19,50.7 v2(157.79,50.29)
DMI_RXN1: length 160.2
  IN4 w0.089: v2(157.26,49.06) 148.76,49.06 148.05,48.35 144.55,48.35 142.92,49.98 140.06,49.98 139.66,49.58 137.31,49.58 136.42,50.46 118.47,50.46 118,49.99 106.75,49.99 103.47,53.27 103.47,74.01 101.73,75.75 101.73,88.71 78.99,111.45 78.99,115.77 74.69,120.07 74.69,121.29 72.72,123.26 72.72,124.15 69.91,126.96 65.13,126.96 64.35,127.74 61.71,127.74 60.82,128.63 59.67,128.63 v6(59.29,129.01)
  BOTTOM w0.076: U0300.F6 58.94,128.67 v6(59.29,129.01)
  BOTTOM w0.089: 159.56,49.93 159.6,49.97 159.91,49.97 160.29,49.59
  BOTTOM w0.102: U2000.B28 160.29,49.59
  BOTTOM w0.114: 159.56,49.93 158.72,49.93 158.58,49.78 157.86,49.78 157.58,49.49 157.58,49.37 v2(157.26,49.06)
DMI_RXN2: length 160.4
  IN4 w0.089: v2(159.17,49.06) 159.17,48.77 159.11,48.71 158.75,48.71 158.14,48.1 149.85,48.1 149.51,47.76 144.33,47.76 142.82,49.27 140.61,49.27 140.25,48.91 138.16,48.91 137.68,48.42 133.04,48.42 131.59,49.88 124.64,49.88 123.18,48.43 113.16,48.43 112.52,49.07 106.86,49.07 102.9,53.02 102.9,73.77 101.16,75.51 101.16,88.47 78.35,111.27 78.35,115.6 74.04,119.91 74.04,121.07 71.96,123.15 71.96,124.05 69.61,126.39 65.05,126.39 64.18,127.27 60.99,127.27 60.38,127.88 60.28,127.88 v6(59.94,128.22)
  BOTTOM w0.076: v6(59.94,128.22) 59.94,127.95 59.82,127.83 U0300.E5
  BOTTOM w0.114: U2000.B29 159.97,49.08 159.88,49.17 159.29,49.17 v2(159.17,49.06)
DMI_RXN3: length 164.2
  IN4 w0.089: v6(57.95,130.6) 57.95,130.37 58.01,130.3 58.36,130.3 58.78,129.89 58.78,129 59.46,128.31 59.46,127.5 60.22,126.74 62.2,126.74 62.51,126.43 64.26,126.43 64.69,126 68.35,126 69.95,124.4 70.71,124.4 71.43,123.69 71.43,123.13 73.58,120.97 73.58,119.73 77.67,115.64 77.67,111.4 100.76,88.3 100.76,75.35 102.49,73.62 102.49,52.84 106.69,48.63 109.03,48.63 109.68,47.98 123.42,47.98 124.04,48.61 132.12,48.61 132.77,47.96 140.05,47.96 140.83,48.73 142.8,48.73 144.17,47.36 149.94,47.36 150.09,47.52 155.63,47.52 155.78,47.36 156.57,47.36 156.66,47.45 156.66,47.49 v2(156.77,47.6)
  BOTTOM w0.076: v6(57.95,130.6) 57.83,130.6 U0300.J9
  BOTTOM w0.102: U2000.B30 160.06,48.7 159.4,48.7 159.32,48.62 157.16,48.62 156.77,48.23 v2(156.77,47.6)
DMI_RXP0: length 159.6
  IN4 w0.089: v2(158.42,50.29) 158.42,50.67 158.34,50.74 157.67,50.74 157.4,50.47 155.33,50.47 154.86,50 148.64,50 147.93,49.29 145.98,49.29 144.53,50.74 140.22,50.74 139.88,51.08 138.1,51.08 137.83,51.35 125.85,51.35 125.71,51.21 118.16,51.21 117.7,50.75 107.11,50.75 104.22,53.65 104.22,74.36 102.48,76.1 102.48,89.02 79.74,111.76 79.74,116.08 76.23,119.59 76.23,121.75 70.26,127.71 65.19,127.71 64.5,128.4 62.19,128.4 61.29,129.3 60.45,129.3 60.33,129.43 60.33,129.74 60.39,129.8 v6(60.59,129.8)
  BOTTOM w0.076: v6(60.59,129.8) 60.59,129.44 60.55,129.4 U0300.D8
  BOTTOM w0.114: U2000.B27 160.04,50.22 159.16,50.22 158.91,50.47 158.59,50.47 v2(158.42,50.29)
DMI_RXP1: length 160
  IN4 w0.089: v6(59.94,129.01) 59.95,129.01 60.16,128.81 60.9,128.81 61.79,127.91 64.43,127.91 65.2,127.14 69.98,127.14 72.9,124.22 72.9,123.33 74.87,121.37 74.87,120.14 79.16,115.84 79.16,111.53 101.91,88.79 101.91,75.83 103.65,74.08 103.65,53.35 106.82,50.17 117.92,50.17 118.39,50.64 136.5,50.64 137.38,49.76 139.58,49.76 139.98,50.16 142.99,50.16 144.62,48.53 147.98,48.53 148.68,49.24 156.87,49.24 157.1,49.47 157.73,49.47 157.89,49.62 158.06,49.62 158.18,49.51 158.18,49.34 v2(157.9,49.06)
  BOTTOM w0.076: v6(59.94,129.01) 59.94,128.67 59.89,128.62 U0300.E6
  BOTTOM w0.114: U2000.A28 158.82,49.69 158.67,49.54 157.96,49.54 157.81,49.39 157.81,49.15 v2(157.9,49.06)
DMI_RXP2: length 160.5
  IN4 w0.089: v6(60.59,128.22) 60.59,127.92 61.06,127.45 64.25,127.45 65.13,126.57 69.69,126.57 72.14,124.12 72.14,123.23 74.22,121.14 74.22,119.98 78.53,115.67 78.53,111.34 101.33,88.54 101.33,75.59 103.08,73.84 103.08,53.09 106.93,49.24 112.59,49.24 113.23,48.61 123.11,48.61 124.56,50.06 131.66,50.06 133.12,48.6 137.6,48.6 138.09,49.09 140.17,49.09 140.53,49.45 142.9,49.45 144.41,47.93 149.44,47.93 149.78,48.27 158.06,48.27 158.53,48.75 v2(158.53,49.06)
  BOTTOM w0.076: U0300.D5 60.59,128.15 v6(60.59,128.22)
  BOTTOM w0.102: U2000.C29 160.64,49.08 160.41,49.31 160.22,49.31
  BOTTOM w0.114: v2(158.53,49.06) 158.94,49.47 159.46,49.47 159.53,49.41 159.97,49.41 160.07,49.31 160.22,49.31
DMI_RXP3: length 164.2
  IN4 w0.089: v2(157.4,47.58) 157,47.19 155.7,47.19 155.55,47.34 150.16,47.34 150.01,47.19 144.1,47.19 142.73,48.55 140.9,48.55 140.13,47.78 132.7,47.78 132.05,48.43 124.11,48.43 123.49,47.81 109.61,47.81 108.96,48.46 106.62,48.46 102.31,52.76 102.31,73.55 100.58,75.28 100.58,88.23 77.49,111.33 77.49,115.57 73.41,119.65 73.41,120.9 71.25,123.06 71.25,123.62 70.64,124.22 69.88,124.22 68.28,125.82 64.61,125.82 64.18,126.25 62.44,126.25 62.13,126.56 60.15,126.56 59.28,127.42 59.28,128.24 58.6,128.92 58.6,129.81 58.28,130.13 58.05,130.13 57.99,130.06 v6(57.99,129.8)
  BOTTOM w0.076: U0300.J8 57.67,129.8 v6(57.99,129.8)
  BOTTOM w0.102: U2000.A30 159.44,48.46 159.4,48.42 157.25,48.42 156.97,48.15 156.97,48.01 157.03,47.95 157.33,47.95 157.4,47.88 v2(157.4,47.58)
DMI_TXN0: length 173.3
  IN4 w0.089: v2(163.83,50.76) 163.83,50.46 163.77,50.4 163.48,50.4 163.25,50.63 163.25,51.22 162.98,51.49 160.67,51.49 159.13,53.02 155.3,53.02 154.08,51.81 151,51.81 149.71,53.1 146.28,53.1 145.78,52.6 141.6,52.6 140.88,53.32 130.82,53.32 130.43,53.71 117.33,53.71 116.21,52.59 109.01,52.59 105.94,55.67 105.94,66.5 106.37,66.93 106.37,74.7 104.19,76.87 104.19,89.79 81.59,112.39 81.59,116.65 78.08,120.16 78.08,122.37 77.34,123.11 77.34,132.73 76.63,133.44 74.81,133.44 73.41,132.05 67.47,132.05 65.54,130.12 65.54,129.36 65.45,129.27 65.39,129.27 65.24,129.42 65.11,129.42 65.05,129.36 v7(65.05,128.97)
  BOTTOM w0.076: U0300.A8 62.05,129.4 61.97,129.48 61.97,129.67 62.02,129.72 62.87,129.72 63.08,129.51
  BOTTOM w0.114: 63.08,129.51 64.89,129.51 65.05,129.35 v7(65.05,128.97) ; v2(163.83,50.76) 163.83,50.59 163.91,50.51 164.08,50.51 164.29,50.31 164.29,50.06 164.36,49.98 164.52,49.98 U2000.L27
DMI_TXN1: length 173.3
  IN4 w0.089: v6(64.39,129.04) 64.2,129.24 64.2,129.46 69.45,134.71 73.89,134.71 74.7,135.53 76.78,135.53 77.75,134.56 77.75,123.26 78.43,122.57 78.49,122.52 78.49,120.31 81.98,116.81 81.98,112.55 104.58,89.95 104.58,77.04 106.79,74.83 106.79,55.38 107.03,55.15 107.03,55.14 109.16,53 116.06,53 117.17,54.11 119.6,54.11 120.37,54.88 131.54,54.88 132.33,55.67 141.98,55.67 143.96,53.69 150.5,53.69 151.49,52.7 154.21,52.7 154.99,53.48 159.23,53.48 160.37,52.34 161.95,52.34 162.04,52.25 162.04,52.14 v2(161.8,51.9)
  BOTTOM w0.076: U0300.B6 61.32,128.62 61.24,128.69 61.24,128.84 61.34,128.94 62.53,128.94 63.08,128.39 64.03,128.39 64.19,128.54 64.19,128.83 v6(64.39,129.04)
  BOTTOM w0.114: U2000.E24 161.88,51.29 161.98,51.39 161.98,51.72 v2(161.8,51.9)
