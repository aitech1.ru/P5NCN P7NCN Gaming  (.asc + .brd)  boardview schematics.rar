# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+FBVDDQ on TOP (solid shape): 134.39,102.96 134.39,102.22 134.59,102.02 134.59,101.77 134.42,101.59 132.44,101.59 132.39,101.64 132.39,102.71 132.44,102.76 133.68,102.76 134.04,103.11 134.24,103.11
+FBVDDQ on TOP (solid shape): 154.99,96.36 154.99,95.6 154.23,94.84 154.23,90.14 153.85,89.76 151.05,89.76 149.66,91.15 149.66,96.11 150.55,96.99 154.36,96.99
+FBVDDQ on TOP (solid shape): 142,128.51 142.08,128.47 142.1,128.39 142.44,127.95 142.79,128.39 142.81,128.47 142.89,128.51 143.18,128.51 143.47,128.22 143.47,127.67 143.44,127.65 143.37,127.6 143.31,127.52 143.22,127.48 143.13,127.53 142.83,127.71 142.43,127.48 142.34,127.53 142.13,127.7 141.87,127.67 141.81,127.77 141.74,127.86 141.27,128.33 141.2,128.33 141.2,128.39 141.22,128.47 141.3,128.51
+FBVDDQ on TOP (solid shape): outline of 219 points within 103.05,150.64 116.46,152.75
+FBVDDQ on TOP (solid shape): outline of 370 points within 126.45,109.11 131.72,114.46
+FBVDDQ on TOP (solid shape): outline of 510 points within 109.64,107.55 116.37,118.05
+FBVDDQ on TOP (solid shape): outline of 737 points within 118.22,178.1 123.56,184.03
+FBVDDQ on TOP (solid shape): outline of 1005 points within 138.73,164.37 148.34,173.37
+FBVDDQ on TOP (solid shape): outline of 1504 points within 117.46,150.95 132.76,175.35
+FBVDDQ on TOP (solid shape): outline of 2109 points within 149.02,142.28 157.59,166.38
+FBVDDQ on TOP (solid shape): outline of 2690 points within 103.69,167.77 117.04,184.61
+FBVDDQ on TOP (solid shape): outline of 3487 points within 108.71,126.98 137.65,149.41
+FBVDDQ on BOTTOM (solid shape): 128.39,114.64 128.39,114.13 127.98,113.72 126.49,113.72 126.46,113.75 126.46,114.54 126.59,114.67 128.36,114.67
+FBVDDQ on BOTTOM (solid shape): 115.61,185.02 115.61,183.95 115.51,183.85 113.4,183.85 113.13,184.11 113.13,185.13 113.26,185.26 115.37,185.26
+FBVDDQ on BOTTOM (solid shape): 129.21,169.31 129.21,168.67 129.08,168.54 126.62,168.54 126.44,168.73 126.44,169.42 126.59,169.58 128.94,169.58
+FBVDDQ on BOTTOM (solid shape): 108.31,185.03 108.31,183.73 108.23,183.66 106.07,183.66 105.46,184.27 105.46,185.21 105.51,185.26 108.08,185.26
+FBVDDQ on BOTTOM (solid shape): 138.99,101.06 138.99,100.55 138.74,100.3 138.5,100.3 137.97,100.83 137.97,101.08 138.2,101.31 138.74,101.31
+FBVDDQ on BOTTOM (solid shape): 154.93,96.49 154.93,95.53 154.36,94.96 154.36,90.39 154.1,90.14 150.42,90.14 149.78,90.77 149.78,95.44 151.18,96.84 154.58,96.84
+FBVDDQ on BOTTOM (solid shape): 155.45,145.18 155.45,144.01 155.65,143.8 155.65,142.97 155.58,142.89 154.61,142.89 154.35,143.15 154.35,144.7 154.92,145.28 155.35,145.28
+FBVDDQ on BOTTOM (solid shape): 121.7,185.12 121.7,183.46 121.64,183.4 120.75,183.4 120.62,183.53 120.62,185.1 120.75,185.23 121.59,185.23
+FBVDDQ on BOTTOM (solid shape): 156.58,182.7 156.58,181.63 156.54,181.59 156.54,181.59 156.11,181.59 155.94,181.76 155.94,182.05 155.85,182.14 155.09,182.14 155.04,182.18 155.04,182.7 155.1,182.76 156.53,182.76
+FBVDDQ on BOTTOM (solid shape): 129.06,185.31 129.06,184.47 128.88,184.29 127.23,184.29 127,184.06 127,183.58 126.85,183.43 126.11,183.43 125.98,183.56 125.98,185.38 126.14,185.54 128.83,185.54
+FBVDDQ on BOTTOM (solid shape): 113.13,101.16 114.02,101.16 114.1,101.08 114.1,100.85 113.75,100.51 113.75,100.38 113.54,100.17 113.06,100.17 112.5,100.73 112.5,100.85 112.34,101.01 111.51,101.01 111.48,101.03 111.48,101.67 111.51,101.69 112.6,101.69
+FBVDDQ on BOTTOM (solid shape): 155.57,159.85 155.57,155.98 155.47,155.88 155.47,154.36 155.46,154.35 154.34,154.35 154.25,154.44 154.25,156.84 154.47,157.06 154.47,157.37 154.07,157.76 154.07,160.16 154.12,160.21 155.21,160.21
+FBVDDQ on BOTTOM (solid shape): 112.71,114.66 113.31,114.66 113.83,114.14 113.83,113.71 113.65,113.53 113.22,113.53 113,113.32 113,113.22 112.95,113.17 112.95,112.32 113.14,112.13 113.23,112.13 113.26,112.11 113.79,112.11 113.97,112.28 114.05,112.28 114.15,112.18 114.15,112 113.56,111.42 113.18,111.42 112.95,111.19 112.95,110.86 113.21,110.61 113.83,110.61 113.92,110.7 114.06,110.7 114.15,110.61 114.15,110.38 113.64,109.87 113.4,109.87 113.37,109.89 113.24,109.89 112.55,110.59 112.55,110.74 112.3,110.99 111.1,110.99 110.73,111.36 110.73,113.06 110.53,113.27 110.53,115.13 110.86,115.47 111.9,115.47
+FBVDDQ on BOTTOM (solid shape): 155.54,120.78 155.54,119.59 155.41,119.46 155.41,117.17 155.7,116.88 156.32,116.88 156.33,116.89 156.46,116.75 156.46,115.52 156.17,115.23 154.65,115.23 154.09,115.79 148.96,115.79 148.91,115.84 148.91,116.25 148.95,116.29 149.22,116.57 149.09,116.95 149.05,117.02 149.08,117.1 149.56,117.57 149.73,117.57 150.16,117.14 150.16,116.88 150.39,116.3 150.78,116.78 150.78,116.78 150.78,116.91 150.9,117.04 150.9,117.52 150.98,117.59 151.41,117.59 151.46,117.54 151.46,116.85 151.84,116.47 152.15,116.3 152.45,116.47 152.65,116.67 152.65,117.57 152.68,117.59 153.06,117.59 153.09,117.57 153.09,116.55 153.47,116.55 153.48,116.55 153.64,116.51 153.81,116.55 153.82,116.55 154.1,116.55 154.23,116.68 154.23,120.77 154.33,120.87 155.45,120.87
+FBVDDQ on BOTTOM (solid shape): 145.69,182.5 146.51,182.5 146.86,182.15 146.86,181.38 147.34,180.9 147.34,180.49 147.19,180.2 147.34,179.91 147.34,179.74 147.23,179.63 146.97,179.63 146.6,180 146.38,180.11 146.15,180.02 146.09,179.96 145.83,179.96 145.78,180.02 145.72,180.07 145.72,180.32 145.76,180.36 145.82,180.78 145.4,180.86 145.32,180.78 145.27,180.68 145.27,180.66 145.11,180.51 145.1,180.5 144.92,180.41 144.82,180.24 144.81,180.23 144.68,180.09 144.67,180.09 144.58,180.05 144.52,179.98 144.22,179.98 144.19,180.01 144.11,180.08 144.11,180.32 144.15,180.36 144.27,180.56 144.22,180.78 144.06,180.94 143.76,180.94 143.26,180.43 143.05,180.43 142,181.48 142,182.57 142.08,182.64 145.54,182.64
+FBVDDQ on BOTTOM (solid shape): 149.68,129.61 149.8,129.63 149.86,129.54 149.86,128.45 149.71,128.15 149.86,127.86 149.86,127.43 149.42,127.43 149.42,127.17 149.36,126.87 149.59,126.67 149.65,126.64 149.67,126.57 149.73,126.4 149.86,126.27 149.86,126.07 149.75,125.99 149.68,125.87 149.68,125.86 149.63,125.82 149.59,125.86 149.58,125.88 149.46,126.06 149.25,126.13 149.18,126.15 149.15,126.22 148.63,126.39 148.8,125.87 148.86,125.83 148.88,125.77 148.96,125.56 149.14,125.43 149.15,125.43 149.2,125.38 149.13,125.32 149.09,125.3 149.06,125.28 148.85,125.28 148.78,125.31 148.75,125.38 148.65,125.72 148.4,125.97 148.07,125.97 147.99,126.06 147.99,126.42 148.05,126.48 148.05,126.66 148.09,126.67 148.31,126.82 148.33,127.08 148.32,127.09 148.32,127.14 148.07,127.4 148.16,127.49 148.17,127.49 148.34,127.71 148.27,127.97 148.27,127.99 148.82,128.54 148.84,128.55 149.06,128.68 149.15,128.92 149.15,129.08
+FBVDDQ on BOTTOM (solid shape): outline of 212 points within 129.19,172.42 133.55,182.63
+FBVDDQ on BOTTOM (solid shape): outline of 2111 points within 102.87,129.02 128.02,159.28
+FBVDDQ on BOTTOM (solid shape): outline of 2114 points within 147.78,141.25 155.44,165.79
+FBVDDQ on BOTTOM (solid shape): outline of 2737 points within 141.11,164.57 157.19,184.79
+FBVDDQ on IN1 (solid shape): outline of 216 points within 120.85,109.42 123.03,112.23
+FBVDDQ on IN1 (solid shape): outline of 569 points within 126.65,107.54 129.76,114.12
+FBVDDQ on IN1 (solid shape): outline of 1131 points within 123.1,99.15 135.03,108.13
+FBVDDQ on IN1 (solid shape): outline of 1987 points within 144.12,162.11 155.87,174.24
+FBVDDQ on IN1 (solid shape): outline of 2799 points within 101.22,173.22 118.87,184.44
+FBVDDQ on IN1 (solid shape): outline of 8510 points within 103.26,90.78 160.32,162.67
+FBVDDQ on GND2 (solid shape): 158.67,125.52 158.67,115.41 158.68,115.36 158.71,115.32 159.32,114.71 160.71,110.31 160.71,106.05 158.19,102.27 158.17,102.24 158.17,102.2 158.17,97.56 156.43,95.81 156.4,95.77 156.39,95.72 156.39,91.33 155.95,90.9 154.74,90.9 154.69,90.89 154.65,90.86 153.67,89.88 151.11,89.88 149.11,91.88 149.07,91.91 149.02,91.91 143.11,91.91 142.8,92.22 142.8,92.75 144.16,94.11 144.19,94.15 144.2,94.2 144.2,108.55 144.19,108.6 144.16,108.64 143.02,109.78 142.97,109.81 142.93,109.82 141.15,109.82 141.15,115.1 141.58,115.54 144.58,115.54 144.62,115.54 144.66,115.56 145.29,116.07 145.33,116.12 145.34,116.17 145.34,117.14 145.68,117.48 145.71,117.52 145.72,117.57 145.72,118.91 146.41,119.6 151.82,119.6 151.86,119.61 151.91,119.64 152.54,120.27 152.57,120.31 152.58,120.36 152.58,121.2 153.68,122.31 153.71,122.35 153.72,122.39 153.72,124.88 154.66,125.82 158.37,125.82
+FBVDDQ on IN2 (solid shape): 104.78,175.17 104.78,174.91 104.77,174.91 104.77,174.06 104.5,173.79 104.5,173.48 104.32,173.17 104.5,172.85 104.5,172.79 104.69,172.59 104.69,172.24 104.5,172.05 104.5,171.9 104.36,171.75 104.32,171.55 104.34,171.47 104.34,171.19 104.38,171.15 104.38,170.98 104.33,170.93 104.04,170.93 103.89,171.08 103.89,174.74 104.36,175.2 104.41,175.23 104.47,175.22 104.53,175.29 104.66,175.29
+FBVDDQ on IN2 (solid shape): outline of 3027 points within 112.31,99.13 125.96,113.12
+FBVDDQ on IN2 (solid shape): outline of 29044 points within 94.87,90.8 160.96,185.4
+FBVDDQ on IN3 (solid shape): 104.84,175.36 104.84,174.42 105.01,174.26 105.01,173.56 104.96,173.47 104.85,173.47 104.32,173.17 104.85,172.86 104.96,172.86 105.01,172.77 105.01,171.98 104.96,171.89 104.85,171.89 104.34,171.7 104.63,171.23 104.71,171.16 104.69,171.06 104.55,170.92 104.37,170.92 104.05,170.6 103.54,170.6 103.41,170.73 103.41,174.77 104.08,175.44 104.76,175.44
+FBVDDQ on IN3 (solid shape): 107.9,176.79 107.93,176.7 107.87,176.62 107.65,176.22 108.02,175.94 108.09,175.91 108.12,175.83 108.12,174.34 108.09,174.26 108.02,174.23 107.66,173.96 107.86,173.55 107.86,173.37 107.67,173.07 107.84,172.75 107.89,172.67 107.84,172.58 107.68,172.18 108.02,171.92 108.09,171.89 108.12,171.82 108.12,171.12 108.09,171.05 108.02,171.02 107.74,170.87 107.69,170.55 107.6,170.46 107.1,170.46 106.99,170.58 106.99,171.03 107.03,171.11 107.11,171.12 107.57,171.46 107.11,171.81 107.03,171.82 106.99,171.9 106.99,172.63 107.03,172.71 107.11,172.72 107.57,173.07 107.11,173.41 107.03,173.42 106.99,173.51 106.99,177.22 107.15,177.38 107.31,177.38
+FBVDDQ on IN3 (solid shape): outline of 255 points within 118.9,109.05 122.74,112.72
+FBVDDQ on IN3 (solid shape): outline of 32554 points within 94.98,90.92 161.47,185.4
+FBVDDQ on IN4 (solid shape): outline of 429 points within 141.75,143.96 148.5,147.28
+FBVDDQ on IN4 (solid shape): outline of 702 points within 111.98,168.08 115.25,178.83
+FBVDDQ on IN4 (solid shape): outline of 23015 points within 98.17,98.87 158.9,185.43
+LX on TOP (solid shape): 229.97,91.28 230.12,91.28 230.25,91.15 230.25,90.87 230.34,90.78 230.41,90.68 230.52,90.6 230.56,90.57 231.04,90.57 231.42,90.95 232.46,90.95 232.77,90.64 232.77,89 232.64,88.88 231.25,88.88 229.59,90.54 229.59,91.29 229.96,91.29
+NVVDD on TOP (solid shape): outline of 85 points within 99.06,90.44 144.07,111.12
+NVVDD on TOP (solid shape): outline of 1982 points within 87.18,131.01 118.29,161.82
+NVVDD on BOTTOM (solid shape): outline of 349 points within 100.28,90.44 145.3,114.65
+NVVDD on BOTTOM (solid shape): outline of 7704 points within 85.67,131.08 119.17,161.18
+NVVDD on IN1 (solid shape): outline of 8566 points within 88.33,90.66 144.45,160.69
+NVVDD on GND2 (solid shape): outline of 105 points within 90.35,90.64 143.94,160.29
+NVVDD on IN2 (solid shape): outline of 18998 points within 85.4,90.14 144.2,161.32
+NVVDD on IN3 (solid shape): outline of 22304 points within 85.4,90.14 144.31,160.9
+NVVDD on GND3 (solid shape): outline of 101 points within 86.67,91.03 144.2,160.24
+NVVDD on IN4 (solid shape): outline of 13317 points within 82.93,90.67 144.23,160.42
+RTC_POWER on TOP (solid shape): 219,81.81 219,77.1 218.75,76.85 218.49,76.85 218.45,76.89 218.45,77.04 218.41,77.08 218.41,77.11 218.41,77.23 218.36,77.36 218.36,78.88 217.69,79.56 217.69,81.87 217.75,81.93 218.87,81.93
+VCORE on TOP (solid shape): 56.15,138.31 56.15,137.51 56.06,137.28 56.15,137.04 56.15,136.9 56.14,136.89 56.08,136.69 56.15,136.49 56.15,134.52 56.14,134.51 56.11,134.4 56.11,134.29 56.12,134.26 55.93,134.08 55.19,134.08 55.19,138.44 55.32,138.57 55.88,138.57
+VCORE on TOP (solid shape): outline of 727 points within 34.97,132.98 66.73,167.27
+VCORE on BOTTOM (solid shape): outline of 2698 points within 37.19,132.65 62.2,164.1
+VCORE on IN1 (solid shape): outline of 3205 points within 35.74,132.98 60.76,162.45
+VCORE on GND2 (solid shape): 46.28,161.71 46.28,160.37 46.29,160.32 46.32,160.28 47.71,158.88 47.75,158.85 47.8,158.84 54.92,158.84 54.96,158.85 55,158.88 56.36,160.24 60.58,160.24 60.76,160.06 60.76,157.37 60.45,157.07 58.98,157.07 58.93,157.06 58.89,157.03 54.7,152.84 54.67,152.8 54.66,152.75 54.66,145.13 54.67,145.08 54.7,145.04 55.68,144.06 55.68,133.12 55.5,132.94 41.38,132.94 41.2,133.12 41.2,141.9 41.67,142.37 41.7,142.41 41.71,142.46 41.71,150.72 41.7,150.76 41.67,150.81 40.78,151.69 40.74,151.72 40.69,151.73 39.22,151.73 36.37,154.58 36.37,161.97 36.81,162.4 45.59,162.4
+VCORE on IN2 (solid shape): outline of 3355 points within 37.08,132.98 59.57,162.46
+VCORE on IN3 (solid shape): outline of 1155 points within 35.74,146.57 59.54,162.45
+VCORE on IN3 (solid shape): outline of 1929 points within 41.83,132.98 56.11,145.41
+VCORE on GND3 (solid shape): 60.5,161.71 60.5,155.09 56.35,150.93 56.32,150.89 56.31,150.84 56.31,146.32 55.88,145.89 55.3,145.89 55.25,145.88 55.21,145.85 54.95,145.6 54.92,145.56 54.92,145.51 54.92,134.89 54.74,134.71 42.9,134.71 42.72,134.89 42.72,151.48 42.71,151.53 42.69,151.57 37.61,156.65 37.56,156.68 37.52,156.68 37.14,156.68 37.14,162.22 37.57,162.65 59.56,162.65
+VCORE on IN4 (solid shape): outline of 3479 points within 36.39,134.2 59.34,162.45
+VTT_DDR on TOP (solid shape): 100.81,67.83 100.82,67.79 100.82,67.06 100.63,66.88 99.58,66.88 99.52,66.94 99.52,68 99.59,68.07 100.57,68.07
+VTT_DDR on TOP (solid shape): 128.8,58.74 128.8,56.66 128.7,56.56 126.47,56.56 126.16,56.86 126.16,58.13 126.87,58.84 128.7,58.84
+VTT_DDR on TOP (solid shape): outline of 168 points within 96.16,52.67 106.62,58.23
+VTT_DDR on BOTTOM (solid shape): 97.2,54.93 97.2,54.05 97.11,53.95 96.23,53.95 96.04,54.14 96.04,54.93 96.1,54.99 97.15,54.99
+VTT_DDR on BOTTOM (solid shape): 96.25,85.83 96.25,85.81 96.25,85.67 96.29,85.55 96.29,82.57 97.21,81.65 97.21,81.21 96.93,80.93 95.77,80.93 95.65,81.06 95.65,85.72 95.65,85.73 95.65,85.84 95.75,85.94 96.14,85.94
+VTT_DDR on BOTTOM (solid shape): 100.55,74.42 100.6,74.17 100.81,74.01 100.85,74 100.85,73.81 100.83,73.79 100.66,72.84 101.51,72.39 101.59,72.36 101.62,72.28 101.62,71.32 102.85,71.32 102.85,70.47 102.56,70.19 101.76,70.19 101.49,70.46 101.49,71.08 101.12,71.44 101.12,71.46 100.89,71.78 100.5,71.73 100.39,71.83 100.45,72.24 100.1,72.46 100.06,72.46 99.97,72.52 99.99,72.63 100.2,73.39 99.68,73.97 99.68,74.3 99.86,74.48 100.54,74.48
+VTT_DDR on IN2 (solid shape): outline of 361 points within 96.14,53.64 101.42,64.64
AMP_SPK_LN on BOTTOM (solid shape): 15.47,88.23 15.47,86.11 15.68,85.9 15.68,85.14 14.78,85.14 14.74,85.18 14.74,88.51 14.81,88.57 15.13,88.57
AMP_SPK_LN on BOTTOM (solid shape): 13.79,115.27 13.79,113.08 13.75,113.04 13.75,112.62 13.69,112.55 13.03,112.55 12.99,112.59 12.99,113.37 13.22,113.59 13.22,115.3 13.76,115.3
AMP_SPK_LP on BOTTOM (solid shape): 12.8,115.23 12.8,113.63 12.75,113.58 12.75,112.94 12.69,112.89 12.07,112.89 11.97,112.98 11.97,113.72 12.2,113.95 12.2,115.26 12.78,115.26
AMP_SPK_LP on BOTTOM (solid shape): 14.18,88.49 14.51,88.49 14.55,88.45 14.55,85.28 14.38,85.11 13.64,85.11 13.61,85.14 13.61,85.88 13.85,86.12 13.85,88.5 13.89,88.54 14.12,88.54
AMP_SPK_RN on BOTTOM (solid shape): 14.81,115.28 14.81,113.19 15.04,112.95 15.04,112.29 14.9,112.15 14.43,112.15 14.21,112.37 14.21,115.3 14.79,115.3
AMP_SPK_RN on BOTTOM (solid shape): 18.18,89.63 18.18,89.21 17.98,89.01 17.98,87.13 17.78,86.93 17.78,86.31 17.69,86.22 16.85,86.22 16.85,86.22 16.85,86.79 17.23,87.16 17.23,87.93 17.32,88.18 17.23,88.44 17.23,89.35 17.64,89.76 18.05,89.76
AMP_SPK_RP on BOTTOM (solid shape): 15.8,113.81 16.04,113.57 16.04,112.64 16.04,112.63 15.29,112.63 15.29,113.17 15.21,113.25 15.21,115.28 15.22,115.29 15.8,115.29
AMP_SPK_RP on BOTTOM (solid shape): 19.02,88.55 19.02,87.96 18.82,87.76 18.82,86.92 18.95,86.79 18.95,86.32 18.9,86.27 18.09,86.27 18.09,86.77 18.21,86.9 18.21,88.03 18.88,88.7
AMP_WOF_LN_R on BOTTOM (solid shape): 197.52,31.63 197.86,31.29 199.35,31.29 199.35,31.05 197.73,31.05 197.71,31.06 197.61,31.16 196.96,31.16 196.78,31.34 196.78,32.53 196.8,32.55 197.52,32.55
AMP_WOF_LP_R on BOTTOM (solid shape): 199.32,30.81 199.32,30.62 199.31,30.61 198.81,30.61 198.4,30.19 197.03,30.19 196.97,30.25 196.97,30.71 197.09,30.84 199.3,30.84
BAT on BOTTOM (solid shape): 247.45,41.37 247.45,40.61 247.83,40.23 247.83,38.45 247.45,38.07 246.05,38.07 245.8,38.32 244.02,38.32 243.76,38.57 243.76,40.35 243.89,40.48 244.53,40.48 244.78,40.73 244.78,41.5 244.91,41.62 247.19,41.62
BOOT_C on BOTTOM (solid shape): 70.03,172.05 70.03,170.7 69.77,170.7 69.77,171.21 69.27,171.71 69.21,171.78 69.13,171.85 69.03,171.88 68.96,171.9 68.81,172.05 67.95,172.05 67.95,172.48 68.05,172.59 69.49,172.59
CHG_BST on TOP (solid shape): 225.71,27.82 225.71,27.04 225.29,26.62 224.64,26.62 223.63,26.95 223.56,26.97 223.01,26.97 222.98,26.99 222.98,27.23 224.16,27.23 224.55,27.11 224.91,27.32 225.12,27.53 225.12,27.89 225.64,27.89
CHG_BST_R on TOP (solid shape): 227.79,28.95 227.79,27.42 227.5,27.13 226.82,27.13 226.57,27.38 226.57,27.85 226.61,27.89 227.05,27.89 227.17,28.01 227.18,28.01 227.23,28.06 227.23,28.92 227.3,29 227.74,29
CHG_HG on TOP (solid shape): 224.78,27.77 224.79,27.41 224.66,27.28 224.42,27.27 223.96,27.48 223.03,27.48 222.99,27.51 222.99,27.67 223.08,27.76 223.76,27.76 224.6,27.94
CHG_HG on TOP (solid shape): 231.33,23.23 231.45,23.21 231.56,23.23 235.28,23.23 235.45,23.06 235.45,22.77 235.19,22.52 232.34,22.52 231.68,21.86 231.68,21.14 231.47,20.92 230.81,20.92 230.8,20.93 230.67,20.93 230.55,21.05 230.55,22.95 230.82,23.23
CHG_LDO on TOP (solid shape): 224.84,26.06 224.84,25.89 223.8,25.89 223,26.46 222.99,26.65 223.06,26.72 223.55,26.72
CHG_LG on TOP (solid shape): 230.66,11.66 230.66,11.28 230.15,10.77 228.02,10.77 228.02,11.92 230.4,11.92
CHG_LG on TOP (solid shape): 222.81,26.15 223.63,25.77 223.63,25.37 223.36,25.1 223.19,25.1 222.6,25.62 222.6,26.04 222.72,26.16 222.8,26.16
CHG_LX on TOP (solid shape): 226.7,28.85 226.7,28.34 226.5,28.15 224.81,28.15 224.72,28.07 224.43,28.12 224.15,27.99 223.01,27.99 223.01,28.14 223.11,28.23 223.61,28.23 224.28,28.7 224.32,28.7 224.63,29.01 224.71,29.06 226.49,29.06
CHG_LX on TOP (solid shape): 237.54,19.91 240.34,19.91 240.97,19.27 240.97,16.6 239.57,15.21 238.56,15.21 236.02,12.67 236.02,12.16 235.13,11.27 233.6,11.27 233.33,11.55 233.2,11.76 232.99,11.88 232.84,12.03 232.84,15.56 233.5,16.22 233.5,18.16 232.15,19.52 232.15,21.61 232.46,21.92 235.53,21.92
CHG_RC on TOP (solid shape): 232.94,18.05 232.94,16.96 232.69,16.71 232.28,16.71 232.26,16.73 231.95,16.73 231.19,17.49 230.33,17.49 230.28,17.54 230.28,17.95 230.44,18.11 232.89,18.11
CHG_VCC on TOP (solid shape): 224.9,30.21 225.21,30.21 225.21,29.33 225.19,29.31 224.89,29.31 224.88,29.32 223.57,28.49 223.06,28.49 223.06,28.75 223.35,29.19 223.35,29.95 224.11,30.71 224.41,30.71
DDR_BST on TOP (solid shape): 132.03,62.12 132.26,62.12 132.28,62.09 132.28,61.88 131.56,61.88 131.06,62.37 129.41,62.37 129.25,62.54 129.25,63.19 129.3,63.24 130.91,63.24
DDR_BST_R on TOP (solid shape): 130.43,66.57 130.43,64.08 129.54,64.08 129.46,64.15 129.46,66.47 129.74,66.74 130.25,66.74
DDR_HG on TOP (solid shape): 132.69,62.74 132.69,62.35 132.66,62.32 132.09,62.32 131.61,62.8 131.6,62.8 130.86,63.54 130.86,63.97 131.01,64.13 131.31,64.13
DDR_HG on BOTTOM (solid shape): 122.99,77.36 122.99,76.85 122.86,76.72 121.72,76.72 121.21,76.21 121.21,75.96 120.13,75.96 120.13,76.47 120.19,76.47 121.21,77.48 122.86,77.48
DDR_LG on TOP (solid shape): 132.94,65.54 132.94,65.14 133.19,64.89 133.6,64.12 133.84,63.88 133.84,63.09 133.79,63.04 133.67,63.04 133.38,63.32 132.46,64.49 132.46,65.55 132.58,65.66 132.82,65.66
DDR_LG on BOTTOM (solid shape): 125.28,64.86 125.28,64.27 125.53,64.02 125.78,64.02 126.04,63.77 126.04,63.39 125.78,63.13 124.99,63.13 124.1,64.02 124.1,64.94 124.13,64.98 125.16,64.98
DDR_LX on TOP (solid shape): 132.11,66.03 132.11,64.75 132.73,63.7 133.48,62.95 133.48,62.81 133.42,62.75 132.97,62.75 130.78,64.94 130.78,66.01 130.94,66.16 131.98,66.16
DDR_LX on BOTTOM (solid shape): 121.27,75.14 121.27,71.78 121.28,71.77 120.73,71.22 120.73,69.49 120.98,69.23 122.19,69.23 122.82,68.6 123.09,68.6 123.18,68.51 123.18,64.66 121.54,64.66 121.53,64.64 118.3,64.64 117.35,65.6 117.35,66.87 115.98,68.24 115.98,68.31 115.42,68.87 115.42,74.29 116.33,75.2 121.21,75.2
DDR_LX on IN2 (solid shape): 132.21,65.9 132.21,65.08 132.07,64.95 130.73,64.95 130.56,65.12 130.56,65.9 130.68,66.03 132.08,66.03
DDR_RC on BOTTOM (solid shape): 123.63,71.03 123.63,70.65 123.53,70.55 123.1,70.55 122.97,70.42 122.97,69.94 122.74,69.71 121.19,69.71 120.94,69.96 120.94,71.1 121.09,71.26 123.4,71.26
DMIC_CLK_R on TOP (solid shape): 206.7,147.57 206.7,145.86 206.32,145.48 205.34,145.48 205.12,145.7 205.12,146.04 205.34,146.25 205.75,146.25 205.94,146.44 205.94,147.24 205.44,147.74 205.44,148.07 205.65,148.28 205.99,148.28
DMIC_DATA_R on TOP (solid shape): 206.16,149.17 207.08,149.17 207.19,149.28 208.16,149.28 208.47,148.96 208.47,147.79 208.26,147.58 207.9,147.58 207.71,147.77 207.71,148.42 207.62,148.51 205.58,148.51 205.43,148.66 205.43,149.13 205.58,149.28 206.05,149.28
FBX_PLL_AVDD on TOP (solid shape): 120.69,151.1 120.69,150.36 120.67,150.28 120.66,150.17 120.69,150.05 120.69,150.04 120.69,149.41 120.65,149.36 120.2,149.36 119.81,149.75 119.52,149.75 119.3,149.96 119.3,150.19 120.27,151.16 120.64,151.16
GPU_PLLVDD on TOP (solid shape): 94.47,167.23 94.56,167.15 94.66,167.09 94.67,167.09 94.86,166.91 94.88,166.91 94.89,166.89 95.92,166.89 96.05,166.84 96.19,166.82 97.55,166.82 98.13,166.24 98.13,165.55 97.98,165.55 97.97,165.56 97.59,165.61 97.36,165.31 97.35,165.29 97.18,165.11 95.3,165.11 94.31,166.11 93.75,166.11 93.65,166.21 93.65,167.23
HDA_SPKR_LN on BOTTOM (solid shape): 15.71,84.21 15.71,83.66 15.01,82.97 14.64,82.97 14.28,83.33 14.84,83.89 14.87,83.89 14.91,83.93 14.91,84.26 15.66,84.26
HDA_SPKR_LN on BOTTOM (solid shape): 13.71,80.74 13.71,79.76 12.96,79.01 12.81,78.96 12.7,78.86 12.06,78.86 11.88,79.04 11.88,79.48 12.02,79.62 12.05,79.61 12.49,79.63 12.74,79.99 12.88,80.13 12.88,80.78 13,80.9 13.55,80.9
HDA_SPKR_LN on IN4 (solid shape): 12.62,79.42 12.62,79.05 11.88,78.31 11.87,78.31 11.3,78.87 11.3,78.89 11.96,79.55 12.49,79.55
HDA_SPKR_LP on BOTTOM (solid shape): 14.46,84.21 14.46,83.76 14.36,83.76 13.71,83.11 13.27,83.11 13.14,83.24 13.14,83.7 13.56,84.12 13.56,84.25 13.57,84.25 14.42,84.25
HDA_SPKR_LP on BOTTOM (solid shape): 12.61,81.8 12.61,81 12.61,80.99 12.61,80.1 12.36,79.86 11.87,79.86 11.82,79.92 11.82,81.11 11.82,81.12 11.82,81.73 11.92,81.84 12.58,81.84
HDA_SPKR_LP on IN4 (solid shape): 12.6,80.33 12.6,80.03 12.28,79.71 11.37,79.71 11.33,79.75 11.33,80.34 11.52,80.53 12.4,80.53
HDA_SPKR_RN on BOTTOM (solid shape): 17.73,85.33 17.73,84.89 17.7,84.86 17.57,84.86 17.44,84.72 17.44,84.36 17.37,84.29 16.65,84.29 16.65,84.29 16.65,85.21 16.83,85.38 17.67,85.38
HDA_SPKR_RN on BOTTOM (solid shape): 15.27,82.05 15.27,80.21 15.08,80.14 14.95,79.99 14.57,79.99 14.34,80.21 14.34,81.57 15.04,82.27
HDA_SPKR_RN on IN4 (solid shape): 15.19,80.71 15.19,80.34 15.01,80.16 14.63,80.16 13.84,80.94 14.13,81.23 14.67,81.23
HDA_SPKR_RP on BOTTOM (solid shape): 18.97,85.28 18.97,85.02 18.46,84.5 18.46,83.75 17.9,83.75 17.66,83.99 17.66,84.61 17.79,84.74 17.87,84.74 17.87,85.11 18.17,85.41 18.84,85.41
HDA_SPKR_RP on BOTTOM (solid shape): 16.65,81.86 16.65,81.35 16.61,81.35 16.34,81.08 16.35,81.07 16.35,80.92 16.12,80.69 16.12,80.36 16.1,80.34 15.84,80.08 15.57,80.08 15.53,80.12 15.47,80.16 15.44,80.19 15.44,81.22 16.36,82.15
HDA_SPKR_RP on IN4 (solid shape): 16.07,81.23 16.07,80.5 16.06,80.42 16.07,80.34 16.07,80.19 15.94,80.06 15.65,80.06 15.58,80.08 15.52,80.13 15.45,80.17 15.42,80.18 15.37,80.2 15.32,80.25 15.32,81.58 15.52,81.79
HDMI_SE_STBY_OFF_CK on TOP (solid shape): 253.54,95.85 253.54,94.84 253.42,94.71 252.15,94.71 251.89,94.96 251.89,95.98 253.42,95.98
HDMI_SE_STBY_OFF_CK on IN4 (solid shape): outline of 145 points within 252.15,83.28 253.92,101.44
LAN_GND on TOP (solid shape): 258.13,149.02 258.13,148.69 258.65,148.17 259.59,148.17 259.59,145.82 259.08,145.31 257.45,145.31 256.21,146.55 256.21,148.99 256.46,149.24 257.91,149.24
LAN_GND on TOP (solid shape): 255.72,134.67 255.72,134.67 255.91,134.67 258.35,132.23 258.35,131.53 257.95,131.12 257.56,131.12 253.87,134.82 253.87,135.11 254.13,135.36 255.03,135.36
LAN_GND on TOP (solid shape): 270.14,147.71 262.22,147.71 262.06,147.92 261.85,148.08 260.48,147.7 260.84,146.33 260.84,131.47 260.34,130.61 260.82,129.74 260.82,129.74 261.35,129.59 261.88,129.74 262.07,129.9 262.22,130.09 270.14,130.09 270.14,128.95 269.64,128.95 269.64,129.59 267.06,129.59 266.65,129.18 264.86,129.18 264.45,129.59 262.47,129.59 262.45,129.56 260.68,129.24 259.85,130.83 260.02,131.32 260.34,131.72 260.34,146.08 260.1,148.06 262.04,148.55 269.64,148.55 269.64,149.37 270.14,149.37
LAN_GND on BOTTOM (solid shape): 248.21,148.46 248.21,137.33 249.09,136.45 253.07,136.45 253.27,136.25 253.27,136.01 253.23,135.98 248.24,135.98 247.27,136.95 247.27,141.25 247.46,141.44 247.46,142.56 247.45,142.56 247.45,142.71 247.19,142.97 247.19,148.61 247.32,148.73 247.93,148.73
LAN_GND on BOTTOM (solid shape): 270.14,147.71 262.22,147.71 262.06,147.92 261.85,148.08 260.48,147.7 260.84,146.33 260.84,131.47 260.34,130.61 260.82,129.74 260.82,129.74 261.35,129.59 261.88,129.74 262.07,129.9 262.22,130.09 270.14,130.09 270.14,128.95 269.64,128.95 269.64,129.59 267.06,129.59 266.65,129.18 264.86,129.18 264.45,129.59 262.47,129.59 262.45,129.56 260.68,129.24 259.85,130.83 260.02,131.32 260.34,131.72 260.34,146.08 260.22,148.21 262.36,148.33 262.42,148.27 262.47,148.21 264.8,148.21 265.23,148.64 266.64,148.64 267.07,148.21 269.64,148.21 269.64,149.37 270.14,149.37
LAN_GND on GND1 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.04,128.88 269.04,128.87 259.75,128.87 252.76,135.9 248.19,135.9 247.19,136.9 247.19,149.12 247.42,149.32 257.84,149.32 258.12,149.04 258.12,148.81 258.12,148.76 258.13,148.72 258.13,148.69 258.65,148.17 259.8,148.17 259.87,148.2 259.92,148.23 261.05,149.07 261.44,149.36 261.45,149.37 270.14,149.37
LAN_GND on IN1 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.64,128.88 269.64,129.59 266.78,129.59 266.41,129.21 264.74,129.21 264.36,129.59 262.47,129.59 260.33,129.49 260.24,131.63 260.29,131.68 260.34,131.72 260.34,146.08 260.28,148.27 262.47,148.21 264.39,148.21 264.9,148.72 266.39,148.72 266.9,148.21 269.64,148.21 269.64,149.37 270.14,149.37
LAN_GND on GND2 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.04,128.88 269.04,128.87 259.75,128.87 252.76,135.9 248.19,135.9 247.19,136.9 247.19,149.12 247.42,149.32 257.84,149.32 258.12,149.04 258.12,148.81 258.12,148.76 258.13,148.72 258.13,148.69 258.65,148.17 259.8,148.17 259.87,148.2 259.92,148.23 261.05,149.07 261.44,149.36 261.45,149.37 270.14,149.37
LAN_GND on IN2 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 262.55,128.88 262.13,129.3 260.17,129.65 260.24,131.63 260.29,131.68 260.34,131.72 260.34,146.08 260.28,148.27 262.47,148.21 264.31,148.21 264.97,148.87 266.68,148.87 267.34,148.21 269.64,148.21 269.64,149.37 270.14,149.37
LAN_GND on IN3 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.64,128.88 269.64,129.59 266.9,129.59 266.52,129.2 264.95,129.2 264.57,129.59 262.47,129.59 260.33,129.49 260.24,131.63 260.29,131.68 260.34,131.72 260.34,146.08 260.28,148.27 262.47,148.21 264.49,148.21 264.97,148.69 266.33,148.69 266.81,148.21 269.64,148.21 269.64,149.37 270.14,149.37
LAN_GND on GND3 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.04,128.88 269.04,128.87 259.75,128.87 252.76,135.9 248.19,135.9 247.19,136.9 247.19,149.12 247.42,149.32 257.84,149.32 258.12,149.04 258.12,148.81 258.12,148.76 258.13,148.72 258.13,148.69 258.65,148.17 259.8,148.17 259.87,148.2 259.92,148.23 261.05,149.07 261.44,149.36 261.45,149.37 270.14,149.37
LAN_GND on IN4 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.64,128.88 269.64,129.59 266.85,129.59 266.44,129.18 264.93,129.18 264.52,129.59 262.47,129.59 260.33,129.49 260.24,131.63 260.29,131.68 260.34,131.72 260.34,146.08 260.28,148.27 262.47,148.21 264.26,148.21 264.67,148.62 266.79,148.62 267.2,148.21 269.64,148.21 269.64,149.37 270.14,149.37
LAN_GND on GND4 (solid shape): 270.14,147.71 262.22,147.71 260.64,147.91 260.84,146.33 260.84,131.47 260.64,129.89 262.22,130.09 270.14,130.09 270.14,128.88 269.04,128.88 269.04,128.87 259.75,128.87 252.76,135.9 248.19,135.9 247.19,136.9 247.19,149.12 247.42,149.32 257.84,149.32 258.12,149.04 258.12,148.81 258.12,148.76 258.13,148.72 258.13,148.69 258.65,148.17 259.8,148.17 259.87,148.2 259.92,148.23 261.05,149.07 261.44,149.36 261.45,149.37 270.14,149.37
PEX_PLLVDD_1 on TOP (solid shape): 99.66,142.43 99.66,139.28 99.47,139.08 97.51,139.08 97.46,139.13 97.46,139.61 97.54,139.69 98.45,139.69 98.73,139.97 98.73,142.02 99.2,142.49 99.6,142.49
PH1_A on TOP (solid shape): outline of 128 points within 41.07,162.27 48.13,171.63
PH1_A on BOTTOM (solid shape): 47.8,168.95 47.8,168.09 47.37,167.65 44.37,167.65 44.25,167.78 44.25,168.92 44.37,169.05 47.7,169.05
PH1_B on TOP (solid shape): outline of 129 points within 2.08,153.07 12.62,163.34
PH2_A on TOP (solid shape): outline of 139 points within 28.82,163.17 35.82,171.76
PH2_A on BOTTOM (solid shape): 35.48,170.83 35.48,168.95 35.23,168.7 33.61,168.7 33.45,168.86 33.45,170.83 33.71,171.08 35.23,171.08
PH2_B on TOP (solid shape): 25.32,167.87 25.32,166.64 26.56,165.4 26.56,161.37 26.23,161.04 24,161.04 23.92,161.08 23.9,161.17 23.84,161.55 23.49,161.68 23.46,161.68 23.24,161.9 23.24,162.26 23.48,162.26 23.48,162.74 23.36,162.74 23.36,162.79 22.72,162.79 22.72,162.74 22.59,162.74 22.59,162.26 22.83,162.26 22.83,161.68 22.8,161.67 22.57,161.48 22.55,161.17 22.54,161.08 22.46,161.04 20.15,161.04 19.48,161.7 19.48,163.44 19.2,163.72 19.2,163.72 19.2,166.93 19.27,167.01 19.55,167.01 19.55,166.26 19.72,166.26 19.72,167.01 20.05,167.01 20.05,166.26 20.22,166.26 20.22,167.01 20.55,167.01 20.55,166.26 20.72,166.26 20.72,167.01 21.05,167.01 21.05,166.26 21.22,166.26 21.22,167.01 21.55,167.01 21.55,166.26 21.72,166.26 21.72,167.01 22.05,167.01 22.05,166.26 22.22,166.26 22.22,167.01 22.55,167.01 22.55,166.26 22.72,166.26 22.72,167.01 23.07,167.01 23.24,167.17 23.24,167.46 23.98,167.46 23.98,167.64 23.24,167.64 23.24,167.96 23.98,167.96 23.98,168.14 23.24,168.14 23.24,168.45 24.74,168.45
PH2_B on BOTTOM (solid shape): 22.59,166.84 22.59,163.73 22.5,163.64 21.54,163.64 21.44,163.74 21.44,166.84 21.7,167.09 22.33,167.09
PH3_A on TOP (solid shape): outline of 147 points within 60.12,158.72 69.65,167.41
PH_C on BOTTOM (solid shape): 69.52,168.78 69.22,168.78 68.67,168.23 68.67,167.08 69.32,166.44 70.28,166.44 70.54,166.18 70.54,165.85 70.4,165.71 68.42,165.71 67.89,166.24 67.89,168.66 68.41,168.66 69.05,169.31 69.52,169.31
PH_C on BOTTOM (solid shape): 83.49,175.15 83.49,172.35 84.38,171.46 85.52,171.46 85.78,171.21 85.78,168.8 86.03,168.54 87.81,168.54 87.81,167.91 86.41,167.91 85.49,166.99 85.49,166.73 85.33,166.56 80.87,166.56 80.19,165.88 78.28,165.88 77.9,166.26 77.9,171.98 78.36,172.44 80.61,172.44 81.33,173.16 81.33,174.49 81.57,174.73 81.51,175.07 81.71,175.27 83.36,175.27
SURGE_IN_C on IN1 (solid shape): 245.27,146.26 245.27,138.64 244.7,138.07 244.02,138.07 243.52,138.57 243.52,145.75 241.64,147.63 240,147.63 239.89,147.75 239.89,148.93 240.04,149.08 242.45,149.08
SURGE_OUT_C on TOP (solid shape): 255.7,149.06 255.7,146.91 255.58,146.78 255.07,146.78 254.94,146.91 254.94,147.59 254.76,147.77 254.46,147.77 254.18,148.05 254.18,148.94 254.43,149.19 255.58,149.19
VCLK on TOP (solid shape): 247.45,68.75 247.45,67.07 247.27,66.89 245.02,66.89 244.74,67.17 244.74,68.25 245.31,68.82 247.37,68.82
VGA_BST1 on BOTTOM (solid shape): 148.9,85.23 149.36,84.71 150.55,83.53 150.55,82.87 150.3,82.87 148.69,84.48 148.16,84.48 148.16,85.23 148.23,85.31 148.83,85.31
VGA_BST1_R on BOTTOM (solid shape): 147.44,85.1 147.64,85.1 147.68,85.06 147.68,84.6 147.61,84.54 146.8,84.54 146.19,83.93 146.19,83.37 145.97,83.15 145.47,83.15 145.34,83.28 145.34,84.03 145.43,84.12 145.43,85.05 146,85.05 146,84.99 146.01,84.94 146.03,84.89 146.06,84.84 146.1,84.79 146.14,84.76 146.18,84.72 146.23,84.7 146.28,84.68 146.34,84.67 146.39,84.67 146.45,84.67 146.5,84.69 146.56,84.71 146.6,84.74 146.65,84.77 146.68,84.82 146.71,84.86 146.74,84.91 146.75,84.97 146.76,85.02 146.76,85.08 146.75,85.13 146.74,85.19 146.71,85.24 146.68,85.28 146.65,85.32 146.6,85.36 146.56,85.39 146.5,85.41 146.45,85.43 146.39,85.43 146.34,85.43 146.28,85.42 146.23,85.4 146.18,85.38 146.14,85.34 146.1,85.3 146.06,85.26 146.03,85.21 146.01,85.16 146,85.11 146,85.05 145.43,85.05 145.43,85.79 145.7,86.06 146.48,86.06
VGA_BST2 on BOTTOM (solid shape): 150.57,79.13 150.44,79.13 149.17,77.86 149.04,77.73 147.15,77.73 147.09,77.79 147.09,78.4 147.16,78.47 148.98,78.47 150.11,79.6 150.57,79.6
VGA_BST2_R on BOTTOM (solid shape): 146.58,78.23 146.58,77.57 144.37,77.57 144.2,77.74 144.2,78.17 144.38,78.35 146.46,78.35
VGA_BST3 on TOP (solid shape): 145.47,94.72 145.47,94.7 145.83,94.33 145.83,91.94 145.48,91.58 144.57,91.58 144.56,91.6 144.56,92.21 144.83,92.49 144.83,94.85 145.33,94.85
VGA_BST3_R on TOP (solid shape): 143.31,95.06 143.31,94.68 143.25,94.63 142.8,94.63 142.67,94.5 142.67,92.8 143.25,92.22 143.61,92.22 143.62,92.22 144.02,92.22 144.06,92.18 144.06,91.6 144,91.54 142.83,91.54 141.78,92.58 141.78,94.63 142.29,95.14 143.23,95.14
VGA_DDR_BST1 on TOP (solid shape): 178.28,84.09 178.28,83.51 176.89,82.11 176.23,82.11 176.2,82.14 176.2,82.67 176.23,82.69 176.56,82.69 178,84.14 178.23,84.14
VGA_DDR_BST1_R on TOP (solid shape): 175.76,83.51 175.76,82.19 175.68,82.11 174.63,82.11 174.5,82.24 174.5,83.48 174.6,83.58 175.68,83.58
VGA_DDR_HG1 on TOP (solid shape): 178.71,84.32 178.71,83.51 179.27,82.94 179.27,82.64 178.67,82.04 177.71,82.04 177.64,82.11 177.64,82.52 178.48,83.36 178.48,84.31 178.49,84.32 178.7,84.32
VGA_DDR_HG1 on BOTTOM (solid shape): 175.39,90.11 175.39,89.02 175.26,88.89 174.4,88.89 174.09,89.2 174.09,90.13 174.24,90.29 175.21,90.29
VGA_DDR_HG1_R on TOP (solid shape): 168.83,87.47 168.83,86.58 168.71,86.45 168.45,86.45 168.2,86.71 166.93,86.71 166.8,86.83 166.8,87.47 166.93,87.6 168.71,87.6
VGA_DDR_HG1_R on BOTTOM (solid shape): 169.98,87.98 169.98,87.85 169.6,87.47 169.6,86.58 168.96,86.58 168.71,86.33 168.45,86.33 168.26,86.52 168.26,87.79 168.71,88.23 169.72,88.23
VGA_DDR_HG1_R on BOTTOM (solid shape): 173.53,89.88 173.53,88.49 173.39,88.35 172.66,88.35 172.52,88.49 172.52,89.12 172.64,89.25 172.72,89.25 172.85,89.37 172.85,89.73 173.08,89.96 173.46,89.96
VGA_DDR_LG1 on TOP (solid shape): 167.82,81.37 168.96,81.37 169.09,81.25 169.09,80.74 168.96,80.61 167.18,80.61 166.93,80.87 166.93,81.63 167.06,81.75 167.44,81.75
VGA_DDR_LG1 on TOP (solid shape): 176.75,85.07 177.92,85.07 177.95,85.05 177.95,84.89 177.9,84.85 176.09,84.85 175.96,84.72 175.53,84.72 175.35,84.9 175.35,85.39 175.1,85.64 175.1,85.98 175.26,86.14 175.68,86.14
VGA_DDR_LG1 on BOTTOM (solid shape): 169.85,81.37 169.85,80.74 169.72,80.61 168.37,80.61 168.2,80.78 168.2,81.25 168.33,81.37 169.22,81.37 169.34,81.5 169.72,81.5
VGA_DDR_LG1 on IN4 (solid shape): 170.23,81.35 170.23,80.47 170.22,80.47 169.98,80.41 169.8,80.24 168.51,80.24 168.2,80.55 168.2,81.11 168.58,81.49 170.09,81.49
VGA_DDR_LX1 on TOP (solid shape): 170.36,84.93 170.36,82.72 170.62,82.45 172.96,82.45 173.03,82.39 173.03,81.75 172.9,81.63 167.95,81.63 167.56,82.01 162.61,82.01 162.48,82.14 162.48,84.8 162.61,84.93 168.33,84.93 168.58,85.18 170.1,85.18
VGA_DDR_LX1 on TOP (solid shape): 177.97,84.65 177.97,84.46 176.53,83.02 176.25,83.02 176.23,83.05 176.23,83.53 176.07,83.69 175.9,83.69 175.84,83.74 175.54,83.74 175.34,83.94 175.34,84.4 175.46,84.52 177.24,84.52 177.34,84.62 177.34,84.65 177.36,84.67 177.95,84.67
VGA_DDR_LX1 on BOTTOM (solid shape): 169.3,84.76 173.19,84.76 173.41,84.55 173.41,82.14 173.03,81.75 168.96,81.75 168.83,81.63 168.33,81.63 167.88,81.18 167.88,79.66 167.69,79.47 161.09,79.47 160.83,79.72 160.83,84.04 160.85,84.05 160.85,84.63 161.17,84.95 169.11,84.95
VGA_DDR_RC1 on TOP (solid shape): 171.88,85.06 171.88,82.9 171.76,82.77 170.56,82.77 170.52,82.81 170.52,83.23 171.12,83.83 171.12,85.11 171.13,85.12 171.82,85.12
VGA_HG1 on TOP (solid shape): 117.65,85.06 117.66,85.06 117.66,84.78 117.92,84.52 117.92,84.31 117.78,84.17 116.76,84.17 116.38,84.54 116.38,84.93 116.64,85.19 117.52,85.19
VGA_HG1 on BOTTOM (solid shape): 150.92,84.54 151.07,83.66 151.07,82.95 151.03,82.91 150.85,82.91 150.79,82.96 150.79,83.38 150.51,84.02 150.51,84.02 148.86,85.66 147.53,85.66 147.34,85.85 147.34,86.4 147.51,86.57 148.9,86.57
VGA_HG1 on IN2 (solid shape): 147.8,86.4 147.8,85.92 147.55,85.67 145.51,85.67 145.36,85.82 145.36,86.3 145.61,86.56 147.65,86.56
VGA_HG1_R on TOP (solid shape): 118.05,83.64 118.05,83.01 118.23,82.83 120.23,82.83 120.27,82.8 120.27,82.29 120.21,82.22 117.69,82.22 117.38,82.54 117.38,83.68 118,83.68
VGA_HG2 on TOP (solid shape): 124.05,89.81 124.05,89.55 124.04,89.44 124.05,89.32 124.05,88.94 123.93,88.81 123.42,88.81 123.16,89.06 123.16,89.92 123.36,90.11 123.75,90.11
VGA_HG2 on BOTTOM (solid shape): 151.11,79.75 151.11,78.73 149.51,77.13 149.51,76.89 149.08,76.46 147.24,76.46 147.05,76.65 147.05,77.35 147.18,77.48 149.02,77.48 149.49,77.94 149.63,78.08 150.41,78.86 150.56,78.86 150.81,79.11 150.81,79.75 150.85,79.79 151.07,79.79
VGA_HG2 on IN2 (solid shape): 148.41,78.14 148.41,77.15 148.33,77.06 147.34,77.06 147.18,77.22 147.18,77.95 147.44,78.2 148.35,78.2
VGA_HG2_R on TOP (solid shape): 125.46,88.02 127.16,88.02 127.31,87.87 127.31,86.67 126.72,86.67 126.72,87.11 126.58,87.25 125.24,87.25 124.78,87.7 123.4,87.7 123.26,87.85 123.26,87.98 123.31,88.04 123.31,88.34 125.14,88.34
VGA_HG3 on TOP (solid shape): 145.35,95.35 145.35,95.13 145.32,95.1 144.79,95.1 144.65,94.96 144.65,94.44 143.94,93.74 143.34,93.74 143.34,94.13 143.8,94.59 143.8,94.92 144.23,95.35 145.34,95.35
VGA_HG3_R on TOP (solid shape): 151.18,105.87 151.05,105.75 149.92,105.75 149.78,105.88 149.78,106.77 149.91,106.9 151.18,106.9
VGA_HG3_R on TOP (solid shape): 144.58,93.41 144.58,92.6 144.45,92.47 143.89,92.47 143.43,92.93 143.43,93.23 143.94,93.23 144.2,93.49 144.49,93.49
VGA_HG3_R on IN4 (solid shape): 151.87,106.57 151.87,105.94 151.61,105.68 150.12,105.68 149.86,105.94 149.86,106.63 150.11,106.88 151.56,106.88
VGA_HG3_R on IN4 (solid shape): 145.78,93.37 145.78,92.65 145.37,92.24 144.34,92.24 144.07,92.5 144.07,93.46 144.35,93.74 145.42,93.74
VGA_LG1 on TOP (solid shape): 110.92,87.6 110.92,86.71 110.8,86.58 109.27,86.58 109.14,86.71 109.14,87.47 109.4,87.72 110.8,87.72
VGA_LG1 on TOP (solid shape): 115.59,86.63 117.24,86.63 117.49,86.37 117.49,85.96 117.27,85.74 115.33,85.74 114.7,86.37 114.7,86.88 115.33,86.88
VGA_LG1 on BOTTOM (solid shape): 110.41,87.64 110.41,86.5 110.29,86.37 109.2,86.37 109.08,86.5 109.08,87.65 109.2,87.77 110.29,87.77
VGA_LG1 on BOTTOM (solid shape): 118.58,86.36 118.78,86.36 119.12,86.02 119.12,85.48 118.99,85.36 117.85,85.36 117.61,85.6 116.78,85.6 116.29,86.09 116.29,86.31 116.48,86.5 118.44,86.5
VGA_LG1 on BOTTOM (solid shape): 149.45,82.22 150.06,82.22 150.06,81.97 149.96,81.87 148.2,81.87 148.13,81.81 147.73,81.81 147.51,82.02 147.51,82.56 147.39,82.68 147.39,83.06 147.57,83.23 148.23,83.23
VGA_LG1 on IN2 (solid shape): 111.2,87.03 111.2,86.78 110.95,86.52 109.3,86.52 109.08,86.74 109.08,87.52 109.24,87.68 110.56,87.68
VGA_LG1 on IN2 (solid shape): 148.64,83.02 148.64,82.09 148.51,81.96 147.5,81.96 147.22,82.24 147.22,83.05 147.4,83.23 148.44,83.23
VGA_LG2 on TOP (solid shape): 126.16,80.61 126.16,80.1 126.04,79.98 125.15,79.98 125.02,80.1 125.02,80.99 125.15,81.12 125.65,81.12
VGA_LG2 on TOP (solid shape): 131.62,80.84 131.62,79.9 131.51,79.79 130.48,79.79 130.23,80.04 130.23,80.8 130.35,80.93 131.53,80.93
VGA_LG2 on BOTTOM (solid shape): 126.3,81 126.3,79.99 125.42,79.99 125.03,80.06 125.03,81 125.16,81.12 126.18,81.12
VGA_LG2 on BOTTOM (solid shape): 132.39,80.79 132.39,79.78 131.5,79.78 131.12,79.85 131.12,80.79 131.24,80.91 132.26,80.91
VGA_LG2 on BOTTOM (solid shape): 150.12,80.66 150.12,80.44 150.08,80.41 149.48,80.41 148.88,79.81 147.71,79.81 147.71,79.81 146.9,79.81 146.71,80 146.71,80.41 146.86,80.56 147.24,80.56 147.38,80.42 148.06,80.42 148.06,80.41 148.6,80.41 148.61,80.42 148.98,80.42 149.03,80.48 149.17,80.56 149.26,80.68 150.1,80.68
VGA_LG2 on IN2 (solid shape): 133.02,80.35 133.02,79.64 131.95,79.64 131.83,79.76 131.24,79.76 131.12,79.89 131.12,80.91 132.45,80.91
VGA_LG2 on IN2 (solid shape): 149.1,80.28 149.1,79.75 148.93,79.58 146.9,79.58 146.77,79.7 146.77,80.33 146.86,80.42 148.96,80.42
VGA_LG3 on TOP (solid shape): 148.59,95.84 148.59,95.53 148.53,95.48 147.36,95.48 147.25,95.59 146.62,95.59 146.61,95.6 146.61,95.85 147.35,95.85 147.6,96.1 148.33,96.1
VGA_LG3 on BOTTOM (solid shape): 155.88,98.52 155.63,98.26 154.48,98.26 154.36,98.39 154.36,99.53 154.61,99.79 155.88,99.79
VGA_LG3 on BOTTOM (solid shape): 157.66,102.68 157.66,101.95 157.53,101.82 156.64,101.82 156.52,101.95 156.52,102.7 157.64,102.7
VGA_LG3 on BOTTOM (solid shape): 156.21,110.46 156.21,109.39 156.07,109.25 155.06,109.25 154.97,109.34 154.97,110.48 156.19,110.48
VGA_LG3 on IN4 (solid shape): 155.47,100.5 155.47,98.42 155.17,98.11 154.81,98.11 154.36,98.57 154.36,100.65 154.46,100.75 155.22,100.75
VGA_LG3 on IN4 (solid shape): 149.05,95.91 149.05,95.34 148.97,95.27 147.42,95.27 147.37,95.32 147.37,95.95 147.52,96.11 148.85,96.11
VGA_LG3 on IN4 (solid shape): 156.21,109.52 156.21,108.02 155.83,107.64 154.91,107.64 154.74,107.82 154.74,109.47 155.03,109.76 155.97,109.76
VGA_LX1 on TOP (solid shape): 119.91,90.03 122.71,90.03 123,89.73 123,88.51 123.02,88.5 123.02,86.87 122.78,86.62 121.1,86.62 120.65,86.17 120.65,83.9 120.32,83.57 120.3,83.58 118.87,83.58 118.54,83.92 118.54,86.41 117.89,87.06 115.68,87.06 115.37,87.38 115.37,87.9 114.86,88.41 114.1,88.41 113.84,88.66 113.84,89.88 114.57,90.61 118.84,90.61
VGA_LX1 on BOTTOM (solid shape): 149.07,83.81 150.05,82.82 150.05,82.58 150.04,82.56 150.04,82.44 149.55,82.44 149.51,82.47 148.95,82.95 148.25,83.47 147.36,83.47 147.16,83.27 146.86,83.27 146.82,83.32 146.82,84.2 146.96,84.34 148.51,84.34
VGA_LX1 on BOTTOM (solid shape): 120.57,90.06 122.58,90.06 122.84,89.8 122.84,89.25 124.38,87.7 124.38,82.52 124.89,82.01 124.89,79.72 124.64,79.47 124,79.47 123.88,79.6 123.88,80.61 122.96,81.53 120.22,81.53 119.79,81.96 119.79,86.12 119.19,86.71 115.62,86.71 115.24,87.09 115.24,87.64 114.86,88.03 114.69,88.03 114.09,88.62 109.99,88.62 109.99,88.63 109.99,92.12 109.98,92.12 109.74,92.12 109.73,92.13 109.73,93.31 109.78,93.36 114.73,93.36
VGA_LX1 on IN2 (solid shape): 148.74,84.5 148.74,83.61 148.7,83.57 146.7,83.57 146.41,83.86 146.41,84.5 146.48,84.57 148.67,84.57
VGA_LX1 on IN4 (solid shape): 122.92,90.05 122.92,87.15 122.6,86.82 115.27,86.82 113.42,88.67 113.42,89.9 113.86,90.34 122.63,90.34
VGA_LX2 on TOP (solid shape): 133.91,89.68 133.91,86.83 133.66,86.58 128.07,86.58 127.81,86.83 127.81,88.1 127.56,88.36 125.66,88.36 125.37,88.64 125.37,88.64 124.27,89.75 124.27,89.88 124.45,90.05 125.9,90.05 125.91,90.06 133.53,90.06
VGA_LX2 on BOTTOM (solid shape): 150.11,80.08 150.11,79.89 148.94,78.72 144.4,78.72 144.19,78.93 144.19,79.53 148.86,79.53 149.5,80.17 150.02,80.17
VGA_LX2 on BOTTOM (solid shape): 125.43,90.18 126.03,90.18 126.04,90.18 133.66,90.18 133.91,89.93 133.91,87.64 134.67,86.88 137.01,86.88 137.83,86.06 137.83,83.83 137.83,83.83 137.85,82.41 138.41,81.1 138.42,81.08 138.42,79.53 138.35,79.47 137.45,79.47 137.34,79.58 137.34,80.52 136.78,81.07 136.69,81.07 136.01,81.75 136,81.74 131.31,81.74 131.27,81.78 126.14,81.78 125.23,82.69 125.23,87.65 124.36,88.52 124.36,90.01 124.55,90.2 125.41,90.2
VGA_LX2 on IN4 (solid shape): 134.04,89.85 134.04,86.8 133.73,86.49 131.77,86.49 131.03,87.24 125.77,87.24 125.41,87.6 125.41,89.96 125.7,90.25 133.64,90.25
VGA_LX3 on TOP (solid shape): 144.58,95.87 144.7,95.87 144.72,95.85 145.32,95.85 145.33,95.85 145.33,95.65 145.27,95.59 144.65,95.59 144.58,95.52 142.67,95.52 142.35,95.84 142.35,96.72 142.67,97.04 143.41,97.04
VGA_LX3 on TOP (solid shape): 154.44,114.87 154.44,109.34 155.12,108.67 155.12,105.76 154.99,105.63 151.94,105.63 151.82,105.76 151.82,106.9 151.44,107.28 148.26,107.28 148.13,107.41 148.13,108.1 146.66,109.57 146.66,115.06 146.81,115.21 154.1,115.21
VGA_LX3 on BOTTOM (solid shape): 143.74,97.56 143.74,97 142.9,96.16 142.33,96.16 142.24,96.25 142.24,96.88 143.08,97.72 143.58,97.72
VGA_LX3 on BOTTOM (solid shape): 154.18,114.42 154.18,109.76 153.93,109.51 153.93,107.33 154.57,106.69 155.48,106.69 155.8,106.37 155.8,101.94 155.01,101.15 150.7,101.15 150.41,101.44 150.41,104.01 150.8,104.39 150.8,105.89 150.78,105.91 150.78,106.92 150.55,107.15 148.39,107.15 148.14,107.41 148.14,107.88 147.88,108.14 147.88,108.23 147.75,108.36 147.75,108.37 147.61,108.59 147.37,108.67 147.34,108.67 145.94,110.08 145.94,115.15 146.07,115.28 153.31,115.28
VGA_PWM on TOP (solid shape): 148.41,93.79 148.41,91.87 148.13,91.59 147.81,91.59 147.72,91.69 147.5,91.69 147.5,93.88 147.65,94.03 148.17,94.03
VGA_PWM on IN4 (solid shape): 148.06,93.95 148.06,92.57 147.63,92.15 147.22,92.15 147.06,92.31 147.06,93.92 147.29,94.15 147.85,94.15
VGA_PWM on IN4 (solid shape): 148.65,81.85 148.65,81.12 148.58,81.02 148.53,80.91 148.3,80.67 148.08,80.67 147.96,80.79 147.93,80.98 147.8,81.14 147.8,81.92 147.86,81.97 148.53,81.97
VLDOIN on TOP (solid shape): 131.44,61.72 132.63,61.72 132.68,61.67 132.68,61.48 132.63,61.43 131.92,61.24 131.9,61.23 128.91,61.23 128.83,61.31 128.83,62.1 128.91,62.17 130.99,62.17
N60425076 on TOP (solid shape): 119.58,61.84 120.14,61.84 120.32,61.65 120.32,59.09 120.17,58.93 119.68,58.93 118.34,60.27 118.34,61.75 118.79,62.2 119.21,62.2
N60425076 on BOTTOM (solid shape): 116.89,66.18 116.89,64.91 117.15,64.66 117.65,64.66 117.91,64.4 117.91,63.13 118.67,62.37 119.05,62.37 119.69,61.74 120.83,61.74 120.96,61.61 120.96,60.59 120.83,60.47 119.56,60.47 119.37,60.28 119.37,59.51 119.18,59.32 118.36,59.32 118.02,59.54 117.67,59.32 114.22,59.32 113.97,59.58 113.97,66.05 114.22,66.31 116.76,66.31
N60425240 on TOP (solid shape): 122.79,60.18 122.79,59.46 122.63,59.3 122.45,59.3 122.06,58.91 122.06,58.13 121.95,58.02 121.66,58.02 121.59,58.09 121.59,58.89 121.53,58.95 121.23,58.95 121.18,58.99 121.18,60.19 121.35,60.35 122.62,60.35
N60425541 on TOP (solid shape): 121.5,62.86 121.5,61.55 121.62,61.42 122.37,61.42 122.57,61.22 122.57,60.89 122.4,60.72 121.01,60.72 120.92,60.81 120.92,62.82 120.98,62.88 120.99,62.88 121.02,62.91 121.45,62.91
N60690738 on BOTTOM (solid shape): 122.73,79.34 121.21,79.34 120.45,80.1 120.45,80.61 120.57,80.74 122.73,80.74
N60690747 on BOTTOM (solid shape): 139.02,78.41 139.78,78.41 139.94,78.25 139.94,77.74 139.76,77.56 138.55,77.56 137.85,76.86 137.51,76.86 137.38,76.99 137.38,78.48 138.95,78.48
N65023456 on TOP (solid shape): 11.7,108.63 11.79,108.6 11.89,108.59 12.01,108.57 12.13,108.59 12.23,108.56 12.25,108.46 12.4,108.05 12.83,108.04 14.15,108.04 14.15,107.03 13.96,106.83 7.93,106.83 7.27,107.49 7.27,108.31 7.5,108.54 7.8,108.54 7.9,108.64 11.69,108.64
N125020990 on BOTTOM (solid shape): outline of 227 points within 41.12,132.7 44.05,150.64
N125034509 on BOTTOM (solid shape): outline of 272 points within 23.29,135.35 26.99,139.97
N125034565 on TOP (solid shape): 27.48,143.78 27.48,143.07 27.36,142.94 26.41,142.94 26.24,142.76 25.07,142.76 24.94,142.89 24.94,143.3 25.02,143.37 26.14,143.37 26.83,144.06 27.2,144.06
N125034565 on BOTTOM (solid shape): 25.18,144.83 25.2,144.8 25.2,144.63 25.29,144.54 26.17,144.54 26.18,144.5 26.53,144.18 26.88,144.5 26.89,144.54 27.48,144.54 27.61,144.41 27.61,143.14 27.48,143.02 25.45,143.02 25.2,142.76 25.2,142.69 25.19,142.68 25.17,142.56 25.19,142.44 25.2,142.43 25.2,141.9 25.19,141.89 25.17,141.77 25.19,141.66 25.2,141.62 25.26,141.55 25.32,141.49 25.35,141.49 25.49,141.45 25.63,141.49 25.64,141.49 25.99,141.49 26,141.49 26.14,141.45 26.28,141.49 26.29,141.49 26.46,141.49 26.49,141.47 26.59,141.37 26.59,140.73 26.47,140.6 24.94,140.6 24.86,140.69 24.85,140.7 24.77,140.85 24.62,140.93 24.61,140.94 24.48,141.06 24.47,141.11 24.47,141.17 24.22,141.42 24.22,141.44 24.13,141.62 23.96,141.72 23.93,141.73 23.93,142 24.18,142.25 24.2,142.26 24.39,142.33 24.49,142.52 24.49,142.53 24.55,142.6 24.57,142.6 24.86,142.89 24.69,143.26 24.69,144.22 24.87,144.53 24.69,144.84 24.69,145 24.7,145.01 24.74,145.04 24.78,145.07 24.94,145.07
