# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ5: length 95.6
  TOP w0.159: v2(32.59,63.29) 33.12,63.82 35.08,63.82 35.38,64.12 CON1700.8
  IN4 w0.108: v2(32.59,63.29) 32.26,63.29 30.28,65.27 30.28,65.74 30.38,65.83 30.48,65.83 30.58,65.93 30.58,66.07 30.48,66.17 30.38,66.17 30.28,66.27 30.28,66.41 30.38,66.51 30.48,66.51 30.58,66.61 30.58,66.75 30.48,66.84 30.38,66.84 30.28,66.94 30.28,70.09 28.29,72.09 28.29,79.65 25.63,82.31 25.63,82.95 25.35,83.22 25.21,83.22 25.04,83.04 24.9,83.04 24.8,83.14 24.8,83.28 24.98,83.46 24.98,83.6 24.88,83.7 24.74,83.7 24.56,83.52 24.42,83.52 24.32,83.62 24.32,83.76 24.5,83.94 24.5,84.08 24.4,84.17 24.26,84.17 24.08,84 23.94,84 23.85,84.09 23.85,84.23 24.02,84.41 24.02,84.55 14.42,94.15 14.42,126.76 17.96,130.29 17.96,131.14 18.89,132.08 19.38,132.08 19.49,131.97 v6(20.42,131.97)
  BOTTOM w0.076: v6(20.42,131.97) 20.62,131.97 20.65,132.01 22.87,132.01 23.34,131.54 U0300.BN11
  BOTTOM w0.159: v2(32.59,63.29) 32.59,62.71 32.41,62.53 32.01,62.53 31.71,62.83 31.71,63.93 32.13,64.35 CON1701.3 ; v1(19.49,131.91) 20.36,131.91 v6(20.42,131.97)
M_CHB_DQ6: length 92.8
  TOP w0.159: v2(36.42,62.5) 36.65,62.74 36.65,63.11 37.38,63.83 CON1700.16
  IN4 w0.076: v6(20.03,129.97) 20.03,129.41 18.44,127.83
  IN4 w0.108: 18.44,127.83 16.93,126.31 16.93,120.52 16.81,120.41 16.81,95.64 30.53,81.91 30.53,81.54 30.63,81.44 30.97,81.44 31.06,81.34 31.06,81.2 30.97,81.1 30.63,81.1 30.53,81.01 30.53,80.87 30.63,80.77 31.33,80.77 31.41,80.69 31.41,80.5 31.34,80.43 30.63,80.43 30.53,80.33 30.53,80.19 30.63,80.09 31.35,80.09 31.41,80.03 31.41,79.83 31.34,79.76 30.63,79.76 30.53,79.66 30.53,79.52 30.63,79.42 31.29,79.42 31.41,79.3 31.41,79.16 31.34,79.08 30.63,79.08 30.53,78.99 30.53,78.05 34.43,74.16 34.43,71.9 33.76,71.23 33.76,70.46 33.47,70.18 33.47,66.53 33.47,65.5 33.53,65.44 34.01,64.96 34.28,64.96 35.38,63.85 35.38,63.75 36.42,62.71 v2(36.42,62.5)
  BOTTOM w0.076: U0300.BP8 22.57,130.28 20.76,130.28 20.64,130.16 20.21,130.16 v6(20.03,129.97)
  BOTTOM w0.159: CON1701.21 36.63,63.54 36.12,63.04 36.12,62.7 36.32,62.5 v2(36.42,62.5)
M_CHB_DQ7: length 94.7
  TOP w0.159: v2(36.41,61.89) 36.88,61.89 37.04,62.05 37.04,62.86 38.38,64.2 CON1700.20
  IN4 w0.076: 18.52,127.62 20.48,129.58 v6(20.48,130.55)
  IN4 w0.108: v2(36.41,61.89) 36.41,61.7 36.53,61.58 36.85,61.58 36.93,61.66 36.93,62.78 35.82,63.89 35.82,63.9 34.41,65.3 34.15,65.3 33.8,65.64 33.8,66.12 33.8,70.04 34.09,70.32 34.09,71.09 34.76,71.76 34.76,74.3 31.75,77.31 31.75,78.2 31.65,78.3 30.99,78.3 30.89,78.4 30.89,78.54 30.99,78.64 31.65,78.64 31.75,78.73 31.75,81.17 17.14,95.78 17.14,121.28 17.89,122.03 17.89,123.96 17.63,124.22 17.63,126.74 18.52,127.62
  BOTTOM w0.076: U0300.BN8 23.49,129.96 23,130.45 20.58,130.45 v6(20.48,130.55)
  BOTTOM w0.159: v2(36.41,61.89) 36.14,61.89 35.19,62.84 35.19,63.31 35.39,63.52 35.97,63.52 36.09,63.64 36.09,63.85 35.63,64.32 CON1701.17
M_CHB_DQ8: length 94.3
  TOP w0.159: CON1700.28 40.38,64.35 40.22,64.2 40.15,64.2 37.94,61.99 v2(37.72,61.99) ; v6(24.51,131.93) 24.51,131.44 v1(24.66,131.28)
  IN4 w0.076: v6(24.51,131.93) 24.51,131.27 23.91,130.66 21.91,130.66 18.64,127.39
  IN4 w0.108: v2(37.72,61.99) 37.72,61.83 37.63,61.74 37.39,61.74 37.26,61.87 37.26,62.92 36.15,64.03 36.15,64.03 34.14,66.05 34.14,69.9 34.43,70.19 34.43,70.95 35.1,71.62 35.1,74.49 32.09,77.51 32.09,81.31 17.69,95.7 17.69,121.28 18.09,121.68 18.09,124.04 17.83,124.3 17.83,126.58 18.64,127.39
  BOTTOM w0.076: U0300.BL12 24.51,132 v6(24.51,131.93)
  BOTTOM w0.159: CON1701.25 37.63,64.09 37.5,63.96 37.2,63.96 37.01,63.78 37.01,62.01 37.19,61.84 37.57,61.84 v2(37.72,61.99)
M_CHB_DQ9: length 92.7
  TOP w0.159: CON1700.24 39.38,63.97 38.03,62.63 v2(37.72,62.63)
  IN4 w0.076: 18.29,124.4 18.29,125.43 18.83,125.97 18.83,126.02 19.16,126.35 19.16,126.84 19.09,126.91 19.09,127.57 22,130.47 23.95,130.47 24.79,131.32 24.79,131.4 v6(25.31,131.92)
  IN4 w0.108: v2(37.72,62.63) 37.64,62.7 37.64,63.02 36.49,64.17 36.49,64.17 35,65.66 35,66.22 35,68.3 34.9,68.41 34.61,68.41 34.5,68.52 34.5,68.79 34.61,68.9 34.9,68.9 35,69.01 35,69.28 34.9,69.39 34.61,69.39 34.5,69.49 34.5,69.77 34.61,69.88 34.9,69.88 35,69.98 35,70.97 35.2,71.16 35.44,71.4 35.44,74.63 34.06,76.01 34.06,76.15 34.15,76.24 34.15,76.38 34.05,76.48 33.92,76.48 33.82,76.39 33.68,76.39 33.59,76.49 33.59,76.62 33.68,76.72 33.68,76.86 33.58,76.95 33.44,76.95 33.35,76.86 33.21,76.86 33.11,76.96 33.11,77.1 33.2,77.19 33.2,77.33 33.1,77.43 32.96,77.43 32.87,77.34 32.73,77.34 32.42,77.65 32.42,81.45 18.03,95.84 18.03,121.23 18.29,121.49 18.29,124.4
  BOTTOM w0.076: v6(25.31,131.92) 25.22,131.92 U0300.BL11
  BOTTOM w0.159: v2(37.72,62.63) 37.64,62.7 37.64,63.46 37.91,63.73 38.13,63.73 38.25,63.61 38.43,63.61 38.64,63.81 38.64,63.99 38.51,64.11 38.51,64.33 38.63,64.45 CON1701.29
M_CHB_DQ10: length 94
  TOP w0.159: CON1700.29 40.63,57.99 38.66,59.96 v2(37.9,59.96) ; v1(23.77,130.36) v6(24.51,130.36)
  IN4 w0.076: v6(24.51,130.36) 24.38,130.22 23.74,130.22 21.31,127.79 21.11,127.59 20.65,127.59 19.09,126.03
  IN4 w0.108: 19.09,126.03 19.09,125.29 18.5,124.7 18.5,121.19 18.36,121.05 18.36,95.98 32.76,81.59 32.76,78.34 36.26,74.85 36.26,71.75 35.34,70.83 35.34,66.08 35.34,66.08 35.34,65.8 36.83,64.31 36.83,64.31 37.98,63.16 38.13,63.01 38.13,61.67 38.1,61.64 38.1,61.28 38.61,60.77 38.61,60.57 38.54,60.5 37.62,60.5 37.52,60.39 37.52,60.09 37.65,59.96 v2(37.9,59.96)
  BOTTOM w0.076: v6(24.51,130.36) 24.51,130.29 U0300.BL8
  BOTTOM w0.159: CON1701.24 37.38,58.48 37.11,58.74 37.11,60.16 37.26,60.32 37.64,60.32 37.9,60.06 v2(37.9,59.96)
M_CHB_DQ11: length 92.6
  TOP w0.159: v2(41.25,59.65) 41.96,59.65 43.63,57.99 CON1700.41
  IN4 w0.076: v6(26.18,129.97) 25.72,129.51 25.72,129.31 23.9,127.49 23.9,127.4
  IN4 w0.108: 23.9,127.4 23.9,126.46 22.78,125.35 22.78,125.14 20.61,122.97 20.61,96.92 36.83,80.69 36.83,77.75 38.91,75.67 38.91,70.31 38.91,70.03 38.66,69.77 38.26,69.38 38.26,66.25 38.26,66.06 41.88,62.44 41.88,61.48 41.77,61.37 41.57,61.37 41.46,61.26 41.46,60.99 41.57,60.88 41.77,60.88 41.88,60.78 41.88,60.53 41.75,60.4 40.6,60.4 40.45,60.25 40.45,59.76 40.55,59.65 v2(41.25,59.65)
  BOTTOM w0.076: U0300.BJ8 26.05,129.97 v6(26.18,129.97)
  BOTTOM w0.159: CON1701.38 40.88,58.08 40.44,58.52 40.44,59.56 40.54,59.65 v2(41.25,59.65)
M_CHB_DQ12: length 93.6
  TOP w0.159: v2(41.1,61.86) 41.58,61.86 43.88,64.16 CON1700.42
  IN4 w0.076: v6(26.18,131.27) 25.81,130.9 25.81,130.36 25.65,130.19 25.65,129.91 25.37,129.63 25.37,129.43 22.13,126.19 22.13,125.13 20.81,123.81
  IN4 w0.108: 20.81,123.81 19.94,122.94 19.94,96.64 34.9,81.67 34.9,78.49 38.24,75.15 38.24,70.31 37.59,69.66 37.59,69.65 36.92,68.98 36.92,66.46 37.59,65.79 37.59,65.78 40.64,62.73 40.64,62.1 40.44,61.89 40.44,61.41 40.57,61.28 41,61.28 41.1,61.38 v2(41.1,61.86)
  BOTTOM w0.076: v6(26.18,131.27) 26.05,131.27 U0300.BJ11
  BOTTOM w0.159: CON1701.41 41.63,63.95 41.5,63.82 41.17,63.82 41.02,63.67 41.02,63.37 41.8,62.58 41.8,62.26 41.4,61.86 v2(41.1,61.86)
M_CHB_DQ13: length 92.6
  TOP w0.159: v2(41.1,62.5) 41.67,62.5 42.88,63.71 CON1700.38
  IN4 w0.076: 23.51,127.09 23.51,127.34 25.55,129.38 25.55,129.58 25.81,129.84 25.81,130.13 26.18,130.49 v6(26.18,130.62)
  IN4 w0.108: 23.51,127.09 23.11,126.69 23.11,126.53 23.23,126.41 23.23,126.26 23.04,126.07 22.88,126.07 22.76,126.19 22.61,126.19 22.33,125.91 22.33,125.04 20.28,122.98 20.28,96.78 35.77,81.28 35.77,80.92 35.67,80.82 35.4,80.82 35.31,80.72 35.31,80.58 35.4,80.48 35.82,80.48 35.92,80.38 35.92,80.24 35.82,80.14 35.4,80.14 35.31,80.05 35.31,79.91 35.4,79.81 35.82,79.81 35.92,79.71 35.92,79.57 35.82,79.47 35.4,79.47 35.31,79.37 35.31,79.23 35.4,79.13 35.82,79.13 35.92,79.04 35.92,78.9 35.82,78.8 35.4,78.8 35.31,78.7 35.31,78.56 35.4,78.46 35.64,78.46 38.58,75.53 38.58,70.17 38.52,70.11 38.52,70.11 37.93,69.52 37.93,69.23 37.82,69.12 37.61,69.12 37.5,69.02 37.5,68.74 37.61,68.63 37.82,68.63 37.93,68.53 37.93,67.03 37.93,66.39 37.93,65.92 41.1,62.75 v2(41.1,62.5)
  BOTTOM w0.076: U0300.BJ10 25.72,130.74 25.83,130.62 v6(26.18,130.62)
  BOTTOM w0.159: v2(41.1,62.5) 40.87,62.5 40.13,63.24 40.13,63.8 40.63,64.29 CON1701.37
M_CHB_DQ14: length 92.1
  TOP w0.159: v2(37.9,59.32) 38.46,59.32 39.63,58.15 CON1700.25
  IN4 w0.076: 19.56,125.4 19.58,125.4 20.83,126.65 21.11,126.65 21.39,126.92 21.39,127.4 23.44,129.45 24.41,129.45 v6(24.52,129.57)
  IN4 w0.108: v2(37.9,59.32) 39.47,59.32 39.78,59.63 39.78,60.08 38.47,61.39 38.47,63.15 35.68,65.94 35.68,69.74 35.79,69.85 35.92,69.85 36.03,69.96 36.03,70.23 35.92,70.34 35.79,70.34 35.68,70.45 35.68,70.69 36.6,71.61 36.6,74.98 33.1,78.48 33.1,81.73 18.7,96.12 18.7,124.54 19.56,125.4
  BOTTOM w0.076: v6(24.52,129.57) 24.83,129.25 U0300.BL7
  BOTTOM w0.159: v2(37.9,59.32) 38.61,59.32 38.74,59.2 38.74,58.31 38.38,57.95 CON1701.28
M_CHB_DQ15: length 91.6
  TOP w0.159: CON1700.37 42.63,58.33 41.94,59.02 v2(41.25,59.02)
  IN4 w0.076: 24.79,128.12 26,129.32 v6(26.18,129.32)
  IN4 w0.108: 24.79,128.12 24.79,126.85 20.95,123.01 20.95,97.06 37.68,80.32 37.68,77.38 39.25,75.81 39.25,70.45 39.25,69.89 38.8,69.43 38.6,69.24 38.6,66.2 42.22,62.58 42.22,59.77 42.84,59.15 42.84,58.09 42.7,57.95 42.16,57.95 42.03,58.08 42.03,58.77 41.78,59.02 v2(41.25,59.02)
  BOTTOM w0.076: v6(26.18,129.32) 26.05,129.32 U0300.BJ7
  BOTTOM w0.159: v2(41.25,59.02) 41.78,59.02 41.88,58.92 CON1701.42
M_CHB_DQ16: length 93.6
  TOP w0.159: v2(43.1,61.61) 45.88,64.38 CON1700.50
  IN4 w0.076: 24.66,126.35 25.38,126.35 25.59,126.56 25.59,128.17 25.83,128.41 25.98,128.41 27.47,129.9 27.47,131.37 v6(28.01,131.91)
  IN4 w0.108: 24.66,126.35 21.29,122.97 21.29,97.19 38.02,80.46 38.02,77.52 39.59,75.95 39.59,70.59 39.59,70.59 39.59,69.75 38.94,69.1 38.94,66.34 42.57,62.7 42.57,61.88 42.84,61.61 v2(43.1,61.61)
  BOTTOM w0.076: U0300.BG11 27.86,131.91 v6(28.01,131.91)
  BOTTOM w0.159: CON1701.45 42.63,64.19 42.47,64.03 42.37,64.03 42.24,63.9 42.24,63.61 42.37,63.49 42.47,63.49 42.6,63.36 42.6,63.06 42.47,62.93 42.32,62.93 42.19,62.8 42.19,62.52 42.32,62.39 42.47,62.39 42.63,62.23 42.63,62.09 v2(43.1,61.61)
M_CHB_DQ17: length 91.8
  TOP w0.159: CON1700.46 44.88,64.02 v2(43.1,62.24)
  IN4 w0.076: 24.72,125.99 24.91,126.18 25.44,126.18 25.76,126.49 25.76,127.19 26.54,127.98 26.54,128.32 27.18,128.96 27.18,129.38 27.64,129.83 27.64,131.15 27.76,131.27 v6(28.01,131.27)
  IN4 w0.108: v2(43.1,62.24) 43.1,62.64 39.27,66.48 39.27,67.98 39.38,68.09 39.59,68.09 39.71,68.22 39.71,68.45 39.59,68.58 39.38,68.58 39.27,68.69 39.27,68.9 39.92,69.55 39.92,69.61 39.92,71.13 40.41,71.61 40.41,72.75 40.32,72.84 39.92,73.24 39.92,76.09 38.35,77.66 38.35,80.6 21.78,97.18 21.78,121.62 21.48,121.92 21.48,122.82 23.29,124.63 23.51,124.63 23.6,124.55 23.75,124.55 23.94,124.74 23.94,124.89 23.86,124.98 23.86,125.13 24.05,125.32 24.2,125.32 24.29,125.24 24.44,125.24 24.63,125.43 24.63,125.59 24.55,125.67 24.55,125.82 24.72,125.99
  BOTTOM w0.076: U0300.BG10 27.55,131.12 27.71,131.27 v6(28.01,131.27)
  BOTTOM w0.159: CON1701.49 43.63,64.21 43.47,64.05 43.33,64.05 43.21,63.92 43.21,63.64 43.33,63.51 43.49,63.51 43.63,63.38 43.63,62.77 v2(43.1,62.24)
M_CHB_DQ18: length 93
  TOP w0.159: v2(43.33,60.34) 43.8,60.34 45.56,58.58 45.56,58.1 45.63,58.04 CON1700.49
  IN4 w0.076: v6(28.01,129.97) 27.35,129.31 27.35,128.89 26.72,128.27 26.72,127.92 26.23,127.43 26.23,126.73 23.4,123.91 23.4,123.19 22.34,122.13
  IN4 w0.108: 22.34,122.13 22.11,121.91 22.11,98.57 24.03,96.65 24.03,95.4 38.69,80.74 38.69,77.8 40.26,76.23 40.26,73.38 40.46,73.18 40.46,73.18 40.74,72.89 40.74,71.47 40.26,70.99 40.26,70.86 40.37,70.76 40.41,70.76 40.52,70.65 40.52,70.38 40.41,70.27 40.37,70.27 40.26,70.16 40.26,69.47 40.26,68.37 40.42,68.21 40.42,66.08 40.42,65.8 43.59,62.64 43.59,61.11 43.41,60.93 42.91,60.93 42.65,60.68 42.65,60.3 42.84,60.11 43.1,60.11 v2(43.33,60.34)
  BOTTOM w0.076: U0300.BG8 27.55,129.88 27.64,129.97 v6(28.01,129.97)
  BOTTOM w0.159: v2(43.33,60.34) 42.32,60.34 42.14,60.16 42.14,59.76 42.55,59.35 42.55,58.41 42.88,58.08 CON1701.46
M_CHB_DQ19: length 94.4
  TOP w0.159: CON1700.63 49.13,58.09 47.76,59.46 47.14,60.08 47.14,60.52 v2(46.13,61.53)
  IN4 w0.076: v6(28.92,129.97) 28.92,129.89 29.29,129.53 29.29,129.17 27.75,127.63 27.75,126.33 27.02,125.59 26.55,125.59 25.74,124.77 25.74,124.66
  IN4 w0.108: v2(46.13,61.53) 45.9,61.76 45.9,63.03 44.65,64.28 44.65,70.94 43.16,72.43 43.16,77.21 42.44,77.92 42.44,83.21 36.95,88.71 34.68,88.71 26.71,96.67 26.71,96.81 26.8,96.9 26.8,97.04 26.7,97.14 26.56,97.14 26.47,97.05 26.34,97.05 26.24,97.15 26.24,97.29 26.33,97.38 26.33,97.52 26.23,97.62 26.09,97.62 26,97.53 25.86,97.53 25.76,97.62 25.76,97.76 25.85,97.85 25.85,97.99 25.75,98.09 25.61,98.09 25.52,98 25.38,98 25.05,98.33 25.05,114.29 24.5,114.84 24.5,119.66 25.12,120.29 25.12,122.88 25.74,123.5 25.74,124.66
  BOTTOM w0.076: U0300.BF8 28.79,129.97 v6(28.92,129.97)
  BOTTOM w0.159: CON1701.62 46.88,58.18 47.07,58.37 47.07,58.62 46.96,58.72 46.41,58.72 46.28,58.84 46.28,59.2 46.88,59.8 46.88,60.79 v2(46.13,61.53)
M_CHB_DQ20: length 91
  TOP w0.159: CON1700.58 47.88,64.06 46.77,62.96 v2(46.77,62.83)
  IN4 w0.076: v6(28.92,131.91) 29.47,131.36 29.47,129.89 29.62,129.74 29.62,129.03 28.08,127.49 28.08,125.19 27.76,124.87 27.76,123.74 27.38,123.36
  IN4 w0.108: v2(46.77,62.83) 46.77,63.11 45.32,64.56 45.32,71.22 43.83,72.71 43.83,77.48 43.12,78.2 43.12,83.49 37.23,89.38 35.6,89.38 32.65,92.34 32.51,92.34 32.32,92.15 32.18,92.15 32.09,92.25 32.09,92.39 32.27,92.57 32.27,92.71 32.17,92.81 32.03,92.81 31.85,92.63 31.71,92.63 31.61,92.73 31.61,92.87 31.79,93.05 31.79,93.19 31.69,93.29 31.55,93.29 31.37,93.11 31.23,93.11 31.13,93.2 31.13,93.34 31.32,93.53 31.32,93.67 31.22,93.76 31.08,93.76 30.9,93.58 30.76,93.58 30.66,93.68 30.66,93.82 30.84,94 30.84,94.14 30.74,94.24 30.6,94.24 30.42,94.06 30.28,94.06 30.18,94.16 30.18,94.3 30.36,94.48 30.36,94.62 30.27,94.72 30.13,94.72 29.94,94.53 29.8,94.53 29.71,94.63 29.71,94.77 29.89,94.95 29.89,95.09 25.72,99.26 25.72,121.98 27.1,123.36 27.38,123.36
  BOTTOM w0.076: U0300.BF11 28.78,131.91 v6(28.92,131.91)
  BOTTOM w0.159: v2(46.77,62.83) 47.13,63.18 CON1701.63
M_CHB_DQ21: length 92.1
  TOP w0.159: v2(46.77,62.19) 47.19,62.19 47.32,62.32 47.32,62.92 48.88,64.48 CON1700.62
  IN4 w0.076: 26.98,124.07 26.98,124.53 27.91,125.47 27.91,127.56 29.46,129.1 29.46,129.67 29.29,129.84 29.29,130.9 v6(28.92,131.27)
  IN4 w0.108: v2(46.77,62.19) 46.27,62.7 46.27,63.13 44.99,64.42 44.99,71.08 43.49,72.57 43.49,77.35 42.78,78.06 42.78,83.35 37.09,89.04 34.82,89.04 28.94,94.92 28.94,95.06 29.11,95.23 29.11,95.37 29.01,95.47 28.87,95.47 28.7,95.3 28.56,95.3 28.47,95.4 28.47,95.53 28.63,95.7 28.63,95.84 28.54,95.94 28.4,95.94 28.23,95.77 28.09,95.77 27.99,95.87 27.99,96.01 28.16,96.18 28.16,96.32 28.06,96.42 27.92,96.42 27.75,96.25 27.61,96.25 27.25,96.61 27.25,97.25 25.39,99.12 25.39,121.92 26.75,123.28 26.75,123.84 26.98,124.07
  BOTTOM w0.076: v6(28.92,131.27) 28.79,131.27 U0300.BF10
  BOTTOM w0.159: CON1701.59 46.13,64.43 46.43,64.12 46.43,63.46 45.92,62.96 45.92,62.4 46.13,62.19 v2(46.77,62.19)
M_CHB_DQ22: length 91
  TOP w0.159: CON1700.45 44.63,58.39 43.92,59.1 v2(43.33,59.1)
  IN4 w0.076: v6(28.01,129.32) 26.89,128.2 26.89,127.86 26.41,127.38 26.41,126.68 23.58,123.85 23.58,123.01 23.55,122.98
  IN4 w0.108: 23.55,122.98 22.45,121.88 22.45,98.71 31.54,89.62 31.54,89.17 35.02,85.69 35.02,84.88 39.03,80.88 39.03,77.94 40.6,76.37 40.6,73.52 41.08,73.03 41.08,71.33 40.87,71.13 40.87,70.04 40.76,69.92 40.76,65.94 40.76,65.94 43.94,62.76 43.94,59.97 44.02,59.9 45.19,59.9 45.29,59.8 45.29,59.66 45.19,59.57 44.02,59.57 43.94,59.49 43.94,59.28 43.76,59.1 v2(43.33,59.1)
  BOTTOM w0.076: v6(28.01,129.32) 27.88,129.32 U0300.BG7
  BOTTOM w0.159: v2(43.33,59.1) 43.94,59.1 44.25,58.79 44.25,58.63 43.88,58.25 CON1701.50
M_CHB_DQ23: length 93.4
  TOP w0.159: CON1700.59 48.13,58.54 46.08,60.59 v2(46.08,60.82) ; v6(28.92,129.32) 28.65,129.05 v1(28.65,128.52)
  IN4 w0.076: 25.35,124.63 26.48,125.76 26.95,125.76 27.58,126.4 27.58,127.87 28.92,129.21 v6(28.92,129.32)
  IN4 w0.108: 25.35,124.63 25.35,123.62 24.09,122.36 24.09,118.07 24.13,118.03 24.13,106.65 23.77,106.29 23.77,101.84 23.87,101.75 24.31,101.75 24.41,101.65 24.41,101.51 24.31,101.41 23.87,101.41 23.77,101.31 23.77,101.17 23.87,101.07 24.31,101.07 24.41,100.97 24.41,100.83 24.31,100.74 23.87,100.74 23.77,100.64 23.77,100.5 23.87,100.4 24.31,100.4 24.41,100.3 24.41,100.16 24.31,100.06 23.87,100.06 23.77,99.96 23.77,99.13 41.42,81.48 41.42,81.25 42,80.68 42,76.26 42.32,75.94 42.32,71.95 44.31,69.96 44.31,64.14 45.49,62.96 45.49,62.45 45.29,62.25 45.29,61.9 45.49,61.7 45.49,61.41 v2(46.08,60.82)
  BOTTOM w0.076: U0300.BF7 28.47,129.12 28.67,129.32 v6(28.92,129.32)
  BOTTOM w0.159: CON1701.58 45.88,60.62 v2(46.08,60.82)
M_CHB_DQ24: length 89.1
  TOP w0.159: v2(51.87,59.07) 51.99,59.07 53.13,57.94 CON1700.79
  IN4 w0.076: 32.36,127.81 32.36,129.71 32.2,129.88 32.2,131.39 v6(31.67,131.92)
  IN4 w0.108: v2(51.87,59.07) 51.77,59.17 51.77,69.62 51.05,70.34 51.05,71.69 50.1,72.64 50.1,74.25 49.41,74.94 49.41,75.51 48.23,76.7 48.23,83.46 29.32,102.37 29.32,119.67 32.36,122.71 32.36,127.81
  BOTTOM w0.076: v6(31.67,131.92) 31.53,131.92 U0300.BB11
  BOTTOM w0.159: 52.38,57.1 52.38,58.56 v2(51.87,59.07)
M_CHB_DQ25: length 91.6
  TOP w0.159: v2(47.93,62.24) 48.64,62.24 50.88,64.48 CON1700.70
  IN4 w0.076: v6(30.75,131.91) 30.37,131.52 30.37,131.33 30.21,131.17 30.21,129.9 29.96,129.66 29.96,129.14 28.86,128.03 28.86,125.73 27.93,124.8 27.93,123.65 27.78,123.5
  IN4 w0.108: 27.78,123.5 27.78,123.48 26.06,121.76 26.06,99.4 35.21,90.25 36.84,90.25 43.45,83.63 43.45,78.34 44.17,77.62 44.17,72.85 45.66,71.36 45.66,64.7 47.14,63.21 47.14,63.03 v2(47.93,62.24)
  BOTTOM w0.076: v6(30.75,131.91) 30.6,131.91 U0300.BC11
  BOTTOM w0.159: CON1701.71 49.13,62.17 48.74,61.79 48.38,61.79 v2(47.93,62.24)
M_CHB_DQ26: length 93.9
  TOP w0.159: v2(50.6,60.59) 50.83,60.59 54.38,64.14 CON1700.84
  IN4 w0.076: 30.38,125.35 30.67,125.65 30.67,128.16 30.98,128.46 31.33,128.46 32.03,129.17 32.03,129.51 31.67,129.88 v6(31.67,129.97)
  IN4 w0.108: v2(50.6,60.59) 51.01,61 51.01,68.27 49.43,69.85 49.43,73.98 48.74,74.66 48.74,75.18 47.25,76.67 47.25,78.09 46.89,78.46 46.89,83.86 30.22,100.52 28.65,102.09 28.65,116.05 28.71,116.1 28.71,119.81 30.38,121.48 30.38,125.35
  BOTTOM w0.076: v6(31.67,129.97) 31.53,129.97 U0300.BB8
  BOTTOM w0.159: CON1701.79 51.13,63.79 50.85,63.52 50.71,63.52 50.38,63.85 50.19,63.85 49.94,63.59 49.94,63.34 50.09,63.19 50.09,61.1 v2(50.6,60.59)
M_CHB_DQ27: length 91.8
  TOP w0.159: v2(48.31,60.47) 48.59,60.19 48.86,60.19 51.13,57.93 CON1700.71
  IN4 w0.076: 29.38,126.05 29.83,126.51 29.83,128.54 30.38,129.09 30.38,129.61 30.74,129.97 v6(30.75,129.97)
  IN4 w0.108: v2(48.31,60.47) 48.01,60.16 47.83,60.16 47.68,60.32 47.68,60.55 48.44,61.31 48.44,62.95 47.16,64.23 47.16,72.05 45.34,73.86 45.34,77.3 44.97,77.67 44.97,83.06 37.12,90.92 35.49,90.92 31.52,94.89 31.52,96.52 26.73,101.31 26.73,119.53 29.38,122.17 29.38,126.05
  BOTTOM w0.076: U0300.BC8 30.62,129.97 v6(30.75,129.97)
  BOTTOM w0.159: CON1701.66 47.88,58.85 47.55,59.17 47.55,60.11 47.9,60.47 v2(48.31,60.47)
M_CHB_DQ28: length 90.6
  TOP w0.159: v2(47.93,62.88) 48.27,62.88 49.88,64.48 CON1700.66
  IN4 w0.076: 28.09,123.51 28.09,124.73 29.02,125.66 29.02,127.96 30.14,129.09 30.14,129.61 30.38,129.84 30.38,130.9 v6(30.75,131.27)
  IN4 w0.108: 28.09,123.51 27.71,123.13 27.71,121.36 26.4,120.04 26.4,99.54 35.35,90.58 36.98,90.58 43.96,83.6 43.96,78.3 44.5,77.76 44.5,72.99 46,71.5 46,71.17 46.82,70.34 46.82,69.83 46.72,69.73 46.38,69.73 46.28,69.64 46.28,69.5 46.38,69.4 46.72,69.4 46.82,69.3 46.82,69.16 46.72,69.06 46.4,69.06 46.3,68.96 46.3,68.82 46.4,68.73 46.72,68.73 46.82,68.63 46.82,67.25 46.72,67.15 46.43,67.15 46.33,67.06 46.33,66.92 46.43,66.82 46.72,66.82 46.82,66.72 46.82,66.58 46.72,66.48 46.43,66.48 46.33,66.38 46.33,66.24 46.43,66.14 46.72,66.14 46.82,66.05 46.82,64.01 47.61,63.22 47.61,63.2 v2(47.93,62.88)
  BOTTOM w0.076: v6(30.75,131.27) 30.62,131.27 U0300.BC10
  BOTTOM w0.159: v2(47.93,62.88) 48.64,63.59 48.64,63.75 48.51,63.87 48.03,63.87 47.93,63.97 47.93,64.28 48.13,64.47 CON1701.67
M_CHB_DQ29: length 91.3
  TOP w0.159: v2(51.36,59.74) 52.32,59.74 54.13,57.93 CON1700.83
  IN4 w0.076: v6(31.67,131.27) 32.03,130.9 32.03,129.81 32.2,129.64 32.2,128.86 31.49,128.15 31.49,125.34 31.15,125.01 30.89,125.01 30.6,124.72
  IN4 w0.108: 30.6,124.72 30.6,121.43 28.99,119.82 28.99,102.23 30.56,100.66 30.56,100.66 45.84,85.38 47.9,83.32 47.9,76.56 49.08,75.38 49.08,74.8 49.76,74.11 49.76,69.99 50.52,69.23 50.8,69.23 51.36,68.67 v2(51.36,59.74)
  BOTTOM w0.076: v6(31.67,131.27) 31.53,131.27 U0300.BB10
  BOTTOM w0.159: CON1701.80 51.38,58.37 50.81,58.94 50.81,59.89 50.91,59.99 51.11,59.99 v2(51.36,59.74)
M_CHB_DQ30: length 91.3
  TOP w0.159: v1(30,129.38) 30.73,129.38 v6(30.75,129.4) ; CON1700.67 50.13,58.26 48.89,59.5 48.64,59.5 v2(48.31,59.83)
  IN4 w0.076: 29.57,125.99 30,126.42 30,128.47 30.75,129.23 v6(30.75,129.4)
  IN4 w0.108: 29.57,125.99 29.57,122.09 26.94,119.45 26.94,115.09 27.08,114.95 27.08,101.44 45.31,83.2 45.31,77.81 45.68,77.44 45.68,74 47.49,72.18 47.49,64.37 48.77,63.09 48.77,60.57 49.86,59.48 49.86,59.3 49.48,58.92 49.22,58.92 v2(48.31,59.83)
  BOTTOM w0.076: v6(30.75,129.4) 30.75,129.32 30.55,129.12 30.42,129.12 U0300.BC7
  BOTTOM w0.159: v2(48.31,59.83) 48.31,59.2 48.88,58.64 CON1701.70
M_CHB_DQ31: length 93
  TOP w0.159: v2(50.6,61.23) 53.38,64.01 CON1700.80 ; v6(31.67,129.32) 31.75,129.24 v1(31.75,128.69)
  IN4 w0.076: 30.17,125.51 30.51,125.85 30.51,128.28 30.89,128.67 31.01,128.67 31.66,129.32 v6(31.67,129.32)
  IN4 w0.108: v2(50.6,61.23) 50.6,64.35 50.5,64.44 50.01,64.44 49.91,64.54 49.91,64.68 50.01,64.78 50.5,64.78 50.6,64.88 50.6,65.02 50.5,65.12 49.81,65.12 49.71,65.22 49.71,65.35 49.81,65.45 50.5,65.45 50.6,65.55 50.6,68.2 49.09,69.71 49.09,73.84 46.92,76.01 46.92,77.95 46.55,78.32 46.55,83.72 29.88,100.38 28.31,101.95 28.31,115.39 27.89,115.82 27.89,119.27 30.17,121.56 30.17,125.51
  BOTTOM w0.159: v2(50.6,61.23) 50.6,62.65 52.12,64.18 52.12,65.3 CON1701.83 ; U0300.BB7 31.53,129.32 v6(31.67,129.32)
M_CHB_DQ32: length 97.6
  TOP w0.159: CON1700.183 81.13,58.01 80.98,58.16 80.98,58.36 81.28,58.66 81.28,58.92 81.13,59.07 v2(80.57,59.07)
  IN4 w0.076: v6(48.12,131.92) 48.67,131.38 48.67,129.79 48.91,129.55 48.91,128.97 49.51,128.37 49.51,122.5 49.65,122.36
  IN4 w0.108: 49.65,122.36 55.07,116.94 55.07,115.36 84.27,86.16 84.27,81.29 84.78,80.78 84.78,77.96 85.59,77.15 85.59,73.4 85.93,73.06 85.93,69.65 84.72,68.43 84.72,66.75 82.17,64.21 82.17,60.67 81.51,60.01 81.51,58.87 81.28,58.64 81,58.64 v2(80.57,59.07)
  BOTTOM w0.076: U0300.AA11 47.99,131.92 v6(48.12,131.92)
  BOTTOM w0.159: v2(80.57,59.07) 80.57,58.67 80.47,58.56 80.06,58.56 79.88,58.38 CON1701.186
M_CHB_DQ33: length 99.2
  TOP w0.159: CON1700.187 82.13,58.63 81.61,59.15 81.61,59.78 81.31,60.09 80.95,60.09 v2(80.57,59.7)
  IN4 w0.076: 49.51,122.19 49.51,122.19 49.34,122.35 49.34,128.3 48.67,128.97 48.67,129.55 48.51,129.72 48.51,130.89 v6(48.12,131.27)
  IN4 w0.108: v2(80.57,59.7) 80.73,59.7 80.98,59.95 80.98,60.14 80.9,60.21 80.54,60.21 80.47,60.29 80.47,60.49 80.54,60.57 81.59,60.57 81.84,60.81 81.84,64.35 84.38,66.89 84.38,68.57 85.59,69.79 85.59,72.92 85.26,73.26 85.26,77.01 84.44,77.83 84.44,80.64 83.93,81.15 83.93,86.02 54.64,115.32 54.64,116.73 54.4,116.96 54.4,117.3 49.51,122.19
  BOTTOM w0.076: v6(48.12,131.27) 47.99,131.27 U0300.AA10
  BOTTOM w0.159: v2(80.57,59.7) 79.6,59.7 79.45,59.56 79.45,58.5 78.88,57.92 CON1701.182
M_CHB_DQ34: length 99
  TOP w0.159: v2(77.88,60.14) 78.03,59.99 78.08,59.99 78.64,59.43 78.64,59.27 78.56,59.19 78.41,59.19 78.31,59.1 78.31,58.69 78.63,58.37 CON1700.173
  IN4 w0.076: v6(47.21,131.92) 46.67,131.38 46.67,131.17 46.66,131.17 46.66,130.06 46.51,129.91 46.51,128.69 46.66,128.54 46.66,126.1 47.43,125.33 47.43,121.48 47.5,121.41
  IN4 w0.108: 47.5,121.41 51.26,117.66 51.26,114.56 61.52,104.3 61.52,101.85 64.61,98.76 65.83,98.76 68.72,95.87 68.86,95.87 68.98,96 69.12,96 69.22,95.9 69.22,95.76 69.09,95.63 69.09,95.49 69.19,95.39 69.33,95.39 69.46,95.52 69.6,95.52 69.7,95.42 69.7,95.28 69.57,95.16 69.57,95.02 69.67,94.92 69.81,94.92 69.93,95.04 70.07,95.04 70.17,94.95 70.17,94.81 70.05,94.68 70.05,94.54 76.4,88.18 77.19,88.18 77.92,87.46 77.92,85.27 78.84,84.35 79.85,83.33 79.85,81.71 79.91,81.65 79.91,81.09 79.78,80.96 79.78,80.62 80.31,80.09 80.31,78.4 80.84,77.87 80.84,77.27 81.09,77.01 81.09,69.46 80.34,68.72 80.34,67.69 80.19,67.53 79.87,67.53 79.68,67.35 79.68,66.33 78.45,65.1 78.45,60.71 v2(77.88,60.14)
  BOTTOM w0.076: v6(47.21,131.92) 47.08,131.92 U0300.AC11
  BOTTOM w0.159: v2(77.88,60.14) 77.75,60.14 75.88,58.26 CON1701.170
M_CHB_DQ35: length 97.4
  TOP w0.159: CON1700.169 77.63,58.67 v2(77.88,58.92)
  IN4 w0.076: v6(47.21,131.27) 46.83,130.89 46.83,129.94 46.68,129.78 46.68,129.1 47.6,128.18 47.6,121.77 47.68,121.69
  IN4 w0.108: v2(77.88,58.92) 77.88,58.03 77.98,57.93 78.28,57.93 78.38,58.03 78.38,60.17 78.79,60.57 78.79,64.96 80.68,66.85 80.68,68.58 81.43,69.33 81.43,77.15 81.18,77.41 81.18,80.05 80.88,80.34 80.88,83.72 79.74,84.86 78.96,84.86 78.25,85.57 78.25,87.6 77.28,88.57 76.49,88.57 70.51,94.55 70.51,95.08 69.26,96.33 68.73,96.33 65.97,99.1 64.75,99.1 61.86,101.99 61.86,104.44 51.61,114.69 51.61,117.76 47.68,121.69
  BOTTOM w0.076: U0300.AC10 47.08,131.27 v6(47.21,131.27)
  BOTTOM w0.159: CON1701.174 76.88,58.14 77.65,58.92 v2(77.88,58.92)
M_CHB_DQ36: length 98.1
  TOP w0.159: v2(80.7,63.71) 80.15,63.71 80.01,63.85 80.01,64.07 80.16,64.23 80.62,64.23 80.88,64.48 CON1700.182
  IN4 w0.076: 49.01,122.1 49.01,128.16 48.26,128.91 48.26,129.18 v6(48.12,129.32)
  IN4 w0.108: 49.01,122.1 53.68,117.43 53.68,115.32 63.8,105.2 63.8,104.37 64.41,103.76 65.24,103.76 71.58,97.42 76.71,92.3 78.26,90.74 80.16,88.84 80.16,87.3 80.43,87.04 80.57,87.04 80.75,87.22 80.89,87.22 80.99,87.12 80.99,86.99 80.8,86.8 80.8,86.66 83.26,84.21 83.26,80.54 83.34,80.46 83.67,80.46 83.77,80.36 83.77,80.18 83.67,80.08 83.36,80.08 83.26,79.99 83.26,79.85 83.36,79.75 83.67,79.75 83.77,79.65 83.77,79.45 83.67,79.35 83.49,79.35 83.39,79.25 83.39,79.12 83.49,79.02 83.67,79.02 83.77,78.92 83.77,78.78 83.67,78.68 83.49,78.68 83.39,78.58 83.39,78.44 83.49,78.34 83.67,78.34 83.77,78.25 83.77,78.07 83.59,77.89 83.59,77.72 84.05,77.26 84.05,76.84 84.15,76.74 84.48,76.74 84.58,76.64 84.58,76.5 84.48,76.4 84.15,76.4 84.05,76.31 84.05,76.17 84.15,76.07 84.48,76.07 84.58,75.97 84.58,75.83 84.48,75.73 84.15,75.73 84.05,75.63 84.05,75.49 84.15,75.39 84.48,75.39 84.58,75.3 84.58,75.16 84.48,75.06 84.15,75.06 84.05,74.96 84.05,72.69 84.18,72.56 84.35,72.56 84.43,72.64 84.43,72.86 84.49,72.92 84.65,72.92 84.92,72.64 84.92,70.79 84.82,70.69 84.68,70.69 84.58,70.59 84.58,70.45 84.68,70.35 84.82,70.35 84.92,70.26 84.92,70.07 83.71,68.85 83.71,68.36 83.59,68.24 83.1,68.24 83.01,68.15 83.01,67.98 83.11,67.88 83.59,67.88 83.69,67.78 83.69,67.64 83.59,67.54 83.11,67.54 83.01,67.44 83.01,67.31 83.11,67.21 83.43,67.21 83.52,67.12 83.52,66.98 83.44,66.9 83.11,66.9 83.01,66.8 83.01,66.47 81.16,64.63 81.16,64.17 v2(80.7,63.71)
  BOTTOM w0.076: U0300.AA7 47.99,129.32 v6(48.12,129.32)
  BOTTOM w0.159: CON1701.187 80.13,64.48 79.78,64.13 79.78,63.87 79.96,63.7 80.14,63.7 80.26,63.82 80.59,63.82 v2(80.7,63.71)
M_CHB_DQ37: length 98.6
  TOP w0.159: CON1700.186 81.88,63.02 81.64,62.78 81,62.78 v2(80.7,63.07)
  IN4 w0.076: v6(48.12,129.97) 48.12,129.87 48.49,129.5 48.49,128.92 49.18,128.23 49.18,122.23 49.39,122.02
  IN4 w0.108: v2(80.7,63.07) 80.84,63.21 80.98,63.21 81.13,63.06 81.13,62.48 81.22,62.39 81.42,62.39 81.5,62.47 81.5,64.49 84.05,67.03 84.05,68.71 85.26,69.93 85.26,72.78 84.92,73.12 84.92,76.87 84.1,77.69 84.1,80.5 83.59,81.01 83.59,85.19 83.48,85.31 83.32,85.31 83.06,85.04 82.92,85.04 82.82,85.14 82.82,85.28 83.44,85.9 83.44,86.04 83.33,86.15 83.21,86.15 82.75,85.69 82.58,85.52 82.44,85.52 82.34,85.62 82.34,85.76 82.82,86.24 82.82,86.35 82.72,86.45 82.56,86.45 82.12,86.01 82.1,85.99 81.97,85.99 81.87,86.09 81.87,86.23 82.04,86.41 82.04,86.55 81.94,86.65 81.8,86.65 81.63,86.47 81.49,86.47 81.39,86.57 81.39,86.71 81.57,86.88 81.57,87.02 80.57,88.02 80.57,88.91 54.02,115.46 54.02,117.39 49.39,122.02
  BOTTOM w0.076: v6(48.12,129.97) 47.99,129.97 U0300.AA8
  BOTTOM w0.159: CON1701.183 79.13,63.96 79.62,63.46 79.62,63.35 79.83,63.14 80.14,63.14 80.21,63.21 80.56,63.21 v2(80.7,63.07)
M_CHB_DQ38: length 101.7
  TOP w0.159: CON1700.170 77.88,63.75 77.98,63.64 78.31,63.64 78.49,63.47 78.49,63.04 78.16,62.7 78.16,62.31 v2(79.71,60.75)
  IN4 w0.076: v6(47.21,129.97) 46.84,129.6 46.84,129.17 47.76,128.25 47.76,122.01 47.86,121.91
  IN4 w0.108: 47.86,121.91 52.02,117.75 52.02,114.75 62.19,104.58 62.19,102.13 64.89,99.43 66.11,99.43 68.87,96.67 69.4,96.67 70.85,95.22 70.85,94.69 76.63,88.91 77.42,88.91 78.59,87.74 78.59,85.71 79.1,85.2 79.88,85.2 81.22,83.86 81.22,80.48 81.51,80.19 81.51,77.55 81.89,77.17 81.89,72.48 82.3,72.07 82.3,71.19 81.77,70.66 81.77,69.19 81.09,68.51 81.09,66.78 79.13,64.82 79.13,60.62 79.45,60.29 79.65,60.29 79.71,60.35 v2(79.71,60.75)
  BOTTOM w0.159: v2(79.71,60.75) 79.29,60.75 77.86,62.19 77.86,62.64 76.85,63.64 76.46,63.64 75.63,64.47 CON1701.169 ; U0300.AC8 46.89,129.65 v6(47.21,129.97)
M_CHB_DQ39: length 100.5
  TOP w0.159: CON1700.174 78.88,63.06 78.99,62.94 79.39,62.94 79.5,62.83 79.5,62.67 79.39,62.56 78.99,62.56 78.88,62.44 78.88,62.22 v2(79.71,61.39)
  IN4 w0.076: 47.97,122.17 47.93,122.21 47.93,128.4 47.21,129.12 v6(47.21,129.32)
  IN4 w0.108: 47.97,122.17 52.43,117.72 52.43,114.82 62.53,104.72 62.53,102.27 65.03,99.77 66.24,99.77 68.62,97.4 69.41,97.4 78.93,87.88 78.93,85.85 79.24,85.53 80.11,85.53 81.55,84.09 81.55,82.28 81.65,82.18 81.77,82.18 81.86,82.09 81.86,81.95 81.77,81.85 81.65,81.85 81.55,81.75 81.55,80.62 81.85,80.33 81.85,77.68 82.81,76.72 82.81,74.09 82.71,73.99 82.6,73.99 82.5,73.89 82.5,73.75 82.6,73.65 82.71,73.65 82.81,73.56 82.81,70.82 82.88,70.75 83.24,70.75 83.33,70.66 83.33,70.27 82.84,69.79 82.63,69.79 82.52,69.89 82.52,70.51 82.4,70.64 82.22,70.64 82.1,70.52 82.1,69.05 81.47,68.41 81.47,66.68 79.46,64.68 79.46,61.64 v2(79.71,61.39)
  BOTTOM w0.076: v6(47.21,129.32) 47.08,129.32 U0300.AC7
  BOTTOM w0.159: CON1701.173 76.63,64.24 78.28,62.58 78.28,62.31 79.21,61.39 v2(79.71,61.39)
M_CHB_DQ40: length 102.7
  TOP w0.159: v6(49.96,129.99) 49.86,129.99 v1(49.3,129.43) ; v2(82.17,60.05) 82.47,60.05 83.18,59.34 83.85,59.34 84.13,59.07 CON1700.195
  IN4 w0.076: v6(49.96,129.99) 49.95,129.98 49.95,129.84 49.59,129.47 49.59,129.02 50,128.6 50,122.91 51.83,121.09 51.9,121.09
  IN4 w0.108: v2(82.17,60.05) 82.51,60.38 82.51,60.95 83.39,61.82 83.39,63.99 86.64,67.25 86.64,68.66 87.46,69.48 87.46,72.96 87.1,73.32 87.1,75.63 87,75.73 86.71,75.73 86.61,75.83 86.61,75.97 86.71,76.07 87,76.07 87.1,76.17 87.1,76.31 87,76.4 86.71,76.4 86.61,76.5 86.61,76.64 86.71,76.74 87,76.74 87.1,76.84 87.1,77.07 87.04,77.13 86.72,77.13 86.62,77.22 86.62,77.55 86.35,77.82 86.35,80.27 86.25,80.37 85.95,80.37 85.85,80.47 85.85,80.61 85.95,80.71 86.25,80.71 86.35,80.81 86.35,80.95 86.25,81.04 85.95,81.04 85.85,81.14 85.85,81.28 85.95,81.38 86.25,81.38 86.35,81.48 86.35,81.76 85.84,82.28 85.84,84.51 85.74,84.61 85.39,84.61 85.29,84.71 85.29,84.85 85.39,84.95 85.74,84.95 85.84,85.05 85.84,85.29 85.74,85.39 85.62,85.39 85.52,85.49 85.52,85.63 85.62,85.73 85.74,85.73 85.84,85.82 85.84,87.19 65.65,107.37 64.48,107.37 56.13,115.73 56.13,117.16 52.2,121.09 51.9,121.09
  BOTTOM w0.076: U0300.W8 49.84,129.99 v6(49.96,129.99)
  BOTTOM w0.159: v2(82.17,60.05) 82.17,60.04 81.23,59.1 81.23,58.59 80.88,58.23 CON1701.190
M_CHB_DQ41: length 100.8
  TOP w0.159: CON1700.191 83.13,58.19 83.06,58.26 82.83,58.26 82.65,58.44 82.65,58.67 82.73,58.74 82.88,58.74 82.98,58.84 82.98,58.99 82.52,59.45 82.21,59.45 v2(82.17,59.42)
  IN4 w0.076: 51.83,121.38 51.77,121.38 50.17,122.98 50.17,128.72 49.95,128.93 v6(49.95,129.32)
  IN4 w0.108: 51.83,121.38 52.23,121.38 56.65,116.96 56.65,115.69 61.83,110.5 62.69,110.5 63.62,109.57 63.94,109.57 64.25,109.26 64.25,109.12 63.91,108.78 63.91,108.64 64.01,108.55 64.15,108.55 64.49,108.88 64.62,108.88 64.72,108.78 64.72,108.64 64.39,108.31 64.39,108.17 64.49,108.07 64.63,108.07 64.96,108.4 65.1,108.4 86.18,87.33 86.18,82.42 86.69,81.9 86.69,77.96 87.44,77.21 87.44,73.46 87.8,73.1 87.8,69.34 86.98,68.52 86.98,67.11 83.72,63.85 83.72,61.68 82.85,60.81 82.85,59.72 83.03,59.53 83.03,58.18 82.91,58.06 82.32,58.06 82.17,58.2 v2(82.17,59.42)
  BOTTOM w0.076: v6(49.95,129.32) 49.82,129.32 U0300.W7
  BOTTOM w0.159: CON1701.194 81.88,59.12 v2(82.17,59.42)
M_CHB_DQ42: length 101.5
  TOP w0.159: v2(85.55,59.81) 86.31,59.81 86.97,59.15 86.97,58.91 87.13,58.76 CON1700.207
  IN4 w0.076: v6(50.87,131.27) 51.25,130.89 51.25,130.1 51.6,129.75 51.6,128.78 51.7,128.67 51.7,127.83 51.71,127.82 51.71,125.22 52.45,124.49 52.45,122.35 54.56,120.24 54.67,120.24
  IN4 w0.108: 54.67,120.24 55.75,120.24 58.83,117.15 58.83,116.21 62.61,112.43 63.46,112.43 64.04,111.85 65.01,111.85 88.09,88.77 88.09,83.25 89.42,81.91 89.42,77.96 90.2,77.18 90.2,74.53 89.73,74.06 89.73,67.15 85.76,63.19 85.76,61.75 85.86,61.65 85.98,61.65 86.08,61.55 86.08,61.41 85.98,61.32 85.68,61.32 85.58,61.22 85.58,61.08 85.68,60.98 85.98,60.98 86.08,60.88 86.08,60.74 85.98,60.64 85.86,60.64 85.76,60.54 85.76,60.36 85.85,60.26 86.02,60.26 86.1,60.19 86.1,59.98 86.31,59.77 86.31,59.63 86.21,59.53 85.82,59.53 v2(85.55,59.81)
  BOTTOM w0.076: U0300.V10 50.74,131.27 v6(50.87,131.27)
  BOTTOM w0.159: v2(85.55,59.81) 84.73,58.98 84.73,58.5 84.38,58.15 CON1701.204
M_CHB_DQ43: length 100.9
  TOP w0.159: v2(85.55,59.17) 85.78,59.4 86.17,59.4 86.39,59.18 86.39,58.95 86.74,58.6 86.74,58.41 86.59,58.26 86.23,58.26 86.13,58.16 CON1700.203
  IN4 w0.076: v6(50.87,131.92) 51.41,131.38 51.41,130.29 51.77,129.94 51.77,128.84 52.45,128.16 52.45,124.72 52.62,124.55 52.62,122.42 54.53,120.51 54.65,120.51
  IN4 w0.108: 54.65,120.51 55.86,120.51 59.03,117.34 59.03,116.48 62.75,112.77 64.57,112.77 88.42,88.91 88.42,83.39 89.81,82 89.81,78.05 90.54,77.32 90.54,74.39 90.07,73.92 90.07,67.02 86.1,63.05 86.1,62.2 86.44,61.86 86.44,60.12 86.72,59.84 86.72,59.27 86.61,59.17 v2(85.55,59.17)
  BOTTOM w0.076: v6(50.87,131.92) 50.74,131.92 U0300.V11
  BOTTOM w0.159: v2(85.55,59.17) 85.11,58.74 85.11,58.19 85.38,57.93 CON1701.208
M_CHB_DQ44: length 101.8
  TOP w0.159: v2(82.93,62.5) 83.04,62.5 83.46,62.93 83.46,63.01 83.87,63.42 83.87,63.63 83.76,63.75 83.27,63.75 83.16,63.86 83.16,64.02 83.27,64.13 83.76,64.13 83.87,64.25 83.87,65.3 CON1700.194
  IN4 w0.076: v6(49.95,131.92) 49.42,131.39 49.42,129.78 49.26,129.61 49.26,128.85 49.67,128.44 49.67,122.66 49.8,122.53 49.8,122.53
  IN4 w0.108: 49.8,122.53 55.46,116.87 55.46,115.45 67.62,103.29 68.78,103.29 69.01,103.07 69.01,102.93 68.69,102.61 68.69,102.47 68.79,102.37 68.93,102.37 69.25,102.69 69.39,102.69 69.49,102.59 69.49,102.45 69.17,102.13 69.17,101.99 69.27,101.89 69.4,101.89 69.72,102.21 69.86,102.21 69.96,102.11 69.96,101.98 69.64,101.66 69.64,101.52 69.74,101.42 69.88,101.42 70.2,101.74 70.34,101.74 70.44,101.64 70.44,101.5 70.12,101.18 70.12,101.04 70.22,100.94 70.36,100.94 70.68,101.26 70.81,101.26 84.6,87.47 84.6,81.43 85.11,80.92 85.11,78.1 85.93,77.29 85.93,73.54 86.27,73.2 86.27,69.51 85.06,68.29 85.06,66.61 82.51,64.07 82.51,61.87 82.6,61.79 82.83,61.79 82.93,61.89 v2(82.93,62.5)
  BOTTOM w0.076: U0300.W11 49.82,131.92 v6(49.95,131.92)
  BOTTOM w0.159: v2(82.93,62.5) 81.13,64.31 CON1701.191
M_CHB_DQ45: length 101.3
  TOP w0.159: v2(82.93,63.14) 82.52,62.73 82.37,62.73 82.26,62.84 82.26,64.07 82.37,64.18 82.57,64.18 82.88,64.48 CON1700.190
  IN4 w0.076: v6(49.99,131.31) 49.59,130.91 49.59,129.71 49.42,129.54 49.42,128.92 49.84,128.5 49.84,122.79 49.94,122.68 49.95,122.68
  IN4 w0.108: v2(82.93,63.14) 82.93,64.01 85.39,66.47 85.39,68.16 87.12,69.89 87.12,72.82 86.27,73.68 86.27,77.42 86.01,77.68 86.01,79.48 85.5,79.99 85.5,83.99 84.94,84.55 84.94,85.52 85.5,86.08 85.5,87.05 68.48,104.08 68.34,104.08 68.13,103.88 68,103.88 67.9,103.97 67.9,104.11 68.1,104.32 68.1,104.45 68,104.55 67.86,104.55 67.46,104.15 67.32,104.15 67.22,104.25 67.22,104.39 67.62,104.79 67.62,104.93 67.52,105.03 67.38,105.03 66.98,104.62 66.84,104.62 66.74,104.72 66.74,104.86 67.15,105.27 67.15,105.41 67.05,105.51 66.91,105.51 66.5,105.1 66.36,105.1 66.27,105.2 66.27,105.34 66.67,105.74 66.67,105.88 66.57,105.98 66.43,105.98 66.03,105.58 65.89,105.58 65.79,105.68 65.79,105.81 66.19,106.22 66.19,106.36 66.1,106.46 65.96,106.46 65.55,106.05 65.41,106.05 65.31,106.15 65.31,106.29 65.72,106.7 65.72,106.83 65.51,107.04 64.34,107.04 55.8,115.59 55.8,116.83 49.95,122.68
  BOTTOM w0.076: v6(49.99,131.31) 49.78,131.1 49.65,131.1 U0300.W10
  BOTTOM w0.159: v2(82.93,63.14) 82.93,63.64 82.8,63.77 82.3,63.77 82.13,63.95 CON1701.195
M_CHB_DQ46: length 101.5
  TOP w0.159: v2(85.01,62.53) 85.45,62.1 85.7,62.1 85.84,62.24 85.84,63.35 86.38,63.89 CON1700.204
  IN4 w0.076: v6(50.89,129.32) 50.72,129.15 50.72,125.27 51.26,124.73 51.74,124.73 52.1,124.37 52.1,122.24 54.54,119.8 54.64,119.8
  IN4 w0.108: v2(85.01,62.53) 85.01,63.39 88.22,66.59 88.22,68 89.04,68.82 89.04,75.23 88.94,75.33 88.8,75.33 88.7,75.43 88.7,75.57 88.8,75.67 88.94,75.67 89.04,75.77 89.04,75.9 88.94,76 88.8,76 88.7,76.1 88.7,76.24 88.8,76.34 88.94,76.34 89.04,76.44 89.04,76.58 88.94,76.68 88.8,76.68 88.7,76.78 88.7,76.91 88.8,77.01 88.94,77.01 89.04,77.11 89.04,77.36 87.93,78.47 87.93,82.42 87.41,82.93 87.41,87.84 69.39,105.86 69.39,106 69.49,106.11 69.49,106.27 69.39,106.37 69.28,106.37 69.18,106.27 69.06,106.27 68.81,106.52 68.81,107.1 68.65,107.26 68.51,107.26 68.3,107.05 68.2,107.05 68.07,107.18 68.07,107.3 68.27,107.5 68.27,107.64 68.17,107.74 68.03,107.74 67.82,107.53 67.73,107.53 67.59,107.67 67.59,107.77 67.79,107.98 67.79,108.12 67.69,108.21 67.55,108.21 67.35,108.01 67.25,108.01 67.13,108.12 67.13,108.27 67.32,108.45 67.32,108.59 67.22,108.69 67.08,108.69 66.87,108.48 66.77,108.48 66.65,108.61 66.65,108.74 66.84,108.93 66.84,109.07 66.74,109.17 66.6,109.17 66.39,108.96 66.3,108.96 66.17,109.09 66.17,109.21 66.36,109.4 66.36,109.54 66.27,109.64 66.13,109.64 65.93,109.44 65.82,109.44 65.64,109.62 65.64,109.75 65.82,109.93 65.82,110.07 65.72,110.17 65.58,110.17 65.4,109.99 65.26,109.99 65.17,110.09 65.17,110.23 65.34,110.41 65.34,110.55 65.24,110.64 65.1,110.64 64.93,110.47 64.79,110.47 64.69,110.57 64.69,110.71 64.87,110.88 64.87,111.02 64.77,111.12 64.63,111.12 64.45,110.94 64,110.94 63.19,111.76 62.33,111.76 58.3,115.79 58.3,116.82 55.32,119.8 54.64,119.8
  BOTTOM w0.076: v6(50.89,129.32) 50.74,129.32 U0300.V7
  BOTTOM w0.159: v2(85.01,62.53) 85.13,62.64 CON1701.207
M_CHB_DQ47: length 103
  TOP w0.159: v2(85.01,61.61) 85.01,61.36 85.14,61.23 85.73,61.23 86.61,62.12 86.61,63.21 87.38,63.97 CON1700.208
  IN4 w0.076: 54.69,120.02 54.55,120.02 52.29,122.28 52.29,124.42 51.55,125.15 51.55,127.75 51.54,127.76 51.54,128.55 51.44,128.65 51.44,128.71 51.44,128.71 51.44,128.84 51.44,128.84 51.44,129.42 v6(50.88,129.97)
  IN4 w0.108: v2(85.01,61.61) 85.34,61.61 85.42,61.69 85.42,63.33 89.04,66.94 89.04,68.35 89.37,68.68 89.37,77.5 88.26,78.61 88.26,82.56 87.75,83.07 87.75,88.63 73.87,102.51 73.73,102.51 73.58,102.37 73.44,102.37 73.35,102.47 73.35,102.61 73.49,102.75 73.49,102.89 73.39,102.99 73.25,102.99 73.11,102.84 72.97,102.84 72.87,102.94 72.87,103.08 73.02,103.23 73.02,103.37 72.92,103.47 72.78,103.47 72.63,103.32 72.49,103.32 72.39,103.42 72.39,103.56 72.54,103.7 72.54,103.84 72.44,103.94 72.3,103.94 72.16,103.8 72.02,103.8 71.92,103.89 71.92,104.03 72.06,104.18 72.06,104.32 71.96,104.42 71.83,104.42 71.68,104.27 71.54,104.27 71.44,104.37 71.44,104.51 71.59,104.66 71.59,104.8 71.49,104.89 71.35,104.89 71.2,104.75 71.06,104.75 70.97,104.85 70.97,104.99 71.11,105.13 71.11,105.27 71.01,105.37 70.87,105.37 70.73,105.22 70.59,105.22 70.49,105.32 70.49,105.46 70.64,105.61 70.64,105.75 70.54,105.85 70.4,105.85 70.25,105.7 70.11,105.7 70.01,105.8 70.01,105.94 70.16,106.08 70.16,106.22 64.87,111.52 63.9,111.52 63.32,112.09 62.47,112.09 58.64,115.93 58.64,116.92 55.53,120.02 54.69,120.02
  BOTTOM w0.076: U0300.V8 50.74,129.97 v6(50.88,129.97)
  BOTTOM w0.159: CON1701.203 84.13,62.5 v2(85.01,61.61)
M_CHB_DQ48: length 101.8
  TOP w0.159: v2(87.17,62.75) 88.38,63.96 CON1700.212
  IN4 w0.076: 54.6,120.76 54.51,120.76 52.78,122.49 52.78,124.62 52.62,124.79 52.62,128.26 52,128.88 52,129.72 52.15,129.87 52.15,131.04 52.31,131.2 52.31,131.54 v6(52.7,131.92)
  IN4 w0.108: 54.6,120.76 57.2,120.76 59.31,118.66 59.31,116.48 61.4,114.39 61.6,114.39 62.1,113.89 63.93,113.89 88.76,89.05 88.76,83.53 90.14,82.14 90.14,78.19 90.87,77.46 90.87,74.02 90.92,73.97 90.92,73.78 90.84,73.71 90.55,73.71 90.45,73.61 90.45,73.47 90.55,73.37 90.84,73.37 90.92,73.3 90.92,73.1 90.7,72.89 90.7,72.6 90.92,72.39 90.92,70.58 90.82,70.49 90.52,70.49 90.42,70.39 90.42,70.25 90.52,70.15 90.82,70.15 90.92,70.05 90.92,69.91 90.82,69.81 90.52,69.81 90.42,69.71 90.42,69.57 90.52,69.48 90.82,69.48 90.92,69.38 90.92,69.13 90.82,69.03 90.53,69.03 90.4,68.9 90.4,68.57 90.58,68.39 90.58,67.05 90.36,66.83 90.36,66.69 90.42,66.64 90.42,66.51 90.31,66.41 90.17,66.41 90.12,66.46 89.98,66.46 89.88,66.36 89.88,66.22 89.92,66.18 89.92,66.04 89.82,65.94 89.69,65.94 89.64,65.98 89.51,65.98 89.41,65.88 89.41,65.74 89.45,65.7 89.45,65.56 89.35,65.46 89.21,65.46 89.17,65.5 89.03,65.5 88.93,65.4 88.93,65.27 88.97,65.22 88.97,65.08 88.87,64.99 88.73,64.99 88.69,65.03 88.55,65.03 88.45,64.93 88.45,64.79 88.5,64.75 88.5,64.61 88.4,64.51 88.26,64.51 88.22,64.55 88.08,64.55 86.43,62.91 86.43,62.43 86.52,62.35 86.77,62.35 v2(87.17,62.75)
  BOTTOM w0.076: U0300.R11 52.56,131.92 v6(52.7,131.92)
  BOTTOM w0.159: CON1701.215 87.13,62.8 v2(87.17,62.75)
M_CHB_DQ49: length 102.6
  TOP w0.159: v2(90.35,60.09) 90.7,59.73 90.7,59.28 90.96,59.02 91.41,59.02 91.63,58.81 CON1700.225
  IN4 w0.076: v6(53.61,131.92) 54.16,131.38 54.16,130.36 54.38,130.13 54.38,129.13 55.45,128.06 55.45,125.74 56.17,125.01 56.91,125.01 59.1,122.82
  IN4 w0.108: v2(90.35,60.09) 90.53,60.09 92.1,61.66 92.1,63.59 94.17,65.66 94.17,69.69 94.61,70.13 94.61,71.07 95.19,71.64 95.19,72.89 94.61,73.47 94.61,77.63 95.67,78.68 95.67,80.45 95.5,80.61 95.22,80.61 95.1,80.74 95.1,83.5 93.92,84.67 93.92,88.5 68.56,113.86 68.56,117.31 63.04,122.82 59.1,122.82
  BOTTOM w0.076: U0300.P11 53.48,131.92 v6(53.61,131.92)
  BOTTOM w0.159: CON1701.228 90.38,58.27 89.99,58.65 89.99,59.73 v2(90.35,60.09)
M_CHB_DQ50: length 101.8
  TOP w0.159: v2(90.63,63.03) 90.93,63.03 91.72,63.82 91.72,64.08 91.64,64.15 91.47,64.15 91.38,64.24 CON1700.224
  IN4 w0.076: 56.32,122.15 54.95,123.52 54.95,127.86 53.61,129.2 v6(53.61,129.32)
  IN4 w0.108: 56.32,122.15 62.27,122.15 66.57,117.84 66.57,117.06 66.67,116.96 67.45,116.96 67.55,116.86 67.55,116.58 67.45,116.48 66.55,116.48 66.45,116.38 66.45,116.24 66.55,116.14 67.45,116.14 67.55,116.04 67.55,115.9 67.45,115.8 66.57,115.8 66.47,115.71 66.47,115.57 66.57,115.47 67.45,115.47 67.55,115.37 67.55,115.23 67.45,115.13 66.6,115.13 66.5,115.03 66.5,114.89 66.6,114.79 67.45,114.79 67.55,114.7 67.55,114.56 67.45,114.46 66.9,114.46 66.8,114.36 66.8,114.22 66.9,114.12 67.45,114.12 67.55,114.02 67.55,113.44 92.91,88.08 92.91,84.62 92.81,84.52 92.77,84.52 92.67,84.42 92.67,84.28 92.77,84.18 92.87,84.18 93.03,84.02 93.03,80.08 93.6,79.51 93.6,70.54 93.16,70.11 93.16,66.08 91.08,63.99 91.08,63.31 90.8,63.03 v2(90.63,63.03)
  BOTTOM w0.076: U0300.P7 53.48,129.32 v6(53.61,129.32)
  BOTTOM w0.159: v2(90.63,63.03) 90.45,63.21 90.45,63.21 90.19,63.46 90.19,63.82 90.63,64.25 CON1701.229
M_CHB_DQ51: length 101.8
  TOP w0.159: v2(87.43,59.07) 88.47,59.07 89.13,58.41 CON1700.215
  IN4 w0.076: v6(52.7,129.97) 52.53,129.81 52.53,129.7 52.33,129.5 52.33,129.13 52.95,128.52 52.95,124.92 53.12,124.75 53.12,122.62 54.56,121.18 54.68,121.18
  IN4 w0.108: 54.68,121.18 57.58,121.18 59.7,119.05 59.7,116.85 61.62,114.93 63.84,114.93 89.92,88.85 89.92,83.32 90.52,82.72 91.15,82.72 91.46,82.42 91.46,81.48 90.82,80.85 90.82,78.46 92.03,77.26 92.03,73.92 91.59,73.48 91.59,68.48 91.25,68.14 91.25,66.4 88.72,63.87 88.72,63.33 88.63,63.24 88.44,63.24 88.34,63.34 88.34,63.43 88.23,63.54 88.02,63.54 87.92,63.44 87.92,62.44 88.02,62.35 88.13,62.35 88.22,62.25 88.22,62.11 88.13,62.01 88.02,62.01 87.92,61.91 87.92,61.77 88.02,61.67 88.13,61.67 88.22,61.57 88.22,61.43 88.13,61.34 88.02,61.34 87.96,61.28 87.96,59.1 87.83,58.97 87.53,58.97 v2(87.43,59.07)
  BOTTOM w0.076: U0300.R8 52.56,129.97 v6(52.7,129.97)
  BOTTOM w0.159: v2(87.43,59.07) 87.12,59.07 86.38,58.33 CON1701.212
M_CHB_DQ52: length 103
  TOP w0.159: v2(87.17,62.12) 89.38,64.32 CON1700.216
  IN4 w0.076: 54.64,120.97 54.53,120.97 52.96,122.55 52.96,124.68 52.78,124.86 52.78,128.38 52.16,129 52.16,129.62 52.33,129.78 52.33,130.9 v6(52.7,131.27)
  IN4 w0.108: v2(87.17,62.12) 87.17,60.59 86.99,60.41 86.99,60.25 87.1,60.14 87.5,60.14 87.58,60.22 87.58,63.58 87.88,63.88 88.26,63.88 90.92,66.54 90.92,68.28 91.25,68.62 91.25,74.11 91.21,74.16 91.21,77.6 90.48,78.32 90.48,82.28 89.58,83.18 89.58,88.71 63.61,114.67 61.49,114.67 59.51,116.66 59.51,118.74 57.27,120.97 54.64,120.97
  BOTTOM w0.076: U0300.R10 52.56,131.27 v6(52.7,131.27)
  BOTTOM w0.159: CON1701.211 86.13,63.17 v2(87.17,62.12)
M_CHB_DQ53: length 104
  TOP w0.159: v2(90.35,60.72) 91.19,60.72 91.57,60.34 91.57,59.5 92.63,58.44 CON1700.229
  IN4 w0.076: v6(53.61,131.27) 53.98,130.9 53.98,130.27 54.2,130.05 54.2,129.08 55.28,127.99 55.28,124.86 56.49,123.65 56.49,122.8 56.7,122.59
  IN4 w0.108: v2(90.35,60.72) 90.59,60.96 90.92,60.96 91.76,61.8 91.76,63.72 93.84,65.8 93.84,69.83 94.28,70.27 94.28,71.21 94.85,71.78 94.85,72.75 94.28,73.33 94.28,80.62 94.55,80.89 94.55,83.57 93.58,84.53 93.58,88.36 68.22,113.72 68.22,117.14 62.78,122.59 56.7,122.59
  BOTTOM w0.076: U0300.P10 53.48,131.27 v6(53.61,131.27)
  BOTTOM w0.159: CON1701.224 89.38,59.53 89.08,59.83 89.08,60.52 89.28,60.72 v2(90.35,60.72)
M_CHB_DQ54: length 100.9
  TOP w0.159: v2(87.71,58.43) 87.94,58.67 88.32,58.67 88.44,58.54 88.44,58.31 88.13,57.99 CON1700.211
  IN4 w0.076: v6(52.7,129.32) 52.9,129.12 52.9,128.9 53.11,128.68 53.11,125.19 53.26,125.04 53.97,125.04
  IN4 w0.108: v2(87.71,58.43) 88.26,58.43 88.39,58.56 88.39,58.73 88.83,59.17 88.83,59.51 88.64,59.71 88.4,59.71 88.3,59.81 88.3,59.95 88.4,60.04 89.03,60.04 89.13,60.14 89.13,60.28 89.03,60.38 88.4,60.38 88.3,60.48 88.3,60.69 88.56,60.95 88.56,62.21 89.11,62.75 89.11,63.78 91.59,66.26 91.59,68 91.93,68.34 91.93,73.34 92.36,73.78 92.36,77.4 91.16,78.6 91.16,80.71 91.79,81.34 91.79,82.56 91.29,83.06 90.66,83.06 90.25,83.46 90.25,88.99 63.82,115.42 63.48,115.42 61.41,115.42 59.94,116.88 59.94,121 59.49,121.45 56.02,121.45 54.28,123.18 54.28,124.73 54.11,124.9 53.97,125.04
  BOTTOM w0.076: v6(52.7,129.32) 52.56,129.32 U0300.R7
  BOTTOM w0.159: CON1701.216 87.38,58.1 v2(87.71,58.43)
M_CHB_DQ55: length 102.7
  TOP w0.159: CON1700.228 92.38,63.92 91.3,62.84 91.3,62.54 91.16,62.4 v2(90.63,62.4)
  IN4 w0.076: 56.59,122.37 56.29,122.67 56.29,123.62 55.12,124.79 55.12,127.93 54,129.04 54,129.58 v6(53.61,129.97)
  IN4 w0.108: 56.59,122.37 62.52,122.37 67.89,117 67.89,113.58 93.25,88.22 93.25,84.28 93.37,84.16 93.37,83.2 93.47,83.11 94.11,83.11 94.21,83.01 94.21,82.87 94.11,82.77 93.47,82.77 93.37,82.67 93.37,82.53 93.47,82.43 94.11,82.43 94.21,82.33 94.21,82.19 94.11,82.1 93.47,82.1 93.37,82 93.37,81.86 93.47,81.76 94.11,81.76 94.21,81.66 94.21,81.52 94.11,81.42 93.47,81.42 93.37,81.32 93.37,81.01 93.94,80.44 93.94,70.4 93.5,69.97 93.5,65.94 91.41,63.85 91.41,62.02 91.27,61.87 90.73,61.87 90.63,61.97 v2(90.63,62.4)
  BOTTOM w0.076: v6(53.61,129.97) 53.48,129.97 U0300.P8
  BOTTOM w0.159: v2(90.63,62.4) 89.63,63.4 CON1701.225
M_CHB_DQ56: length 102.9
  TOP w0.159: CON1700.245 96.63,58.09 97.03,58.49 97.03,58.88 96.59,59.33 v2(96.1,59.33)
  IN4 w0.076: 60.25,126.22 59.09,127.37 59.09,128.07 58.47,128.7 56.86,130.31 56.86,130.97 56.8,131.04 56.8,131.45 v6(56.33,131.92)
  IN4 w0.108: 60.25,126.22 60.65,126.22 61.78,125.09 67.74,125.09 71.59,121.24 71.59,120.43 73.58,118.44 73.58,113.92 98.4,89.1 98.4,88.15 99.85,86.7 99.85,73.99 100.3,73.53 100.3,72.86 99.63,72.19 99.28,72.19 99.04,71.95 99.04,70.79 99.16,70.67 99.16,70.13 99.16,70.13 99.16,67.85 99.48,67.53 99.48,65.02 98.48,64.02 98.48,63.5 98.15,63.17 97.94,63.17 96.1,61.33 v2(96.1,59.33)
  BOTTOM w0.076: v6(56.33,131.92) 56.22,131.92 U0300.L11
  BOTTOM w0.159: v2(96.1,59.33) 95.88,59.1 CON1701.250
M_CHB_DQ57: length 101.9
  TOP w0.159: v2(92.51,63.39) 92.94,63.39 93.38,63.83 CON1700.232
  IN4 w0.076: 59.32,123.04 59.12,123.04 56.98,125.18 56.24,125.18 55.61,125.81 55.61,128.13 54.67,129.07 54.67,130.18 54.9,130.41 54.9,131.05 55.05,131.2 55.05,131.54 v6(55.44,131.92)
  IN4 w0.108: 59.32,123.04 63.46,123.04 68.9,117.61 68.9,114 94.26,88.64 94.26,86.3 94.37,86.19 94.58,86.19 94.67,86.28 94.67,86.43 94.75,86.51 94.99,86.51 95.15,86.35 95.15,86.11 94.96,85.93 94.96,85.79 95.08,85.67 95.32,85.67 95.39,85.59 95.39,85.45 95.29,85.36 94.96,85.36 94.84,85.23 94.84,85.11 94.93,85.02 95.3,85.02 95.43,84.89 95.43,84.68 95.33,84.58 94.92,84.58 94.82,84.48 94.82,84.34 94.92,84.24 95.33,84.24 95.43,84.14 95.43,81.16 96,80.59 96,78.54 94.95,77.49 94.95,73.61 95.53,73.03 95.53,71.51 94.95,70.93 94.95,69.99 94.51,69.55 94.51,66.92 94.64,66.79 94.92,66.79 95.04,66.66 95.04,66.51 94.92,66.39 94.59,66.39 94.51,66.31 94.51,66.06 94.56,66.01 95,66.01 95.08,65.92 95.08,65.59 94.87,65.37 94.73,65.37 94.62,65.49 94.48,65.49 94.38,65.39 94.38,65.25 94.49,65.14 94.49,65 94.36,64.86 94.22,64.86 94.16,64.93 94.02,64.93 93.92,64.83 93.92,64.69 93.98,64.63 93.98,64.49 93.88,64.39 93.75,64.39 93.68,64.45 93.54,64.45 93.44,64.35 93.44,64.21 93.51,64.15 93.51,64.01 92.88,63.39 v2(92.51,63.39)
  BOTTOM w0.076: v6(55.44,131.92) 55.31,131.92 U0300.M11
  BOTTOM w0.159: v2(92.51,63.39) 92.63,63.51 CON1701.237
M_CHB_DQ58: length 102.6
  TOP w0.159: CON1700.246 96.88,63.78 96.77,63.67 v2(96.34,63.67) ; v1(56.13,128.74) 56.13,129.2 v6(56.3,129.37)
  IN4 w0.076: v6(56.3,129.37) 56.3,129.29 57.46,128.14 57.46,126.54 59.62,124.37
  IN4 w0.108: v2(96.34,63.67) 96.53,63.67 96.87,64.01 96.87,64.16 97.37,64.66 97.37,67.12 97.72,67.47 97.72,68.82 98.03,69.13 98.03,72.38 97.85,72.56 97.85,73.84 98.84,74.83 98.84,86.28 97.39,87.73 97.39,88.68 71.15,114.93 71.15,115.22 71.24,115.32 71.8,115.32 71.9,115.42 71.9,115.56 71.8,115.65 71.24,115.65 71.15,115.75 71.15,115.89 71.24,115.99 72.11,115.99 72.21,116.09 72.21,116.23 72.11,116.33 71.24,116.33 71.15,116.43 71.15,116.57 71.24,116.66 72.11,116.66 72.21,116.76 72.21,116.9 72.11,117 71.24,117 71.15,117.1 71.15,117.24 71.24,117.34 72.11,117.34 72.21,117.44 72.21,117.58 72.11,117.67 71.24,117.67 71.15,117.77 71.15,117.91 71.24,118.01 72.08,118.01 72.17,118.11 72.17,118.25 72.08,118.35 71.24,118.35 71.15,118.45 71.15,119.43 67.4,123.17 66.44,123.17 65.24,124.37 59.62,124.37
  BOTTOM w0.076: v6(56.3,129.37) 56.19,129.37 U0300.L7
  BOTTOM w0.159: v2(96.34,63.67) 95.78,64.23 95.78,64.32 95.63,64.48 CON1701.249
