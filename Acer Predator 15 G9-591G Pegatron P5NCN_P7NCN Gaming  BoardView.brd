# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_TGR_L900MIL: length 13.4
  BOTTOM w0.089: 173.59,64.92 174.55,63.97 U2000.AL2 ; 172.97,65.72 172.97,66.28 172.75,66.5
  BOTTOM w0.102: 173.59,64.92 173.35,65.17 173.35,65.35 172.98,65.72 172.97,65.72 ; 172.75,66.5 172.75,68.36 172.52,68.59 172.52,69.69 R2326.1 171.96,70.25 171.96,71.37 171.83,71.49 171.83,72.03 170.11,73.75 v1(169.92,73.75)
PCH_THMTRIP#_R: length 7
  BOTTOM w0.089: 172.48,63.66 172.81,63.66 173.14,63.33 173.14,62.64 173.03,62.52 173.03,62.33 173.03,62.29 173.07,62.21 173.11,62.09 173.32,61.89 U2000.AJ3
  BOTTOM w0.102: 172.48,63.66 172.21,63.66 171.94,63.94 171.94,64.45 v1(171.63,64.76) 171.33,65.06 171.21,65.06 170.8,65.48
  BOTTOM w0.114: 170.8,65.48 170.38,65.89 R2454.1
PCH_VR_ICC_THROTTLING: length 8
  BOTTOM w0.089: U2000.BD23 181.01,52.05 181.35,52.39 181.76,52.39 181.8,52.43 183.24,52.43 184.51,53.7 184.71,53.7
  BOTTOM w0.102: R2408.2 187.6,53.21 187.43,53.21 186.93,53.7 184.71,53.7
PCH_VSS_AB10: length 9.2
  TOP w0.254: R2701.1 v1(169.52,66.21) 169.52,65.58 169.98,65.12 169.98,59.5 170.46,59.01 v2(170.47,59.01)
  BOTTOM w0.254: v2(170.47,59.01) 170.07,58.61 U2000.AB10
PCH_VSS_AB11: length 10.4
  TOP w0.254: v2(170.47,58.24) 170.77,58.24 v1(171.09,58.56) 171.25,58.72 171.25,64.91 170.82,65.34 170.82,66.72 R2700.1
  BOTTOM w0.254: U2000.AB11 170.07,57.85 v2(170.47,58.24)
PCHXDP_OBSDATA_A0_R: length 14.8
  TOP w0.102: v2(172.84,46.42) 172.43,46.02 172.43,44.54 172.63,44.35 172.63,41.79 171.86,41.01 171.86,40 170.61,38.76 170.61,37.97 v1(170.43,37.79) 170.02,37.37 170.02,37.19 R2107.2 170.02,36.35 170.02,34.52 R2111.1
  BOTTOM w0.089: U2000.AG35 172.56,46.24 172.66,46.24 v2(172.84,46.42)
PCHXDP_OBSDATA_A1_R: length 10.9
  TOP w0.102: R2108.2 R2112.1 v1(168.71,37.89) 169.17,37.89 171.45,40.17 171.45,41.18 172.22,41.95 172.22,43.52 v2(171.78,43.96)
  BOTTOM w0.102: v2(171.78,43.96) 171.96,43.78 U2000.AG39
PCHXDP_OBSDATA_A2_R: length 7.4
  BOTTOM w0.089: 173.63,37.94 173.17,38.41 173.17,38.84 172.81,39.2 172.73,39.2 172.48,39.45 172.48,40.56 172.62,40.71 172.62,41.28 172.75,41.4 172.75,41.62 172.73,41.63 172.73,42.09 172.66,42.17 172.66,42.75 U2000.AF41
  BOTTOM w0.102: R2100.2 173.91,37.28 v1(173.91,37.66) 173.63,37.94
PCHXDP_OBSDATA_B1_R: length 7.3
  BOTTOM w0.089: U2000.AE45 171.77,41.07 171.77,37.73
  BOTTOM w0.102: 171.77,37.73 171.77,35.06 v1(171.78,35.04) 171.78,34.75 R2103.2
PCHXDP_OBSDATA_B2_R: length 8.1
  BOTTOM w0.089: 171.35,37.73 v1(171.32,37.76) 171.32,39.17 171.59,39.43 171.59,41.3 171.84,41.55 U2000.AE44
  BOTTOM w0.102: 171.35,37.73 171.55,37.53 171.55,36.56 171.34,36.34 171.34,34.73 171.6,34.46 R2104.2
PCHXDP_PRDY#: length 9.1
  BOTTOM w0.089: 176.99,63.66 176.99,63.22 177.03,63.19 177.03,62.56 177.07,62.52 177.07,61.71 176.95,61.59 U2000.AT4
  BOTTOM w0.102: 176.99,63.66 176.99,64.77 177.76,65.54 177.76,67.99 177.76,68 177.76,68.57 v1(177.65,68.67) 177.46,68.86 177.46,69.55 R2325.1
PCHXDP_PREQ_R#: length 291.3
  IN1 w0.102: v2(177.6,64.72) 174.55,64.72 173.86,65.41 171.1,65.41 170.9,65.62 168.78,65.62 168.17,65.01 158.74,65.01 157.83,64.1 155.66,64.1 154.95,63.39 153.91,63.39 150.43,59.9 146.12,59.9 145.52,59.3 144.14,59.3 143.28,58.45 141.83,58.45 139.44,56.05 135.6,56.05 135.14,55.59 123.75,55.59 123.35,55.19 116.45,55.19 115.53,56.1 112.51,56.1 112.27,55.86 112.27,55.1 111.63,54.46 102.1,54.46 99.62,51.99 91.63,51.99 91.19,51.55 64.47,51.55 64.11,51.19 62.01,51.19 61.65,51.55 51.23,51.55 50.22,52.56 48.22,52.56 46.85,51.19 43.93,51.19 40.08,55.03 40.08,56.89 38.61,58.36 38.61,62.6 37.72,63.49 33.74,63.49 32.3,64.93 31.49,64.93 26.46,69.96 26.46,70.44 24.87,72.03 24.87,77.68 20.47,82.09 12.2,82.09 11.77,82.52 11,82.52 9.65,83.86 8.05,83.86 7.12,84.8 7.12,120.77 5.44,122.45 5.44,124.59 4.22,125.81 4.22,128.42 5.18,129.38 6.1,129.38 6.45,129.02 8.32,129.02 9,129.7 9,133.18 14.42,138.6 15.17,138.6 17.17,140.59 17.17,144.19 16.66,144.7 16.66,144.72 16.59,144.8 16.59,146.33 16.82,146.57 16.99,146.57 19.1,148.69 19.1,150.54 18.75,150.89 17.96,150.89 16.71,149.65 v2(16.1,149.65)
  BOTTOM w0.089: U2000.AT3 177.62,61.96 177.62,62.55 177.72,62.66 177.72,62.88 177.98,63.13 177.98,64.34 v2(177.6,64.72)
  BOTTOM w0.102: R4403.2 13.24,144.67 v1(13.74,144.67) 14.01,144.67 15.55,146.2 15.55,149.09 v2(16.1,149.65)
PCI_IRQA: length 12.9
  TOP w0.114: v2(178.01,54.34) 178.01,54.34 178.61,54.94 179.16,54.94 179.81,55.58 180.06,55.58 180.68,56.2 180.78,56.3 181.36,56.3 182.39,57.32 183.81,57.32 v1(184.27,57.78) 184.92,58.43 185.52,58.43 R2206.2 186.41,58.31 R2225.2
  BOTTOM w0.089: U2000.AW17 178.59,54.91 178.01,54.34 v2(178.01,54.34)
PCIE_CLK_N_GPU: length 155.2
  IN1 w0.089: v2(165.02,76.21) 165.25,76.44 165.25,76.63 165.18,76.7 160.2,76.7 159.34,75.84 154.58,75.84 153.72,76.7 151.43,76.7 149.01,74.28 146.64,74.28 145.99,73.64 142.42,73.64 141.6,72.82 128.91,72.82 126.82,70.73 120.99,70.73 116.47,66.21 110.98,66.21 108.46,68.73 108.46,69.74 101.85,76.35 101.85,90.01 89.16,102.71 89.16,111.68 90.68,113.2 90.68,123.33 89.59,124.43 89.59,130.9 90.09,131.41 90.09,136.36 91.03,137.3 94.97,137.3 95.12,137.15 95.12,136.67 v6(95.2,136.59)
  BOTTOM w0.114: 165.42,75.4 v1(165.2,75.4) ; 165.42,75.4 165.42,75.81 v2(165.02,76.21) ; 165.42,75.4 165.42,72.82 165.1,72.49 165.1,68.97 R2519.2 ; U7000.BC20 95.1,136.69 v6(95.2,136.59)
PCIE_CLK_N_GPU_R: length 6.5
  BOTTOM w0.089: 165.06,64.14 165.08,64.12 165.08,64.09 165.1,64.06 165.1,62.2 U2000.N3
  BOTTOM w0.114: 165.06,64.14 164.77,64.43 164.77,65.75 ; 164.77,65.75 v1(164.52,65.75) ; 164.77,65.75 R2519.1
PCIE_CLK_P_GPU: length 155.2
  IN1 w0.089: v6(94.63,136.6) 94.95,136.92 94.95,137.08 94.9,137.12 91.1,137.12 90.27,136.29 90.27,131.34 89.76,130.83 89.76,124.5 90.86,123.41 90.86,113.13 89.34,111.61 89.34,102.78 102.03,90.09 102.03,76.42 108.64,69.82 108.64,68.8 111.05,66.39 116.4,66.39 120.92,70.91 126.75,70.91 128.84,73 141.53,73 142.34,73.82 145.92,73.82 146.56,74.46 148.94,74.46 151.36,76.88 153.8,76.88 154.66,76.02 159.26,76.02 160.12,76.88 165.25,76.88 165.43,76.7 165.43,76.44 v2(165.66,76.21)
  BOTTOM w0.114: v2(165.66,76.21) 165.66,73.5 ; 165.66,73.5 165.66,72.72 165.33,72.39 165.33,68.97 R2518.2 ; 165.66,73.5 v1(165.88,73.5) ; U7000.BD20 94.51,137.3 94.64,137.3 94.75,137.19 94.75,136.72 v6(94.63,136.6)
PCIE_CLK_P_GPU_R: length 6.4
  BOTTOM w0.089: U2000.N2 165.39,62.35 165.29,62.46 165.29,64.14 165.27,64.17 165.27,64.22 165.24,64.25 165.24,64.29 165.23,64.3
  BOTTOM w0.114: 165.01,66.85 165.01,67.2 165.13,67.33 165.53,67.33 165.66,67.45 R2518.1 ; 165.01,66.85 165.01,64.52 165.23,64.3 ; 165.01,66.85 v1(165.25,66.85)
PCIE_LAN_TXN: length 12.5
  BOTTOM w0.089: 153.09,49.18 153.1,49.18 153.12,49.15 153.41,49.15 153.5,49.25 154.25,50 154.25,50.88 156.49,53.12 159.27,53.12 159.65,53.5 159.95,53.5 160.22,53.22 160.22,53.09 U2000.B21
  BOTTOM w0.114: C2013.2 150.71,49.18 153.09,49.18
PCIE_LAN_TXP: length 12.5
  BOTTOM w0.089: 153.09,48.94 153.12,48.94 153.14,48.96 153.49,48.96 153.58,49.06 154.44,49.92 154.44,50.8 156.57,52.93 159.35,52.93 159.73,53.31 159.87,53.31 160.03,53.14 160.03,53.05 159.99,53.01 U2000.A21
  BOTTOM w0.114: C2012.2 150.89,48.94 153.09,48.94
PCIE_RCOMPN: length 2.9
  TOP w0.102: 159.04,54.32 v2(159.04,54.34) 159.44,53.94 v1(159.82,53.94)
  TOP w0.203: 159.04,54.32 158.55,54.32 R2516.2
  BOTTOM w0.203: U2000.B18 159.56,54.62 159.3,54.35 159.06,54.35 v2(159.04,54.34)
PCIE_RCOMPP: length 3.2
  TOP w0.102: v1(159.61,55.47) 159.55,55.47 159.06,54.97 159.06,54.96 ; v2(159.04,54.95) 159.06,54.96 ; 159.06,54.96 159.04,54.97 158.5,54.97 R2516.1
  BOTTOM w0.089: U2000.C17 160.52,54.72 160.37,54.87 160,54.87 159.98,54.85 159.14,54.85 v2(159.04,54.95)
PCIE_RXN7_WLAN: length 142
  IN4 w0.089: v2(244.78,82.41) 244.58,82.21 244.58,80.33 243.3,79.05 243.3,72.19 239.83,68.73 239.83,61.52 238.9,60.58 235.67,60.58 234.95,59.86 233.04,59.86 231.42,58.23 226.97,58.23 226.26,57.52 222.48,57.52 222.12,57.88 218.13,57.88 217.48,57.23 214.47,57.23 213.13,55.89 208.87,55.89 208.15,56.61 201.7,56.61 199.08,59.24 199.08,62.61 193.75,67.93 188.87,67.93 186.7,70.11 180.6,70.11 180.33,70.38 178.08,70.38 177.81,70.11 168.99,70.11 161.9,63.01 158,63.01 153.62,58.63 153.62,57.24 153.91,56.95 159.15,56.95 159.97,56.12 163.86,56.12 164.08,55.9 164.08,55.56 164.14,55.51 v2(164.44,55.51)
  BOTTOM w0.114: CON5300.43 246.25,83.73 246.12,83.59 246.12,83.14 245.77,82.79 244.87,82.79 244.78,82.69 v2(244.78,82.41) ; v2(164.44,55.51) 164.44,55.08 164.61,54.91 U2000.L17
PCIE_RXP7_WLAN: length 142
  IN4 w0.089: v2(244.17,82.44) 244.4,82.21 244.4,80.4 243.12,79.12 243.12,72.27 239.66,68.8 239.66,61.59 238.82,60.76 235.6,60.76 234.88,60.04 232.97,60.04 231.34,58.41 226.9,58.41 226.19,57.7 222.55,57.7 222.2,58.06 218.06,58.06 217.41,57.41 214.39,57.41 213.06,56.07 208.95,56.07 208.22,56.79 201.77,56.79 199.26,59.31 199.26,62.68 193.83,68.11 188.95,68.11 186.78,70.28 180.67,70.28 180.4,70.55 178,70.55 177.73,70.28 168.92,70.28 161.82,63.19 157.93,63.19 153.44,58.7 153.44,57.17 153.84,56.77 159.07,56.77 159.9,55.95 163.78,55.95 163.91,55.82 163.91,55.57 163.85,55.51 v2(163.68,55.51)
  BOTTOM w0.114: v2(163.68,55.51) 163.82,55.51 164.06,55.24 U2000.K17 ; v2(244.17,82.44) 244.19,82.44 244.77,83.02 245.67,83.02 245.88,83.24 245.88,83.59 245.75,83.72 CON5300.41
PCIE_SATA_PEDET: length 6.3
  TOP w0.102: v2(49.33,35.53) T5103.1
  BOTTOM w0.102: CON5103.69 48.87,35.35 49.15,35.35 v2(49.33,35.53)
PCIE_SATA_RXN0: length 116.5
  IN4 w0.089: v2(58.92,41.4) 58.92,41.71 58.98,41.78 59.31,41.78 59.53,41.99 59.98,41.99 60.17,41.8 60.17,41.25 60.54,40.88 61.51,40.88 62.07,41.44 96.24,41.44 96.9,40.78 102.14,40.78 102.52,40.4 119.11,40.4 119.34,40.63 129.5,40.63 130.14,40 136.98,40 138.71,38.27 145.34,38.27 145.58,38.51 156.28,38.51 160.06,42.29 160.06,46.65 161.46,48.05 162.05,48.05 162.13,48.13 v2(162.13,48.43)
  BOTTOM w0.114: U2000.G31 162.46,48.33 162.36,48.43 v2(162.13,48.43) ; CON5102.43 58.57,41.85 58.64,41.91 58.64,42.05 58.7,42.12 59.07,42.12 59.23,41.96 59.23,41.71 v2(58.92,41.4)
PCIE_SATA_RXN1: length 118
  IN4 w0.089: v2(61.25,41.39) 60.99,41.66 60.99,41.72 61.09,41.83 97.09,41.83 97.72,41.2 111.8,41.2 111.88,41.28 114.62,41.28 114.8,41.47 124.42,41.47 124.64,41.24 130.1,41.24 130.89,40.45 137.08,40.45 138.86,38.68 145.19,38.68 145.42,38.9 149.71,38.9 150.22,39.41 156.57,39.41 159.66,42.5 159.66,46.93 161.56,48.84 161.98,48.84 162.56,49.42 v2(162.74,49.42)
  BOTTOM w0.114: U2000.G29 162.44,49.12 v2(162.74,49.42) ; CON5102.29 59.55,45.35 61.39,43.51 61.39,42.14 61.25,41.99 v2(61.25,41.39)
PCIE_SATA_RXN2: length 123.7
  IN4 w0.089: v2(62.71,40.3) 62.71,40.63 62.76,40.69 89.18,40.69 89.96,39.91 101.96,39.91 102.21,39.65 111.5,39.65 112.12,39.03 112.62,39.03 113.15,39.57 119.43,39.57 119.73,39.87 128.89,39.87 130.03,38.73 135.38,38.73 137.25,36.86 144.99,36.86 145.89,37.76 146.7,37.76 146.7,37.76 157.17,37.76 160.81,41.4 160.81,46.09 162.01,47.3 163.59,47.3 164.06,47.77 164.06,48.16 v2(164.29,48.39)
  BOTTOM w0.102: v2(164.29,48.39) 164.75,47.93 U2000.L31
  BOTTOM w0.114: v2(62.71,40.3) 62.74,40.34 62.74,44.59 59.12,48.22 58.67,48.22 58.54,48.35 CON5102.17
PCIE_SATA_RXN3: length 127
  IN4 w0.089: v2(64.02,39.21) 63.68,39.55 63.68,39.72 63.82,39.86 68.17,39.86 68.69,39.33 101.72,39.33 101.98,39.08 111.08,39.08 111.79,38.36 112.97,38.36 113.54,38.93 118.9,38.93 119.18,38.65 128.91,38.65 129.59,37.97 132.69,37.97 133.22,37.43 135.69,37.43 136.83,36.29 145.9,36.29 146.73,37.12 146.99,37.12 157.43,37.12 161.38,41.08 161.38,45.66 162.44,46.73 163.71,46.73 163.78,46.65 163.78,46.55 v2(163.55,46.32)
  BOTTOM w0.114: v2(64.02,39.21) 64.06,39.25 64.06,45.64 59.45,50.25 59.45,50.86 59.14,51.17 58.68,51.17 58.5,51.35 CON5102.5 ; v2(163.55,46.32) 163.42,46.32 162.86,46.87 U2000.G33
PCIE_SATA_RXP0: length 116.4
  IN4 w0.089: v2(59.54,41.4) 59.54,41.75 59.59,41.8 59.92,41.8 60,41.72 60,41.18 60.47,40.7 61.59,40.7 62.15,41.26 96.17,41.26 96.83,40.6 102.07,40.6 102.45,40.22 119.18,40.22 119.41,40.45 129.43,40.45 130.06,39.82 136.91,39.82 138.63,38.09 145.41,38.09 145.66,38.33 156.35,38.33 160.24,42.22 160.24,46.58 161.53,47.87 162.14,47.87 162.69,48.43 v2(162.87,48.43)
  BOTTOM w0.114: U2000.H31 163.22,48.07 v2(162.87,48.43) ; CON5102.41 59.17,42.35 59.46,42.06 59.46,41.48 v2(59.54,41.4)
PCIE_SATA_RXP1: length 117.9
  IN4 w0.089: v2(60.63,41.4) 60.81,41.57 60.81,41.8 61.02,42.01 97.17,42.01 97.8,41.38 111.73,41.38 111.81,41.46 114.54,41.46 114.73,41.64 124.49,41.64 124.72,41.42 130.18,41.42 130.96,40.63 137.15,40.63 138.93,38.85 145.12,38.85 145.35,39.08 149.63,39.08 150.14,39.59 156.49,39.59 159.48,42.58 159.48,47.01 161.49,49.01 161.89,49.01 161.98,49.1 v2(161.98,49.42)
  BOTTOM w0.114: v2(60.63,41.4) 61.01,41.78 61.01,42.09 61.15,42.23 61.15,43.41 59.45,45.12 58.66,45.12 58.6,45.05 58.6,44.91 58.54,44.85 CON5102.31 ; v2(161.98,49.42) 162.13,49.27 162.13,49.09 162.04,49 U2000.E29
PCIE_SATA_RXP2: length 123.7
  IN4 w0.089: v2(163.58,48.42) 163.88,48.12 163.88,47.84 163.51,47.47 161.94,47.47 160.63,46.17 160.63,41.47 157.1,37.94 146.63,37.94 146.63,37.94 145.82,37.94 144.92,37.04 137.32,37.04 135.46,38.91 130.1,38.91 128.96,40.05 119.65,40.05 119.35,39.74 113.08,39.74 112.55,39.21 112.19,39.21 111.57,39.83 102.29,39.83 102.03,40.08 90.03,40.08 89.25,40.87 62.67,40.87 v2(62.1,40.29)
  BOTTOM w0.102: U2000.K31 163.99,48.01 v2(163.58,48.42)
  BOTTOM w0.114: v2(62.1,40.29) 62.5,40.7 62.5,44.5 59.02,47.98 58.67,47.98 58.54,47.85 CON5102.19
PCIE_SATA_RXP3: length 127.1
  IN4 w0.089: v2(164.19,46.33) 163.96,46.57 163.96,46.73 163.78,46.9 162.37,46.9 161.2,45.73 161.2,41.15 157.35,37.3 147.13,37.3 146.66,37.3 145.82,36.47 136.9,36.47 135.76,37.61 133.3,37.61 132.76,38.14 129.66,38.14 128.98,38.83 119.26,38.83 118.98,39.11 113.46,39.11 112.89,38.54 111.87,38.54 111.15,39.26 102.05,39.26 101.79,39.51 68.76,39.51 68.24,40.03 63.74,40.03 63.5,39.79 63.5,39.31 v2(63.4,39.2)
  BOTTOM w0.114: U2000.H33 163.63,46.87 164.16,46.33 v2(164.19,46.33) ; v2(63.4,39.2) 63.82,39.63 63.82,45.54 59.22,50.15 59.22,50.76 59.04,50.93 58.63,50.93 58.55,50.85 CON5102.7
PCIE_SATA_TXN0: length 128.2
  TOP w0.114: C5131.1 58.47,26.2 v2(58.37,26.09)
  IN4 w0.089: v2(158.06,47.57) 158.28,47.35 158.28,47.22 158.22,47.17 157.73,47.17 157.19,46.62 156.54,46.62 156.04,46.12 144.4,46.12 143.25,47.27 138.96,47.27 138.9,47.21 131.99,47.21 131.31,47.9 124.28,47.9 123.69,47.3 111.76,47.3 110.71,46.26 102.58,46.26 100.59,48.25 90.1,48.25 89.56,47.72 67.5,47.72 67.36,47.86 67.36,48.05 v2(67.56,48.25)
  BOTTOM w0.089: U2000.C31 160.5,47.9 160.24,48.16 158.43,48.16 158.24,47.97 158.24,47.76 v2(158.06,47.57)
  BOTTOM w0.114: v2(58.37,26.09) 58.37,27.02 59.74,28.39 63.63,28.39 67.11,31.87 67.11,36.58 68.3,37.77 68.3,40.45 ; v2(67.56,48.25) 67.56,47.51 66.98,46.93 66.98,44.15 68.3,42.83 68.3,40.45 ; 68.3,40.45 v1(68.52,40.45)
PCIE_SATA_TXN0_C: length 16.3
  TOP w0.114: 58.18,28.57 58.18,27.92 C5131.2 ; 58.18,28.57 58.18,29.35 v2(58.39,29.56) ; 58.18,28.57 v1(58.41,28.57)
  BOTTOM w0.114: v2(58.39,29.56) 58.22,29.74 58.22,30.01 60.3,32.1 60.3,35.55 59.03,36.82 59.03,40.49 58.8,40.72 58.57,40.72 58.43,40.85 CON5102.47
PCIE_SATA_TXN1: length 124.9
  TOP w0.114: v2(60.06,26.1) 60.19,26.23 C5150.1
  IN4 w0.089: v2(158.8,46.51) 158.58,46.29 158.58,46.08 158.3,45.8 156.77,45.8 156.28,45.31 144.07,45.31 142.87,46.51 139.32,46.51 138.59,45.78 132.06,45.78 130.92,46.92 124.63,46.92 124.23,46.53 123.15,46.53 122.41,45.78 111.37,45.78 111.09,45.5 101.19,45.5 99.72,46.97 67.91,46.97 67.84,46.9 67.84,46.73 v2(68.08,46.49)
  BOTTOM w0.089: v2(158.8,46.51) 159.22,46.93 159.26,46.93 159.96,46.93 160.11,47.08 160.65,47.08 U2000.C32
  BOTTOM w0.114: 69.39,42.3 69.39,37.36 67.9,35.88 67.9,31.72 63.74,27.56 62.69,27.56 60.68,27.56 59.84,26.72 59.84,26.32 v2(60.06,26.1) ; 69.39,42.3 v1(69.61,42.3) ; 69.39,42.3 69.39,43.1 67.84,44.64 67.84,46.25 v2(68.08,46.49)
PCIE_SATA_TXN1_C: length 19.1
  TOP w0.114: 60.02,28.54 v2(60.02,29.58) ; 60.02,28.54 v1(60.25,28.54) ; 60.02,28.54 60.02,28.13 60.19,27.97 C5150.2
  BOTTOM w0.114: CON5102.35 58.5,43.85 58.64,43.72 58.88,43.72 60.21,42.39 60.21,37.58 60.99,36.8 60.99,31.34 59.83,30.18 59.83,29.77 v2(60.02,29.58)
PCIE_SATA_TXN2: length 122.8
  TOP w0.114: C5155.1 61.93,26.13 v2(61.9,26.09)
  IN4 w0.089: v2(69.12,45.93) 69.12,46.25 69.23,46.36 99.29,46.36 100.79,44.87 111.34,44.87 111.54,45.06 122.5,45.06 123.18,45.74 131.05,45.74 131.73,45.06 138.79,45.06 139.66,45.94 142.42,45.94 144.45,43.91 150.17,43.91 150.8,44.54 156.78,44.54 v2(157.53,45.29)
  BOTTOM w0.089: v2(157.53,45.29) 157.28,45.54 157.28,45.7 157.48,45.9 159.05,45.9 159.57,46.41 160.24,46.41 160.62,46.8 U2000.C33
  BOTTOM w0.114: 70.75,38.03 70.75,37.18 69.01,35.44 69.01,31.87 63.95,26.81 61.97,26.81 61.7,26.54 61.7,26.3 v2(61.9,26.09) ; 70.75,38.03 70.75,43.45 68.91,45.29 68.91,45.72 v2(69.12,45.93) ; 70.75,38.03 v1(70.97,38.03)
PCIE_SATA_TXN2_C: length 22.9
  TOP w0.114: v1(61.87,28.54) 61.65,28.54 ; 61.65,28.54 61.65,29.41 v2(61.82,29.58) ; 61.65,28.54 61.65,27.92 C5155.2
  BOTTOM w0.114: CON5102.23 59.56,46.85 62.08,44.32 62.08,41.03 61.65,40.59 61.65,32.15 61.83,31.97 61.83,29.59 v2(61.82,29.58)
PCIE_SATA_TXN3: length 140.2
  TOP w0.114: 41.07,26.13 42.39,26.13 42.49,26.23 42.49,26.38 C5158.1 ; 41.07,26.13 40.94,26.13 40.84,26.23 40.84,27.55 41.33,28.03 41.33,29.92 46.56,35.15 46.56,35.73 48.53,37.7 48.53,41.46 50.6,43.53 50.6,44.35 v2(50.75,44.51) ; 41.07,26.13 v1(41.07,26.36)
  IN4 w0.089: v2(158.8,45.29) 158.8,44.65 158.7,44.54 158.34,44.54 158.24,44.64 158.24,44.8 158.16,44.88 158.01,44.88 157.04,43.91 151.1,43.91 150.47,43.27 144.2,43.27 142.1,45.37 140.07,45.37 139.19,44.49 130.87,44.49 130.22,45.15 123.41,45.15 122.75,44.49 111.86,44.49 111.65,44.28 100.39,44.28 98.92,45.75 73.26,45.75 72.7,45.19 67.77,45.19 67.54,45.42 51.16,45.42 50.6,44.85 50.6,44.67 v2(50.75,44.51)
  BOTTOM w0.089: U2000.B35 159.63,45.51 159.02,45.51 v2(158.8,45.29)
PCIE_SATA_TXN3_C: length 51.4
  TOP w0.114: 42.48,28.38 42.43,28.34 42.43,27.99 C5158.2 ; 42.48,28.38 v1(42.32,28.54) ; 42.48,28.38 43.13,29.04 43.13,29.62 v2(42.98,29.76)
  IN1 w0.089: v2(63.42,29.81) 63.19,30.05 63.19,30.3 62.91,30.58 60.86,30.58 60.56,30.27 53.75,30.27 53.44,30.58 43.38,30.58 43.17,30.37 43.17,29.95 v2(42.98,29.76)
  BOTTOM w0.114: v2(63.42,29.81) 63.42,30.62 64.89,32.09 64.99,32.09 65.58,32.09 66.45,32.97 66.45,35.93 65.58,36.8 64.95,36.8 62.92,38.83 62.92,39.38 63.4,39.86 63.4,45.26 58.94,49.72 58.67,49.72 58.54,49.85 CON5102.11
PCIE_SATA_TXP0: length 128.5
  TOP w0.114: C5132.1 57.66,26.2 v2(57.76,26.09)
  IN4 w0.089: v2(158.7,47.55) 158.46,47.31 158.46,47.15 158.3,46.99 157.8,46.99 157.26,46.45 156.62,46.45 156.11,45.94 144.33,45.94 143.18,47.09 139.03,47.09 138.98,47.03 131.92,47.03 131.23,47.72 124.35,47.72 123.76,47.13 111.83,47.13 110.79,46.09 102.5,46.09 100.52,48.07 90.17,48.07 89.64,47.54 67.43,47.54 67.18,47.79 67.18,48 v2(66.93,48.25)
  BOTTOM w0.089: v2(158.7,47.55) 158.43,47.81 158.43,47.89 158.51,47.97 160.01,47.97 U2000.B31
  BOTTOM w0.114: 68.07,42.13 v1(67.84,42.13) ; 68.07,42.13 68.07,37.87 66.87,36.68 66.87,31.97 63.53,28.62 59.64,28.62 58.13,27.12 58.13,26.47 v2(57.76,26.09) ; 68.07,42.13 68.07,42.73 66.75,44.05 66.75,47.03 67.32,47.61 67.32,47.86 67.23,47.95 66.98,47.95 66.93,48 66.93,48.25 v2(66.93,48.25)
PCIE_SATA_TXP0_C: length 15.7
  TOP w0.114: C5132.2 57.95,27.92 57.95,29.37 v2(57.76,29.56)
  BOTTOM w0.114: CON5102.49 58.43,40.35 58.56,40.48 58.7,40.48 58.79,40.39 58.79,36.72 60.06,35.45 60.06,32.19 57.98,30.11 57.98,29.97 57.98,29.78 v2(57.76,29.56)
PCIE_SATA_TXP1: length 125
  TOP w0.114: C5151.1 59.37,26.18 v2(59.45,26.1)
  IN4 w0.089: v2(67.44,46.55) 67.67,46.78 67.67,46.97 67.84,47.15 99.79,47.15 101.26,45.68 111.02,45.68 111.3,45.96 122.33,45.96 123.08,46.71 124.16,46.71 124.55,47.1 130.99,47.1 132.13,45.96 138.52,45.96 139.25,46.69 142.94,46.69 144.14,45.48 156.21,45.48 156.7,45.97 158.23,45.97 158.4,46.15 158.4,46.27 v2(158.17,46.51)
  BOTTOM w0.089: U2000.B32 160.08,47.32 160.04,47.27 159.88,47.12 159.59,47.12 159.14,47.12 158.94,46.92 158.58,46.92 v2(158.17,46.51)
  BOTTOM w0.114: 69.15,38.35 v1(68.93,38.35) ; 69.15,38.35 69.15,43 67.61,44.55 67.61,46.38 v2(67.44,46.55) ; 69.15,38.35 69.15,37.46 67.67,35.97 67.67,31.82 63.64,27.79 62.79,27.79 62.79,27.79 60.58,27.79 59.61,26.82 59.61,26.26 v2(59.45,26.1)
PCIE_SATA_TXP1_C: length 18.9
  TOP w0.114: v2(59.39,29.58) 59.79,29.18 59.79,28.17 59.66,28.04 59.45,28.04 59.37,27.96 C5151.2
  BOTTOM w0.114: CON5102.37 58.48,43.35 58.61,43.48 58.78,43.48 59.98,42.29 59.98,37.48 60.76,36.7 60.76,31.44 59.6,30.28 59.6,29.8 v2(59.39,29.58)
PCIE_SATA_TXP2: length 122.8
  TOP w0.114: v2(61.29,26.09) 61.12,26.26 C5154.1
  IN4 w0.089: v2(156.9,45.29) 157.03,45.16 157.03,45.04 156.71,44.72 150.73,44.72 150.09,44.09 144.52,44.09 142.49,46.12 139.59,46.12 138.71,45.24 131.8,45.24 131.13,45.91 123.1,45.91 122.43,45.24 111.46,45.24 111.27,45.04 100.86,45.04 99.37,46.54 69.16,46.54 68.96,46.35 68.86,46.35 v2(68.45,45.94)
  BOTTOM w0.089: U2000.B33 160.22,46.69 160.13,46.61 159.49,46.61 158.98,46.09 157.4,46.09 157.09,45.78 157.09,45.49 v2(156.9,45.29)
  BOTTOM w0.114: v1(70.29,39.67) 70.52,39.67 ; 70.52,39.67 70.52,43.35 68.68,45.19 68.68,45.72 v2(68.45,45.94) ; 70.52,39.67 70.52,37.28 68.78,35.54 68.78,31.97 63.85,27.04 61.87,27.04 61.46,26.64 61.46,26.27 v2(61.29,26.09)
PCIE_SATA_TXP2_C: length 22.6
  TOP w0.114: v2(61.19,29.58) 61.41,29.36 61.41,27.92 C5154.2
  BOTTOM w0.114: v2(61.19,29.58) 61.59,29.99 61.59,31.87 61.41,32.05 61.41,40.69 61.85,41.13 61.85,44.23 59.46,46.62 58.69,46.62 58.62,46.54 58.62,46.43 58.54,46.35 CON5102.25
PCIE_SATA_TXP3: length 140
  TOP w0.114: 41.09,29.61 41.09,28.13 40.61,27.65 40.61,26.13 40.84,25.9 42.49,25.9 42.72,26.13 42.72,26.53 C5159.1 ; 41.09,29.61 41.09,30.02 46.32,35.25 46.32,35.82 48.3,37.8 48.3,41.56 50.36,43.63 50.36,44.3 v2(50.14,44.51) ; 41.09,29.61 v1(40.87,29.61)
  IN4 w0.089: v2(158.17,45.29) 156.96,44.09 151.03,44.09 150.4,43.45 144.27,43.45 142.18,45.54 140,45.54 139.12,44.67 130.95,44.67 130.29,45.33 123.34,45.33 122.68,44.67 111.79,44.67 111.58,44.46 100.46,44.46 98.99,45.93 73.18,45.93 72.62,45.37 67.84,45.37 67.62,45.6 51.09,45.6 50.42,44.92 50.42,44.79 v2(50.14,44.51)
  BOTTOM w0.089: U2000.A35 159.8,45.95 159.55,45.7 158.57,45.7 v2(158.17,45.29)
PCIE_SATA_TXP3_C: length 51.2
  TOP w0.114: C5159.2 42.66,27.96 42.66,28.24 43.36,28.94 43.36,29.53 v2(43.59,29.76)
  IN1 w0.089: v2(62.79,29.81) 63.01,30.04 63.01,30.22 62.84,30.4 60.94,30.4 60.63,30.09 53.67,30.09 53.37,30.4 43.45,30.4 43.35,30.29 43.35,30.01 v2(43.59,29.76)
  BOTTOM w0.114: CON5102.13 58.54,49.35 58.67,49.48 58.84,49.48 63.16,45.16 63.16,39.96 62.69,39.48 62.69,38.73 64.85,36.56 65.49,36.56 66.22,35.83 66.22,33.07 65.48,32.33 65.09,32.33 65.09,32.33 64.8,32.33 63.19,30.72 63.19,30.42 63.09,30.32 62.57,30.32 62.41,30.16 62.41,29.89 62.49,29.81 v2(62.79,29.81)
PCIE_TXN7_WLAN: length 150.2
  IN4 w0.089: v2(145.34,55.89) 145.34,56.71 145.56,56.93 147.82,56.93 148.39,57.5 151.43,57.5 158.61,64.68 162.28,64.68 168.45,70.86 177.49,70.86 177.77,71.14 180.79,71.14 181.08,70.86 187.01,70.86 189.03,68.83 193.91,68.83 201.29,61.46 201.29,59.36 203.09,57.56 208.51,57.56 208.74,57.33 212.99,57.33 213.65,57.98 217.15,57.98 217.8,58.63 221.84,58.63 222.2,58.98 230.9,58.98 232.64,60.72 234.63,60.72 235.23,61.33 238.45,61.33 238.81,61.7 238.81,78.37 239.55,79.11 241.46,79.11 242.62,80.27 242.62,83.56 243.28,84.22 244.35,84.22 244.68,83.89 244.68,83.68 v7(244.91,83.45)
  BOTTOM w0.114: v7(244.91,83.45) 244.75,83.61 CON5300.37 ; C2021.1 151.69,50.13 149.35,50.13 149.05,49.83 146.4,49.83 145.59,50.64 145.59,53.31 145.34,53.56 v2(145.34,55.89)
PCIE_TXN7_WLAN_C: length 9.4
  BOTTOM w0.089: 153.09,50 153.36,50.27 153.6,50.27 153.79,50.47 153.79,51.01 156.09,53.31 159.2,53.31 159.69,53.8 160.04,53.8 U2000.B20
  BOTTOM w0.114: 153.09,50 C2021.2
PCIE_TXP7_WLAN: length 150
  IN4 w0.089: v2(244.22,83.45) 244.27,83.45 244.5,83.68 244.5,83.81 244.28,84.04 243.36,84.04 242.8,83.48 242.8,80.2 241.54,78.93 239.62,78.93 238.99,78.3 238.99,61.62 238.52,61.16 235.31,61.16 234.7,60.55 232.71,60.55 230.97,58.81 222.27,58.81 221.92,58.45 217.87,58.45 217.22,57.8 213.72,57.8 213.07,57.15 208.67,57.15 208.43,57.39 203.01,57.39 201.11,59.29 201.11,61.38 193.84,68.66 188.96,68.66 186.94,70.68 181,70.68 180.72,70.96 177.85,70.96 177.57,70.68 168.52,70.68 162.35,64.5 158.68,64.5 151.5,57.32 148.46,57.32 147.9,56.76 145.64,56.76 145.52,56.63 145.52,56.3 145.62,56.2 145.9,56.2 145.97,56.13 v2(145.97,55.89)
  BOTTOM w0.114: CON5300.35 244.25,83.48 v2(244.22,83.45) ; 149.53,50.36 151.69,50.36 C2020.1 ; 149.53,50.36 149.25,50.36 148.95,50.06 146.5,50.06 145.82,50.74 145.82,53.41 145.57,53.66 145.57,55.49 v2(145.97,55.89) ; 149.53,50.36 v1(149.53,50.61)
PCIE_TXP7_WLAN_C: length 9.9
  BOTTOM w0.089: 153.09,50.48 153.11,50.46 153.52,50.46 153.6,50.55 153.6,51.09 156.01,53.5 159.12,53.5 159.61,53.99 160.12,53.99 160.24,53.87 160.4,53.87 160.65,53.62 U2000.C20
  BOTTOM w0.114: C2020.2 153.09,50.48
PCIEGPU_WAKE#_R: length 5
  TOP w0.102: T7000.1 87.76,135.93 v2(87.76,135.45)
  BOTTOM w0.102: U7000.BJ21 89.92,137.9 88.09,136.08 88.09,135.79 v2(87.76,135.45)
PDB: length 258.6
  TOP w0.102: v2(22.54,66.06) 22.5,66.02 21.37,66.02 21.1,66.29 U3600.47 ; Q3602.3 7.04,64.97 7.31,65.24 v1(7.81,65.24) 8.03,65.02 8.76,65.02 9.2,65.46 9.2,66.26 9.5,66.56 R3608.2 9.83,67.66 10.5,68.32 v2(11.19,68.32)
  IN1 w0.102: v2(202.01,28.14) 201.19,28.14 200.7,28.63 199.06,28.63 198.67,29.02 198.67,29.7 199.23,30.26 199.23,34.98 200.58,36.33 v2(200.58,37.05)
  IN3 w0.102: v2(22.54,66.06) 21.44,66.06 21.26,65.88 21.26,64.64 20.54,63.91 13.41,63.91 12.88,64.44 12.88,66.39 12.37,66.9 12.37,67.53 11.58,68.32 v2(11.19,68.32)
  IN4 w0.102: v2(22.54,66.06) 22.82,65.78 22.82,61.97 28.39,56.39 28.39,46.7 29.64,45.45 29.64,37.19 35.8,31.03 111.08,31.03 115.33,26.78 153.13,26.78 156.5,23.41 198.57,23.41 202.01,26.85 v2(202.01,28.14)
  BOTTOM w0.102: v2(22.54,66.06) 21.03,66.06 20.92,66.17 20.18,66.17 19.96,66.39 D3601.1 ; R3702.1 v2(200.58,37.05)
PECI_PCH: length 287.9
  IN1 w0.076: v2(16.01,88.27) 14.75,89.53 11.52,89.53 10.09,90.96 10.09,124.73 10.69,125.34 11.69,125.34 20.27,133.92 20.27,134.45 22.19,136.38 22.19,144.82 23.14,145.76 23.72,145.76 24.57,146.6 24.57,149.54 22.25,151.86 20.42,151.86 v6(20.24,152.03)
  IN2 w0.114: v2(171.5,69.23) 170.97,68.7 170.97,68.07 170.84,67.94 169.5,67.94 167.52,65.96 158.55,65.96 156.77,64.18 156.77,63.32 154.66,61.21 152.42,61.21 148.85,57.65 144.44,57.65 142.83,56.05 142.83,54.18 142.48,53.83 142.48,51.7 140.69,49.91 138.98,49.91 138.14,50.75 125.76,50.75 125.26,50.26 106.27,50.26 103.73,52.8 v2(98.55,52.8)
  IN4 w0.076: v2(16.01,88.27) 16.01,87.94 16.29,87.66 16.29,86.92 17.91,85.31 17.91,84.24 19.16,82.99 21.86,82.99 25.96,78.88 25.96,74.35 25.62,74.01 25.62,70.82 28.12,68.32 28.12,61.4 28.73,60.79 28.73,60.34 34.13,54.94 47.41,54.94 50.9,51.45 97.21,51.45 v2(98.55,52.8)
  BOTTOM w0.089: 174.55,61.97 174.3,62.22 174.3,62.49 174.37,62.56 174.37,62.96 174.3,63.03 174.3,63.94 173.45,64.79
  BOTTOM w0.102: 174.55,61.97 U2000.AL3
  BOTTOM w0.114: v6(20.24,152.03) 20.57,152.36 v1(20.57,154.73) 20.57,155.08 20.2,155.46 R0746.1 ; 173.45,64.79 173.15,65.09 173.15,65.27 172.9,65.52 172.11,65.52 171.87,65.76 171.87,67.59 C2201.1 171.95,68.35 171.95,69.36 R2235.1 v2(171.5,69.23)
PEG_RCOMP: length 14.2
  BOTTOM w0.152: v1(69.6,120.6) 69.16,120.6 68.44,121.32 68.36,121.32 68.34,121.34 67.43,121.34 67.18,121.58 R0600.2
  BOTTOM w0.254: U0300.G2 58.23,125.7 58.23,124.82 60.01,123.03 63.98,123.03 64.69,122.32 66.65,122.32 R0600.2
PEG_RXN_0: length 20.5
  TOP w0.076: v6(59.94,130.59) 60.17,130.36 61.74,130.36 62.27,129.82 62.3,129.82 62.31,129.81
  TOP w0.114: v1(72.01,128.77) 72.01,128.49 ; 72.01,128.49 70.69,128.49 69.44,129.74 62.38,129.74 62.31,129.81 ; 72.01,128.49 76.41,128.49 76.81,128.09 77.29,128.09 77.43,128.23 77.43,128.43 77.36,128.5 77.36,128.63 77.47,128.74 C0631.2
  BOTTOM w0.076: v6(59.94,130.59) 59.94,130.88 59.84,130.98 U0300.E10
PEG_RXN_1: length 16.5
  TOP w0.114: v6(59.94,131.37) 60.57,130.74 61.91,130.74 62.46,130.19 70.69,130.19 ; 70.69,130.19 v1(70.69,129.94) ; 70.69,130.19 71.37,130.19 72.31,129.25 C0629.2
  BOTTOM w0.076: U0300.E11 59.94,131.44 v6(59.94,131.37)
PEG_RXN_2: length 20.3
  TOP w0.114: 65.79,131.11 64.03,131.11 63.58,131.56 62.08,131.56 61.62,132.03 60.22,132.03 v6(59.29,132.95) ; 65.79,131.11 v1(65.79,131.36) ; 65.79,131.11 77.42,131.11 C0627.2
  BOTTOM w0.076: U0300.E12 59.61,132.63 v6(59.29,132.95)
PEG_RXN_3: length 16.5
  TOP w0.114: C0625.2 74.46,132.39 73.87,132.39 73.67,132.19 ; v6(59.94,132.95) 60.57,132.32 61.98,132.32 62.43,131.88 73.36,131.88 73.67,132.19 ; 73.67,132.19 v1(73.91,131.95)
  BOTTOM w0.076: U0300.E13 59.61,133.27 v6(59.94,132.95)
PEG_RXN_4: length 21.6
  TOP w0.114: 71.78,133.44 74.14,133.44 74.77,134.07 77.51,134.07 C0623.2 ; 71.78,133.44 71.43,133.44 71.02,133.04 63.38,133.04 63.19,133.22 62.18,133.22 61.79,133.6 59.23,133.6 58.88,133.95 58.88,134.11 v6(59.29,134.52) ; 71.78,133.44 v1(71.78,133.7)
  BOTTOM w0.076: U0300.E14 59.36,134.13 59.29,134.2 v6(59.29,134.52)
PEG_RXN_5: length 17
  TOP w0.114: v6(59.94,134.52) 60.11,134.36 60.11,134.09 60.3,133.9 62.15,133.9 62.55,133.5 70.35,133.5 71.93,135.09 73.89,135.09 ; C0621.2 74.56,135.09 73.89,135.09 ; 73.89,135.09 v1(73.89,134.82)
  BOTTOM w0.076: v6(59.94,134.52) 59.61,134.85 U0300.E15
PEG_RXN_6: length 20.7
  TOP w0.114: C0619.2 77.52,137.13 77.39,137 77.39,136.58 77.29,136.47 76.65,136.47 76.34,136.77 73.81,136.77 ; v1(73.81,137.05) 73.81,136.77 ; 73.81,136.77 72.24,136.77 70.66,135.2 69.37,135.2 68.78,134.61 63.48,134.61 63.32,134.77 61.97,134.77 61.59,135.15 60.1,135.15 v6(59.94,135.31)
  BOTTOM w0.076: U0300.E16 59.84,135.7 59.94,135.61 v6(59.94,135.31)
PEG_RXN_7: length 17.4
  TOP w0.114: 68.81,135.75 70.53,135.75 72.5,137.72 74.59,137.72 C0617.2 ; 68.81,135.75 68.02,135.75 67.56,135.29 64.43,135.29 64.18,135.04 62.37,135.04 61.97,135.44 60.36,135.44 60.15,135.65 60.15,135.89 v6(59.94,136.1) ; 68.81,135.75 v1(68.81,135.5)
  BOTTOM w0.076: U0300.E17 59.61,136.42 v6(59.94,136.1)
PEG_RXN_8: length 22.3
  TOP w0.076: 63.43,136.18 63.39,136.13 63.26,136.13 63.09,136.3 61.95,136.3 61.61,136.64 60.46,136.64 60.03,137.07 59.63,137.07 59.44,137.25 59.14,137.25 59.01,137.25 v6(58.64,136.89)
  TOP w0.114: 65.38,136.18 65.98,136.18 66.5,136.7 69.01,136.7 69.45,137.13 70.64,137.13 71.17,137.66 73.07,139.56 76.09,139.56 76.28,139.76 77.2,139.76 77.4,139.56 77.49,139.56 C0615.2 ; 65.38,136.18 63.43,136.18 ; 65.38,136.18 v1(65.38,136.44)
  BOTTOM w0.076: U0300.F18 58.85,137.16 58.85,137.09 v6(58.64,136.89)
PEG_RXN_9: length 18
  TOP w0.114: 73.91,140.81 74.42,140.81 C0613.2 ; 73.91,140.81 73.35,140.81 72.52,139.97 70.36,137.82 67.54,137.82 67.23,137.51 65.3,137.51 64.66,136.86 62.23,136.86 61.85,137.25 60.48,137.25 60.38,137.35 60.38,137.47 v6(60.59,137.67) ; 73.91,140.81 v1(73.91,141.09)
  BOTTOM w0.076: v6(60.59,137.67) 60.59,138.16 60.53,138.22 60.42,138.22 U0300.D19
PEG_RXN_10: length 23.3
  TOP w0.114: v6(58.64,139.25) 58.64,138.45 59.01,138.09 61.47,138.09 61.82,137.74 63.17,137.74 63.45,137.45 64.59,137.45 65.58,138.44 66.73,138.44 ; v1(66.73,138.17) 66.73,138.44 ; 66.73,138.44 70.38,138.44 74.1,142.16 77.52,142.16 C0611.2
  BOTTOM w0.076: v6(58.64,139.25) 58.64,139.17 U0300.F20
PEG_RXN_11: length 18.9
  TOP w0.114: C0605.2 74.56,143.87 74.56,143.72 74.47,143.62 73.35,143.62 72.71,142.98 ; v1(72.52,143.17) 72.71,142.98 ; 72.71,142.98 71.62,141.9 71.62,141.14 69.95,139.46 64.74,139.46 63.75,138.47 62.6,138.47 62.26,138.81 60.47,138.81 60.36,138.91 60.36,139.06 60.55,139.25 v6(60.59,139.25)
  BOTTOM w0.076: v6(60.59,139.25) 60.59,139.59 60.54,139.64 U0300.D21
PEG_RXN_12: length 22.8
  TOP w0.114: v1(73.84,144.72) 73.84,144.98 ; 73.84,144.98 73.54,144.98 70.84,142.28 70.84,141.09 69.72,139.97 64.54,139.97 63.89,139.32 61.83,139.32 61.51,139.64 59.69,139.64 v6(59.29,140.04) ; 73.84,144.98 77.49,144.98 C0609.2
  BOTTOM w0.114: U0300.F22 59.29,140.1 v6(59.29,140.04)
PEG_RXN_13: length 18.8
  TOP w0.114: 64.59,141.34 66.24,141.34 67.39,142.49 69.7,142.49 73.79,146.58 74.48,146.58 C0608.2 ; 64.59,141.34 v1(64.59,141.62) ; 64.59,141.34 64.41,141.34 63.2,140.13 62.49,140.13 61.95,140.66 60.1,140.66 v6(59.94,140.82)
  BOTTOM w0.076: v6(59.94,140.82) 59.94,140.89 U0300.D23
PEG_RXN_14: length 23.2
  TOP w0.114: v6(58.64,141.61) 59.04,141.21 63.12,141.21 64.06,142.15 66.24,142.15 67.13,143.04 69.64,143.04 71.91,145.31 71.91,146.17 ; v1(72.16,146.17) 71.91,146.17 ; 71.91,146.17 71.91,146.5 73.14,147.74 75.9,147.74 76.22,147.41 C0602.2
  BOTTOM w0.114: v6(58.64,141.61) 58.64,141.68 U0300.F24
PEG_RXN_15: length 20.7
  TOP w0.114: 71.82,148.47 71.01,147.66 71.01,145.73 69.29,144.01 66.74,144.01 65.78,143.05 63.29,143.05 62.94,142.69 61.8,142.69 61.11,142 59.79,142 59.72,142.08 59.72,142.18 v6(59.94,142.4) ; 71.82,148.47 72.63,149.28 74.39,149.28 74.47,149.37 74.47,149.5 C0600.2 ; 71.82,148.47 v1(71.65,148.63)
  BOTTOM w0.114: U0300.D25 60.07,142.79 59.94,142.66 v6(59.94,142.4)
PEG_RXP_0: length 20.5
  TOP w0.076: 62.14,129.65 62.13,129.66 62.13,129.73 61.67,130.19 59.69,130.19 v6(59.29,130.59)
  TOP w0.114: 73.84,128.26 76.31,128.26 76.71,127.86 C0630.2 ; 73.84,128.26 v1(73.84,128.01) ; 73.84,128.26 70.59,128.26 69.34,129.51 62.28,129.51 62.14,129.65
  BOTTOM w0.076: v6(59.29,130.59) 59.29,130.65 U0300.F10
PEG_RXP_1: length 16.6
  TOP w0.114: 73.84,129.49 72.41,129.49 71.47,130.43 62.55,130.43 62,130.98 60.71,130.98 60.59,131.09 v6(60.59,131.37) ; 73.84,129.49 74.17,129.49 74.32,129.64 74.32,130.04 74.42,130.14 C0628.2 ; 73.84,129.49 v1(73.84,129.76)
  BOTTOM w0.076: U0300.D11 60.48,131.77 60.59,131.65 v6(60.59,131.37)
PEG_RXP_2: length 20.3
  TOP w0.114: 72.31,130.87 63.94,130.87 63.48,131.33 61.98,131.33 61.52,131.79 60.12,131.79 59.61,132.3 59.43,132.3 v6(59.29,132.16) ; 72.31,130.87 77.52,130.87 77.57,130.93 C0626.2 ; 72.31,130.87 v1(72.31,130.62)
  BOTTOM w0.076: U0300.F12 59.23,132.55 59.29,132.5 v6(59.29,132.16)
PEG_RXP_3: length 15.8
  TOP w0.114: v1(72.64,132.35) 72.64,132.11 ; 72.64,132.11 62.52,132.11 62.08,132.55 60.68,132.55 60.59,132.65 v6(60.59,132.95) ; 72.64,132.11 73.26,132.11 73.52,132.37 73.77,132.62 74.49,132.62 C0624.2
  BOTTOM w0.076: U0300.D13 60.27,133.27 v6(60.59,132.95)
PEG_RXP_4: length 21.6
  TOP w0.114: 76.78,133.83 77.54,133.83 C0622.2 ; 76.78,133.83 74.86,133.83 74.24,133.21 71.52,133.21 71.12,132.8 63.28,132.8 63.1,132.98 62.08,132.98 61.7,133.36 59.13,133.36 58.64,133.86 v6(58.64,134.52) ; 76.78,133.83 v1(76.78,133.6)
  BOTTOM w0.076: U0300.F14 58.96,134.2 v6(58.64,134.52)
PEG_RXP_5: length 16.8
  TOP w0.114: 69.72,133.74 70.25,133.74 71.83,135.32 74.4,135.32 C0620.2 ; 69.72,133.74 v1(69.72,134) ; 69.72,133.74 62.65,133.74 62.25,134.14 60.4,134.14 60.34,134.19 60.34,134.28 v6(60.59,134.52)
  BOTTOM w0.076: v6(60.59,134.52) 60.59,134.83 60.5,134.92 U0300.D15
PEG_RXP_6: length 20.8
  TOP w0.114: v6(59.29,135.31) 59.68,134.92 61.49,134.92 61.88,134.53 63.22,134.53 63.38,134.38 68.88,134.38 69.47,134.96 70.76,134.96 71.89,136.1 ; 71.89,136.1 72.34,136.54 76.25,136.54 76.55,136.24 C0618.2 ; 71.89,136.1 v1(72.09,135.91)
  BOTTOM w0.076: U0300.F16 58.96,135.64 v6(59.29,135.31)
PEG_RXP_7: length 17.3
  TOP w0.114: 67.06,135.53 67.46,135.53 67.92,135.98 70.43,135.98 72.4,137.95 74.36,137.95 C0616.2 ; 67.06,135.53 v1(67.06,135.81) ; 67.06,135.53 64.34,135.53 64.08,135.27 62.47,135.27 62.06,135.68 60.46,135.68 60.38,135.75 60.38,135.89 v6(60.59,136.1)
  BOTTOM w0.076: U0300.D17 60.5,136.49 60.59,136.4 v6(60.59,136.1)
PEG_RXP_8: length 22.4
  TOP w0.076: v6(59.29,136.89) 59.08,136.68 59.08,136.54 59.13,136.49 59.54,136.49 59.66,136.62 59.66,136.81 59.76,136.9 59.97,136.9 60.39,136.48 61.55,136.48 61.89,136.14 63.03,136.14 63.19,135.97 63.41,135.97 63.43,135.95
  TOP w0.114: 73.89,139.33 76.18,139.33 76.38,139.52 77.1,139.52 77.3,139.33 77.56,139.33 C0614.2 ; 73.89,139.33 73.17,139.33 71.41,137.57 71.41,137.56 70.74,136.9 69.55,136.9 69.11,136.46 66.59,136.46 66.08,135.95 63.43,135.95 ; 73.89,139.33 v1(73.89,139.08)
  BOTTOM w0.076: U0300.E18 59.5,137.17 59.5,137.1 v6(59.29,136.89)
PEG_RXP_9: length 18
  TOP w0.114: 68.73,137.58 70.46,137.58 73.45,140.58 74.53,140.58 C0612.2 ; 68.73,137.58 v1(68.73,137.3) ; 68.73,137.58 67.64,137.58 67.33,137.27 65.4,137.27 64.76,136.63 62.14,136.63 61.75,137.02 60.39,137.02 60.15,137.25 60.15,137.47 v6(59.94,137.67)
  BOTTOM w0.076: U0300.E19 59.61,138 v6(59.94,137.67)
PEG_RXP_10: length 23.3
  TOP w0.114: v1(64.85,138.47) 65.06,138.26 ; 65.06,138.26 65.48,138.68 70.28,138.68 72.05,140.44 74,142.39 77.53,142.39 C0606.2 ; 65.06,138.26 64.49,137.68 63.55,137.68 63.26,137.97 61.92,137.97 61.57,138.32 59.1,138.32 58.88,138.55 58.88,138.83 v6(59.29,139.24)
  BOTTOM w0.076: v6(59.29,139.24) 59.29,138.9 59.33,138.85 U0300.E20
PEG_RXP_11: length 18.9
  TOP w0.114: 71.86,141.39 71.86,141.8 73.45,143.39 74.64,143.39 C0610.2 ; 71.86,141.39 v1(72.14,141.39) ; 71.86,141.39 71.86,141.04 70.05,139.23 64.84,139.23 63.85,138.24 62.5,138.24 62.17,138.57 60.37,138.57 60.13,138.81 60.13,138.97 59.94,139.16 v6(59.94,139.25)
  BOTTOM w0.076: v6(59.94,139.25) 59.94,139.31 U0300.E21
PEG_RXP_12: length 22.1
  TOP w0.114: v6(59.94,140.04) 60.1,139.87 61.6,139.87 61.93,139.55 63.79,139.55 64.44,140.2 69.62,140.2 70.61,141.19 70.61,141.75 ; 70.61,141.75 70.61,142.38 73.44,145.22 77.56,145.22 C0604.2 ; 70.61,141.75 v1(70.36,141.75)
  BOTTOM w0.114: U0300.E22 59.94,140.1 v6(59.94,140.04)
PEG_RXP_13: length 19.5
  TOP w0.114: 66.17,141.11 64.51,141.11 63.29,139.89 62.39,139.89 61.85,140.43 59.69,140.43 v6(59.29,140.82) ; 66.17,141.11 66.34,141.11 67.49,142.26 69.8,142.26 73.89,146.35 74.47,146.35 C0603.2 ; 66.17,141.11 v1(66.17,140.84)
  BOTTOM w0.076: U0300.E23 59.29,140.89 v6(59.29,140.82)
PEG_RXP_14: length 23.2
  TOP w0.114: 73.46,147.97 76,147.97 76.32,147.65 76.76,147.65 76.91,147.8 76.91,147.97 76.84,148.05 76.84,148.2 76.94,148.3 C0601.2 ; 73.46,147.97 73.05,147.97 71.67,146.6 71.67,145.41 69.54,143.27 67.03,143.27 66.14,142.38 63.96,142.38 63.02,141.45 59.45,141.45 v6(59.29,141.61) ; 73.46,147.97 v1(73.46,148.25)
  BOTTOM w0.114: U0300.E24 59.41,142 59.29,141.88 v6(59.29,141.61)
PEG_RXP_15: length 20.8
  TOP w0.114: 62.2,142.45 61.9,142.45 61.21,141.77 59.69,141.77 59.48,141.98 59.48,142.2 v6(59.29,142.4) ; 62.2,142.45 63.04,142.45 63.39,142.81 65.87,142.81 66.84,143.78 69.39,143.78 71.25,145.64 71.25,147.57 72.73,149.05 74.44,149.05 C0607.2 ; 62.2,142.45 v1(62.2,142.21)
  BOTTOM w0.114: U0300.E25 59.29,142.46 v6(59.29,142.4)
PET0_N: length 3.8
  TOP w0.089: U1101.V22 239.91,28.92 239.91,28.48 239.78,28.36 239.78,27.63 239.77,27.61
  TOP w0.114: 239.77,27.61 238.69,26.54 238.69,26.27 238.83,26.13 C1102.2
PET0_P: length 3.8
  TOP w0.089: 239.58,27.76 239.59,27.78 239.59,28.37 239.47,28.49 239.47,28.82 239.53,28.88 239.63,28.88 239.69,28.83 U1101.V23
  TOP w0.114: 239.58,27.76 238.45,26.63 238.45,26.32 238.26,26.13 C1101.2
PET1_N: length 3.3
  TOP w0.089: 241.31,27.68 241.31,27.69 241.35,27.72 241.35,27.76 241.43,27.85 241.43,28.32 241.3,28.45 241.3,28.92 U1101.P22
  TOP w0.114: 241.31,27.68 241.31,26.35 C1104.2
PET1_P: length 3.3
  TOP w0.089: 241.55,27.68 241.55,27.69 241.62,27.77 241.62,28.33 241.76,28.47 241.76,28.82 241.7,28.88 241.59,28.88 241.53,28.81 U1101.P23
  TOP w0.114: C1103.2 241.55,26.44 241.55,27.68
PET2_N: length 3.6
  TOP w0.089: 243.25,27.83 243.27,27.85 243.27,28.32 243.14,28.46 243.14,28.92 U1101.K22
  TOP w0.114: 243.25,27.83 243.25,27.12 243.79,26.58 243.79,26.27 C1106.2
PET2_P: length 3.9
  TOP w0.089: 243.49,27.83 243.46,27.86 243.46,28.38 243.6,28.52 243.6,28.82 243.55,28.87 243.4,28.87 243.37,28.84 U1101.K23
  TOP w0.114: C1105.2 244.03,26.27 244.03,26.68 243.88,26.83 ; 243.88,26.83 v1(244.04,26.99) ; 243.88,26.83 243.49,27.22 243.49,27.83
PET3_N: length 3.9
  TOP w0.089: 245.15,27.76 245.1,27.81 245.1,28.37 244.98,28.5 244.98,28.92 U1101.F22
  TOP w0.114: 245.15,27.76 245.33,27.59 246.19,26.73 246.19,26.27 C1108.2
PET3_P: length 3.9
  TOP w0.089: 245.32,27.93 245.31,27.94 245.31,28.4 245.44,28.53 245.44,28.8 245.36,28.89 245.29,28.89 245.21,28.81 U1101.F23
  TOP w0.114: 245.32,27.93 246.42,26.82 246.42,26.27 C1107.2
PEX_CLKREQ#: length 245.7
  TOP w0.102: v2(179.77,47.31) 180.3,46.77 180.8,46.77 181.86,45.71 183.63,45.71 183.97,46.05 184.57,46.05 184.89,46.37 R2431.2
  IN1 w0.102: v2(192.45,83.54) 191.63,83.54 190.72,84.44 190.72,85.49 189.66,86.55 188.74,86.72 186.87,86.72 186.3,87.29 184,87.29 183.03,88.27 182.56,88.27 182.22,88.6 181.41,88.6 181.22,88.4 175.1,88.4 174.34,87.65 173.99,87.65 172.39,89.25 161.68,89.25 160.55,88.11 160.55,85.81 158.95,84.21 156.08,84.21 154.65,85.64 152.32,85.64 151.39,86.58 149.04,86.58 148.17,87.44 143.61,87.44 142.02,85.86 139.18,85.86 138.32,84.99 123.76,84.99 120.8,82.04 118.08,82.04 117.11,83 113.51,83 112.38,84.13 108.98,84.13 107.58,85.53 107.58,92.1 97.64,102.05 97.64,110.77 97.76,110.9 97.76,112.15 97.25,112.67 97.25,116.95 98.35,118.05 98.35,120.62 98.98,121.25 98.98,127.37 99.87,128.26 99.87,132.86 99.37,133.36 97.18,133.36 96.84,133.71 96.84,134.78 98.6,136.54 98.6,139.52 98.25,139.88 96.17,139.88 95.77,139.48 92.93,139.48 92.68,139.23 92.68,138.26 92.43,138.02 88.77,138.02 83.24,132.48 v2(83.24,130.32) ; v2(179.77,47.31) 180.26,47.81 180.26,56.82 179.15,57.93 176.26,57.93 175.82,58.37 175.82,60.53 178.38,63.09 178.72,63.09 179.1,63.46 179.1,65.55 181.82,68.27 181.82,69.22 182.26,69.66 188.29,69.66 v2(188.97,70.35)
  BOTTOM w0.102: R7010.2 83.29,129.84 83.29,130.27 v2(83.24,130.32) 83.21,130.35 v1(82.07,130.35) 83.31,131.59 Q7000.3 ; U2000.BC32 179.96,47.51 v2(179.77,47.31) ; v2(188.97,70.35) 188.66,70.67 188.66,71.7 187.85,72.51 187.85,73.17 187.63,73.39 187.63,78.44 188.1,78.92 188.29,78.92 188.62,79.25 188.62,81.63 188.93,81.94 191.12,81.94 192.01,82.83 192.01,83.1 v2(192.45,83.54)
PEX_CLKREQ#_Q: length 18.4
  BOTTOM w0.102: R7001.2 85.6,130.06 85.8,130.27 Q7000.2 85.03,130.64 84.76,130.9 84.76,132.94 85.01,133.19 86.89,133.19 v1(87.86,134.16) 87.99,134.28 95.17,134.28 95.56,134.67 95.56,136.44 95.65,136.53 95.65,136.85 U7000.BB20
PEX_PLLVDD_1: length 0.6
  BOTTOM w0.35: U7000.AW26 98.89,141.51 v6(98.89,141.5)
  vias: v1(99.09,139.18)
PEX_RST#: length 55.6
  TOP w0.102: v6(91.49,124.73) 91.97,124.25 93.93,124.25 95.77,122.41 v1(95.77,121.26) 95.76,121.25 R7000.1 95.76,118.84 96.32,118.28 D7001.3 95.05,117.57 93.93,116.46 93.93,114.13 94.74,113.33 95.82,113.33 96.16,113.67 96.16,113.99 96.7,114.52 98.4,114.52 98.99,115.11 98.99,116.18 99.59,116.78 99.59,117.24 100,117.64 Q7403.1 101.04,117.64 101.8,116.88 101.8,116.4 v2(101.4,115.99) 104.54,115.99 v2(105.11,116.55)
  IN1 w0.102: v6(93.9,136.67) 93.9,134.84 91.11,132.05 91.11,125.11 v6(91.49,124.73)
  BOTTOM w0.102: v2(105.11,116.55) 106.28,116.55 106.6,116.23 106.6,115.62 108.13,114.1 108.13,113.38 107.29,112.54 107.29,110.45 106.92,110.08 Q7404.1 ; v6(93.9,136.67) 93.5,137.07 U7000.BE20
PEX_TERMP: length 4.4
  BOTTOM w0.102: U7000.BJ38 88.95,151.5 87.85,152.6 v1(87.48,152.6) 87,153.08 R7009.1
PEX_TSTCLK_OUT: length 6.2
  BOTTOM w0.102: v1(85.57,152.34) 86.49,152.34 R7006.1 87.05,151.78 88.32,151.78 88.95,151.14 90.55,151.14 90.91,151.5 U7000.BH38
PEX_TSTCLK_OUT#: length 5.8
  BOTTOM w0.102: R7006.2 87.76,151.43 v1(88.19,151) 88.27,150.92 90.7,150.92 90.91,151.12 91.52,151.12 U7000.BG38
PH1_A:
  vias: v2(46.41,168.67) v2(46.41,168.04)
PH2_A:
  vias: v2(33.83,169.05) v2(34.47,169.05)
PH2_B:
  vias: v2(21.77,165.88) v2(22.4,165.88)
PH_C: length 19.8
  TOP w0.254: v3(85.98,167.99) 85.9,167.99 85.4,167.48 T8053.1
  IN4 w0.762: v3(70.16,166.08) 70.59,166.08 71.09,165.58 71.09,165.15 72.32,163.92 80.06,163.92 84.13,167.99 v3(85.98,167.99)
  vias: v1(68.43,167.28)
PLT_RST#_R: length 4.3
  TOP w0.114: R5309.1 250.32,94.5 v1(250.32,93.72) 250.24,93.64 248.93,93.64 v2(248.59,93.31)
  BOTTOM w0.114: v2(248.59,93.31) 248.5,93.21 CON5300.52
PLTRST#: length 213
  TOP w0.114: v2(117,44.08) 116.72,44.36 U3001.22 ; v2(148.64,42.08) 148.36,41.8 148.36,34.97 R3137.2 148.97,34.82 149.89,33.9 149.89,32.35 148.82,31.28 148.82,28.3 149.96,27.16 152.89,27.16 153.23,26.83 154.44,26.83 154.78,27.16 156.17,27.16 157.18,28.16 158.55,28.16 v2(159.08,28.69) ; 178.77,22.32 178.39,21.95 U2401.1 ; 178.77,22.32 178.77,25.65 178.73,25.68 v2(178.73,25.79) 178.73,26.19 178.89,26.36 179.68,26.36 179.8,26.23 179.8,24.15 180.22,23.73 U6200.16 ; 178.77,22.32 178.49,22.6 U2401.2 ; v2(49.63,41.35) 49.33,41.05 49.33,37.62 47.36,35.65 47.36,34.96 v1(43.23,30.83) 44.42,29.64 44.42,28.73 43.94,28.24 R5123.1 ; v2(189.28,50.97) 189.23,50.92 188.7,50.92 R2457.2
  IN1 w0.076: v2(49.63,41.35) 49.98,41 61.46,41 62.04,41.58 89.46,41.58 91.12,43.24 103.64,43.24 104.87,44.48 113.78,44.48 114.86,43.4 116.32,43.4 v2(117,44.08) ; v2(159.08,28.69) 159.73,28.05 176.47,28.05 v2(178.73,25.79) 182.46,29.52 182.46,31.45 182.74,31.73 182.74,32.86 183.1,33.23 183.32,33.23 186.99,36.9 186.99,41.75 187.68,42.44 187.68,44.43 188.01,44.76 188.01,49.7 v2(189.28,50.97)
  IN2 w0.114: v2(117,44.08) 117.65,43.43 130.33,43.43 133.26,40.49 135.02,40.49 135.84,39.67 147.37,39.67 148.64,40.94 v2(148.64,42.08)
PLTRST#_BUF: length 357.9
  TOP w0.114: v2(250.8,94.66) 250.8,95.41 250.51,95.7 R5309.2 ; v2(174.08,31.06) 175.55,31.06 177.32,29.28 177.32,24.89 175.68,23.25 U2401.4 ; v2(243.26,87.54) 241.77,87.54 240.32,86.09 236.85,86.09 236.62,86.32 R3308.2 ; R7002.1 98.25,111.78 97.69,111.22 v2(97.33,111.22)
  IN1 w0.076: v2(97.33,111.22) 97.14,111.03 97.14,102.19 107.35,91.98 107.35,85.36 108.93,83.78 112.14,83.78 113.22,82.7 117.11,82.7 117.99,81.82 120.91,81.82 123.87,84.78 138.41,84.78 139.27,85.64 142.19,85.64 143.76,87.22 148.01,87.22 148.87,86.35 151.28,86.35 152.21,85.43 154.52,85.43 155.95,83.99 159.03,83.99 160.76,85.72 160.76,88.02 161.77,89.03 172.28,89.03 173.71,87.6 173.71,84.6 173.97,84.35 175.83,82.48 176.49,82.48 177.51,83.5 178.29,83.5 178.89,82.9 180.47,82.9 181,83.44 v2(181,83.99) ; v2(231.46,54.85) 234.48,54.85 239.9,60.27 240.11,60.27 242.01,62.17 242.01,63.64 245.4,67.04 245.4,70.21 242.97,72.64 242.97,87.26 v2(243.26,87.54)
  IN2 w0.114: v2(250.8,94.66) 250.2,94.06 250.2,93.53 248.46,91.79 245.52,91.79 244.5,90.77 243.56,90.77 242.8,90.01 242.8,88 v2(243.26,87.54) ; v2(231.46,54.85) 231.46,54.57 229.85,52.96 229.5,52.96 229,52.46 226.48,52.46 219.68,45.66 219.68,39.45 218.73,38.51 218.73,38.14 218.3,37.71 218.3,37 217.48,36.17 214.98,36.17 211.67,32.87 210.59,32.87 209.11,31.39 209.02,31.39 v2(208.71,31.08)
  IN3 w0.114: v2(207.57,86.2) 207.57,84.55 204.9,81.88 192.2,81.88 189.53,84.56 181.57,84.56 v2(181,83.99)
  IN4 w0.076: v2(208.71,31.08) 207.39,32.4 207.39,33.18 206.27,34.31 200.36,34.31 200,33.95 196.38,33.95 194.08,31.64 191.07,31.64 190.49,31.06 v2(174.08,31.06) ; v2(243.26,87.54) 239.82,87.54 237.39,85.11 229.7,85.11 227.85,86.95 227.85,87.86 226.72,88.99 225.57,88.99 223.02,91.55 219.98,91.55 219.73,91.31 219.27,91.31 216.27,88.31 211.86,88.31 209.75,86.2 v2(207.57,86.2)
  BOTTOM w0.114: v1(207.11,85.52) 207.11,85.74 v2(207.57,86.2) ; R1150.2 230.1,46.07 229.07,47.09 229.07,47.9 230.05,48.88 230.05,50.41 229.82,50.64 228.65,50.64 228.07,51.22 228.07,53.31 228.69,53.93 230.54,53.93 v2(231.46,54.85)
PLTRST_CPU#: length 285.4
  TOP w0.102: v2(8.1,84.95) 10.03,83.02 10.97,83.02 12.17,84.22 12.17,84.8 12.45,85.08 12.45,86.2 v2(11.53,87.11) ; v2(6.07,123.44) 6.07,123.72 6.35,123.99 v1(7.13,123.99) 7.29,123.99 v2(8.15,124.86)
  IN1 w0.102: v6(20.44,149.21) 21.26,148.39 21.26,142.89 21.01,142.64 20.19,142.64 19.84,142.28 19.84,138.18 18.72,137.06 18.72,134.2 11.79,127.27 10.57,127.27 v2(8.15,124.86) ; v2(171.39,71.9) 170.87,71.38 170.87,71.19 170.38,70.71 169.86,70.71 168.59,69.44 157.48,69.44 156.76,68.72 153.1,68.72 151.82,67.44 148.96,67.44 146.45,64.93 144.09,64.93 143.41,64.25 142.78,64.25 142.54,64.49 141.18,64.49 140.97,64.28 139.93,64.28 139.42,64.78 138.44,64.78 136.14,67.08 130.37,67.08 124.14,60.85 121.79,60.85 121.4,60.46 111.31,60.46 111.06,60.72 108.95,60.72 107.41,59.17 107.41,59.06 106.6,58.26 98.67,58.26 98.24,57.83 55.55,57.83 48.04,65.33 34.49,65.33 33.46,66.36 33.46,67.44 28.31,72.59 28.31,74.12 26.7,75.73 26.7,78.44 20.04,85.1 18.82,85.1 17.63,86.29 15.71,86.29 14.89,87.11 v2(11.53,87.11)
  IN2 w0.102: v2(8.1,84.95) 7.55,84.95 7.09,85.41 7.09,88.37 6.91,88.55 6.91,104.92 7.46,105.47 7.46,117.82 5.64,119.63 5.64,123 v2(6.07,123.44)
  BOTTOM w0.089: U2000.AK2 173.93,62.39 174.18,62.64 174.18,62.9 174.13,62.95 174.13,63.83 173.31,64.64
  BOTTOM w0.102: v6(20.44,149.21) 20.51,149.14 22.05,149.14 22.16,149.25 22.5,149.25 22.89,149.64 U0300.BP35 ; R4418.2 6.45,121.1 6.45,123.06 v2(6.07,123.44) ; v2(171.39,71.9) 170.94,71.45 170.94,69 171.01,68.93 171.01,67.57 R2474.1
  BOTTOM w0.114: R2474.1 171.04,66.76 171.04,65.91 171.46,65.49 171.86,65.49 172.02,65.32 172.8,65.32 172.95,65.17 172.95,65 173.31,64.64
PM_CLKRUN#: length 139.1
  TOP w0.102: v2(178.52,51.99) 178.96,51.55 180.55,51.55 180.96,51.15 183,51.15 183.69,51.84 183.69,53 184.14,53.44 186.31,53.44 186.36,53.49 186.78,53.49 187.09,53.18 187.53,53.18 187.67,53.04 187.67,52.74 R2251.2 188.25,52.99 190.36,52.99 v1(190.5,52.86) 190.18,52.54 v2(189.89,52.54) ; v2(179.35,25.79) 179.57,25.57 U6200.15 ; v2(120.17,33.75) 121,32.91 122.51,32.91 123.92,31.5 U3001.93
  IN1 w0.102: v2(189.89,52.54) 190.32,52.11 190.32,50.79 188.27,48.73 188.27,44.71 187.89,44.34 187.89,42.31 187.21,41.63 187.21,36.81 183.41,33.01 183.19,33.01 182.96,32.77 182.96,32.22 183.49,31.68 183.49,29.93 v2(179.35,25.79)
  IN2 w0.102: v2(112.24,33.34) 112.24,32.05 114.24,30.05 122.34,30.05 122.81,30.52 132.68,30.52 133.26,29.95 146.04,29.95 146.4,30.3 160.75,30.3 161.94,29.11 163.89,29.11 166.01,26.99 169.21,26.99 169.65,26.55 178.59,26.55 v2(179.35,25.79)
  IN4 w0.102: v2(120.17,33.75) 119.29,32.87 112.72,32.87 v2(112.24,33.34)
  BOTTOM w0.089: v2(178.52,51.99) 178.79,52.26 U2000.AW22
PM_DOWN: length 259.9
  TOP w0.102: v2(172.54,64.06) 172.54,64.22 172.83,64.51 v1(173.1,64.51)
  IN1 w0.102: v2(172.54,64.06) 171.54,64.06 170.62,64.98 169,64.98 168.43,64.4 159.09,64.4 158.17,63.49 155.91,63.49 155.17,62.75 154.17,62.75 150.71,59.3 146.4,59.3 145.8,58.69 144.43,58.69 142.04,56.3 142.04,55.04 141.68,54.68 124.24,54.68 123.76,54.19 115.98,54.19 115.47,53.69 106.71,53.69 106.05,53.02 102.64,53.02 100.36,50.75 66.07,50.75 64.72,49.4 61.89,49.4 61.25,50.04 60.53,50.76 50.09,50.76 v2(49.68,50.35)
  IN2 w0.102: v6(19.23,151.27) 19.23,145.69 18.43,144.9 18.43,143.74 18.77,143.4 18.77,137.59 18.3,137.12 18.3,132.92 15.77,130.39 15.77,125.11 20.14,120.75 20.14,95.57 29.46,86.25 29.46,74.9 28.65,74.09 28.65,72.09 32.61,68.13 32.61,65.85 35.8,62.66 35.8,61.52 36.03,61.28 36.16,61.28 36.16,61.28 36.67,61.28 37.08,60.87 37.08,57.08 40.43,53.74 47.59,53.74 48.71,52.63 48.71,51.33 v2(49.68,50.35)
  BOTTOM w0.089: v2(172.54,64.06) 172.94,64.06 173.48,63.53 173.48,62.59 U2000.AH2
  BOTTOM w0.102: v6(19.23,151.27) 18.49,152.01 18.46,152.01 18.19,152.29 18.19,152.51 17.9,152.8 16.97,152.8 16.84,152.93 R0731.1
