# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 44.37,137.18 44.37,132.27 44.19,132.16 44.1,131.97 44.09,131.95 44.05,131.9 44.02,131.9 43.72,131.7 43.83,131.35 43.87,131.27 43.83,131.19 43.77,131.14 43.73,131.07 43.72,131.06 43.68,131.02 43.65,131.03 43.36,130.99 43.2,130.74 43.2,130.72 43.14,130.67 43.05,130.65 42.98,130.72 42.94,130.81 42.89,130.88 42.86,130.95 42.99,131.27 42.86,131.6 42.89,131.67 42.95,131.76 42.99,131.86 43.02,131.92 43.09,131.94 43.18,131.95 43.25,131.99 43.27,131.99 43.29,131.99 43.53,132.24 43.6,132.24 43.8,132.34 43.9,132.52 43.89,132.77 43.72,132.95 43.72,132.99 43.73,133.03 43.73,137.2 43.82,137.28 44.27,137.28
GND on BOTTOM (solid shape): outline of 143 points within 75.18,78.35 96.51,80.79
GND on BOTTOM (solid shape): 63.07,151.03 63.07,151.02 63.18,150.77 63.42,150.66 63.44,150.66 63.5,150.6 63.5,150.32 63.23,150.32 63.1,150.19 61.92,150.19 61.85,150.22 61.82,150.29 61.58,150.58 61.24,150.43 61.16,150.37 61.07,150.41 60.75,150.53 60.52,150.26 60.47,150.22 60.42,150.26 60.41,150.32 60.39,150.37 60.38,150.41 60.53,150.62 60.5,150.84 60.49,150.87 60.51,150.91 60.52,150.91 60.64,151.08 60.64,151.28 60.67,151.38 60.77,151.4 61.01,151.41 61.18,151.57 61.35,151.57 61.39,151.53 61.76,151.4 61.99,151.71 61.99,151.82 61.98,151.9 61.95,151.98 61.95,152.03 61.99,152.06 62.04,152.06
GND on BOTTOM (solid shape): 20.52,140.63 20.61,140.36 20.87,140.24 20.93,140.24 21,140.17 21.18,140.17 21.19,140.13 21.29,139.96 21.49,139.89 21.59,139.89 21.72,139.93 21.83,140.01 21.91,140.06 22.24,139.89 22.56,140.06 22.64,140.01 22.72,139.94 22.82,139.9 22.86,139.85 22.86,139.85 22.89,139.65 23.03,139.5 23.08,139.41 23.03,139.32 22.89,139.18 22.86,138.98 22.86,138.97 22.82,138.92 22.72,138.88 22.64,138.81 22.56,138.77 22.48,138.81 22.36,138.9 22.21,138.93 22.19,138.93 21.98,139.13 20.67,139.13 20.58,139.18 20.57,139.27 20.53,139.62 20.22,139.77 20.14,139.79 20.11,139.87 19.96,140.02 19.96,140.67 20.03,140.74 20.41,140.74
GND on BOTTOM (solid shape): 60.26,137.45 60.34,137.42 60.39,137.38 60.44,137.35 60.5,137.33 60.56,137.32 60.6,137.3 60.61,137.27 60.67,137.1 60.8,136.99 60.88,136.97 60.96,136.98 61.3,136.64 61.28,136.6 61.27,136.56 61.38,136.24 61.72,136.23 61.76,136.25 62.06,135.95 62.89,135.95 63.1,135.73 63.1,135.55 61.96,135.55 61.87,135.65 61.87,135.67 61.77,135.93 61.49,136 61.4,135.96 61.32,135.89 61.16,135.89 61.08,135.96 60.98,136 60.95,136.02 60.94,136.06 60.91,136.26 60.76,136.41 60.76,136.47 60.57,136.66 60.52,136.66 60.37,136.78 60.17,136.78 60.09,136.74 60.02,136.67 59.94,136.63 59.86,136.67 59.78,136.75 59.68,136.79 59.65,136.81 59.64,136.84 59.65,136.88 59.64,136.93 59.68,136.98 59.7,136.98 59.86,137.09 59.92,137.27 59.93,137.3 59.97,137.32 60.09,137.35 60.19,137.42
GND on BOTTOM (solid shape): outline of 161 points within 29.39,78.42 58.47,87.47
GND on BOTTOM (solid shape): 23.21,149.5 23.29,149.46 23.37,149.39 23.47,149.35 23.5,149.33 23.51,149.29 23.54,149.1 23.68,148.95 23.73,148.86 23.68,148.77 23.54,148.62 23.51,148.43 23.5,148.39 23.47,148.37 23.23,148.07 23.47,147.78 23.5,147.76 23.51,147.72 23.54,147.52 23.68,147.37 23.73,147.28 23.68,147.2 23.51,146.88 23.71,146.57 23.71,146.43 23.29,146.43 23.22,146.45 23.19,146.52 23.12,146.69 22.97,146.79 22.97,146.99 23.19,147.34 22.86,147.59 22.84,147.59 22.57,147.86 22.5,147.86 22.5,147.92 22.51,147.93 22.49,148.25 22.2,148.38 22.07,148.51 22.07,148.91 22.23,149.07 22.57,149.07 22.85,149.34 22.87,149.34 23.02,149.37 23.13,149.46
GND on BOTTOM (solid shape): 130.66,81.14 130.66,79.84 131.04,79.46 132.63,79.46 132.77,79.6 132.77,80.66 133.02,80.91 136.07,80.91 136.45,80.53 136.45,79.2 136.41,79.19 136.3,79.14 136.21,79.06 136.13,79.02 136.06,79.06 135.52,79.19 135.18,78.74 135.21,78.52 135.34,78.34 135.37,78.26 135.18,77.82 135.37,77.37 135.34,77.3 135.33,76.57 136.06,76.58 136.13,76.61 136.21,76.58 136.54,76.42 136.89,76.53 136.93,76.56 138.04,76.56 138.64,77.16 139.96,77.16 140.16,76.96 140.16,76.24 140.05,76.14 138.27,76.14 137.79,75.66 137.05,75.66 137.05,75.66 137,75.66 136.79,75.45 136.79,73.25 136.87,73.18 137.41,73.18 137.41,73.18 137.47,73.18 137.6,73.31 137.6,74.35 137.49,74.47 137.49,74.79 137.55,74.85 137.88,74.85 137.96,74.78 137.96,74.4 137.85,74.29 137.85,73.49 138.17,73.18 138.52,73.18 138.69,73.01 138.69,72.78 138.65,72.75 138.15,72.75 137.9,72.5 132.66,72.5 132.65,72.5 129.96,72.5 127.11,75.34 127.11,76.74 125.87,77.98 125.87,79.27 126.11,79.51 126.43,79.51 126.87,79.95 126.87,80.94 127.17,81.23 130.57,81.23
GND on BOTTOM (solid shape): 121.7,125.16 121.7,124.96 121.59,124.55 121.93,124.32 121.97,124.31 121.98,124.28 121.99,124.22 122.01,124.16 122.03,124.13 121.84,123.94 121.81,123.94 121.42,123.5 121.98,123.31 122.02,123.32 122.05,123.3 122.12,123.24 122.2,123.2 122.23,123.19 122.23,123.01 122.2,123 122.04,122.88 121.98,122.68 121.99,122.66 121.71,122.38 121.71,122.07 121.58,121.93 121.55,121.94 121.46,121.94 121.37,121.91 121.34,121.9 121.27,121.97 121.27,122.15 120.94,122.49 121,122.8 120.76,123.01 120.72,123.02 120.72,123.18 120.76,123.19 121.02,123.5 120.76,123.81 120.72,123.82 120.72,123.98 120.76,123.99 121.02,124.3 120.76,124.61 120.72,124.62 120.72,124.78 120.76,124.79 120.95,124.9 121.02,125.11 121.02,125.13 121.08,125.19 121.11,125.19 121.25,125.2 121.38,125.27 121.59,125.27
GND on BOTTOM (solid shape): 57.26,148.66 57.33,148.61 57.47,148.47 57.67,148.43 57.69,148.43 57.74,148.39 57.74,148.38 58.02,148.16 58.32,148.35 58.33,148.37 58.38,148.4 58.4,148.4 58.47,148.4 58.53,148.4 58.62,148.38 58.66,148.3 58.72,148.12 58.88,148.01 58.9,148 58.94,147.95 58.93,147.93 59.01,147.68 59.24,147.56 59.26,147.55 59.31,147.51 59.31,147.49 59.38,147.32 59.53,147.22 59.55,147.22 59.59,147.17 59.59,147.07 59.55,147.03 59.53,147.02 59.44,146.98 59.37,146.91 59.29,146.87 59.21,146.91 59.05,147.02 58.86,147.02 58.83,147.01 58.54,147.3 58.54,147.31 58.37,147.54 58.09,147.58 58.02,147.58 57.97,147.63 57.66,147.85 57.33,147.66 57.26,147.61 57.17,147.64 57.13,147.68 57.07,147.8 57.11,147.92 57.15,147.97 57.15,147.98 57.16,147.99 57.22,148.17 57.14,148.33 57.07,148.47 57.14,148.61 57.18,148.64
GND on BOTTOM (solid shape): outline of 225 points within 73.71,66.31 97.47,67.99
GND on BOTTOM (solid shape): outline of 246 points within 31.7,64.98 58.73,69.44
GND on BOTTOM (solid shape): 259.84,65.81 260.01,65.7 260.2,65.67 261.6,65.67 261.68,65.67 261.76,65.69 262.42,64.9 263.43,65.11 263.54,65.22 263.62,65.34 265.51,65.34 265.51,65.34 265.98,65.34 266.07,65.28 266.06,65.17 265.94,64.51 266.5,64.14 268.5,64.14 269.06,64.51 268.94,65.17 268.93,65.28 269.02,65.34 269.39,65.34 269.39,52.46 269.02,52.46 268.93,52.52 269.06,53.29 268.5,53.66 266.5,53.66 265.94,53.29 266.07,52.52 265.98,52.46 263.62,52.46 263.09,52.9 262.4,52.89 262.04,52.66 261.8,52.3 261.78,52.23 261.76,52.16 261.71,52.12 261.65,52.13 261.6,52.13 260.2,52.13 259.67,51.6 260.2,51.07 261.6,51.07 261.63,51.07 261.71,51.04 261.74,50.97 261.74,46.91 261.71,46.83 261.62,46.81 261.49,46.82 261.36,46.81 261.27,46.83 261.24,46.91 261.24,50.49 259.74,50.49 259.52,50.71 259.52,51.42 259.46,51.48 259.46,64.82 259.84,65.2
GND on BOTTOM (solid shape): outline of 87 points within 122.11,145.36 128.13,146.65
GND on BOTTOM (solid shape): outline of 111 points within 20.11,136.41 24.76,140.06
GND on BOTTOM (solid shape): outline of 463 points within 90.34,126.42 100.5,132.25
GND on BOTTOM (solid shape): outline of 515 points within 95.29,135.57 99.09,141.23
GND on BOTTOM (solid shape): outline of 220 points within 20.14,140.78 26.34,147.33
GND on BOTTOM (solid shape): outline of 207 points within 58.05,143.72 63.5,150.12
GND on BOTTOM (solid shape): outline of 170 points within 120.03,135.45 129.31,139.41
GND on BOTTOM (solid shape): outline of 691 points within 120.31,125.65 129.51,131.72
GND on BOTTOM (solid shape): outline of 962 points within 90.86,137.9 96.89,151.11
GND on BOTTOM (solid shape): outline of 913 points within 36.5,124.24 43.87,133.75
GND on BOTTOM (solid shape): outline of 1331 points within 101.81,121.82 107.69,130.74
GND on BOTTOM (solid shape): outline of 1063 points within 55.88,124.77 63.42,134.51
GND on BOTTOM (solid shape): outline of 1941 points within 43.29,120.99 55.62,133.72
GND on BOTTOM (solid shape): outline of 3414 points within 17.32,122.49 37.26,135.03
GND on BOTTOM (solid shape): outline of 9174 points within 0.51,0.51 271.99,186.39
GND on BOTTOM (solid shape): outline of 8139 points within 150.44,41.54 180.14,69.64
GND on GND1 (solid shape): outline of 4221 points within 0.51,0.51 271.99,186.19
GND on IN1 (solid shape): 237.69,28.99 239.34,28.99 239.67,28.66 239.67,28.3 239.35,27.97 235.5,27.97 234.71,27.18 233.47,27.18 233.15,27.5 233.15,28.32 233.36,28.53 234.77,28.53 235.55,29.31 237.37,29.31
GND on IN1 (solid shape): 229.81,30.51 230.35,30.51 230.36,30.52 230.61,30.52 230.7,30.43 230.7,30.07 231.8,28.97 231.87,28.97 232.07,28.77 232.07,28.04 232.02,27.99 230.56,27.99 230.47,28.08 230.47,28.29 228.83,29.93 228.34,29.93 228.28,29.99 228.28,30.14 228.28,30.14 228.28,31.01 229.31,31.01
GND on IN1 (solid shape): 227.86,12.71 227.86,12.13 229.69,10.29 229.69,10.22 228.77,10.22 228.66,10.11 213.3,10.11 212.95,10.25 212.81,10.6 212.81,17.3 212.79,17.56 212.72,17.81 222.75,17.81
GND on IN1 (solid shape): 230.8,33.06 231.3,33.06 231.48,32.88 231.48,31.82 231.36,31.7 231.1,31.7 230.67,31.27 230.38,31.27 230.15,31.5 230.15,31.98 230.15,31.99 230.17,32.11 230.15,32.22 230.15,32.23 230.15,32.67 230.15,32.67 230.17,32.79 230.15,32.91 230.15,32.92 230.15,33.26 230.19,33.3 230.56,33.3
GND on IN1 (solid shape): 77.17,150.09 77.17,149.72 79.55,147.33 79.55,130.14 79.23,129.82 79.23,127.01 78.47,126.25 78.47,120.76 78.84,120.39 78.96,120.39 78.97,120.38 79.17,120.33 79.37,120.39 80.19,120.39 80.43,120.15 80.43,119.49 80.21,119.27 77.67,119.27 73.91,123.03 73.91,147.36 71.4,149.88 71.4,151.91 71.83,152.34 74.91,152.34
GND on IN1 (solid shape): 232.63,39.17 232.63,38.76 232.58,38.71 232.58,38.63 232.56,38.59 232.53,38.58 232.16,38.19 232.53,37.81 232.56,37.8 232.58,37.76 232.58,37.54 233.04,37.08 233.04,36.94 233.08,36.94 233.39,36.62 233.39,30.25 233.14,30.14 233.03,29.89 233.03,29.84 232.64,29.84 232.13,30.34 232.13,33.44 232.12,33.46 232.12,33.6 231.65,34.07 230.15,34.07 229.98,34.24 229.98,38.06 229.79,38.25 229.79,39.97 229.9,40.08 231.72,40.08
GND on IN1 (solid shape): outline of 328 points within 259.21,38.69 261.74,51.32
GND on IN1 (solid shape): outline of 365 points within 236.35,23.62 252.7,34.99
GND on IN1 (solid shape): outline of 1153 points within 257.73,51.99 270.14,89.53
GND on IN1 (solid shape): outline of 2383 points within 20.31,0.51 271.99,40.96
GND on IN1 (solid shape): outline of 4454 points within 0.51,43.71 270.14,186.19
GND on GND2 (solid shape): outline of 4233 points within 0.51,0.51 271.99,186.19
GND on IN2 (solid shape): 259.73,65.71 259.8,65.74 259.87,65.71 260.09,65.58 260.34,65.53 261.27,65.53 261.26,65.64 261.6,65.64 261.65,65.64 261.71,65.65 261.75,65.64 261.77,65.61 261.8,65.51 261.84,65.42 262.71,64.84 263.62,65.34 265.61,65.34 265.98,65.34 266.07,65.28 265.94,64.51 266.5,64.14 268.5,64.14 269.06,64.51 268.93,65.28 269.02,65.34 269.39,65.34 269.39,52.46 269.02,52.46 268.93,52.52 269.06,53.29 268.5,53.66 266.5,53.66 265.94,53.29 266.07,52.52 265.98,52.46 263.62,52.46 262.6,52.95 261.77,52.19 261.75,52.16 261.71,52.15 261.65,52.16 261.6,52.16 260.2,52.16 259.64,51.6 260.2,51.04 261.6,51.04 261.63,51.04 261.71,51.01 261.74,50.94 261.74,46.94 261.71,46.86 261.62,46.84 261.49,46.85 261.36,46.83 261.27,46.85 261.24,46.93 261.24,49.68 260.63,50.28 260.1,50.28 259.08,51.31 259.08,64.43 259.46,64.81 259.46,65.44
GND on IN2 (solid shape): outline of 1247 points within 233.55,100.87 255.91,119.9
GND on IN2 (solid shape): outline of 1834 points within 20.31,0.51 271.99,41.62
GND on IN2 (solid shape): outline of 3854 points within 0.51,43.27 270.14,186.19
GND on IN3 (solid shape): outline of 93 points within 258.9,46.83 269.39,65.74
GND on IN3 (solid shape): outline of 690 points within 258.95,69.31 270.14,89.53
GND on IN3 (solid shape): outline of 2595 points within 20.31,0.51 271.99,41.37
GND on IN3 (solid shape): outline of 3099 points within 0.51,43.58 270.14,186.19
GND on IN3 (solid shape): outline of 19529 points within 56.59,39.51 212.98,185.39
GND on GND3 (solid shape): outline of 4165 points within 0.51,0.51 271.99,186.19
GND on IN4 (solid shape): 76.89,135.08 76.89,133.99 76.72,133.82 74.73,133.82 73.36,132.45 68.89,132.45 68.68,132.66 68.68,133.39 69.66,134.37 73.98,134.37 74.89,135.28 76.68,135.28
GND on IN4 (solid shape): 133.74,78.93 133.74,76.54 133.36,76.16 128.55,76.16 125.69,79.02 125.69,79.43 125.8,79.54 126.88,79.54 126.89,79.55 133.12,79.55
GND on IN4 (solid shape): 140.96,90.84 140.96,88.94 140.69,88.67 136.81,88.67 135.31,87.17 134.72,87.17 134.62,87.27 134.62,90.44 134.84,90.66 138.3,90.66 138.68,91.04 140.76,91.04
GND on IN4 (solid shape): 147.63,108.08 147.63,107.28 148.1,106.81 148.55,106.81 149.19,106.17 149.19,100.9 148.61,100.32 145.02,100.32 144.55,100.79 144.55,108.22 144.8,108.48 147.23,108.48
GND on IN4 (solid shape): 76.71,132.66 76.71,125.49 76.19,124.97 75.25,124.97 70.51,129.71 68.71,129.71 68.17,130.24 67.64,130.24 67.46,130.42 67.46,131.18 67.77,131.49 73.56,131.49 75.01,132.94 76.43,132.94
GND on IN4 (solid shape): 77.42,137.65 77.42,136.6 76.96,136.14 74.59,136.14 73.74,135.29 68.99,135.29 63.83,130.13 62.84,130.13 62.63,130.34 62.63,130.85 62.88,131.1 63.27,131.1 69,136.83 73.67,136.83 74.93,138.09 76.97,138.09
GND on IN4 (solid shape): 77.21,139.63 77.21,139.1 77.04,138.93 74.68,138.93 73.51,137.75 68.26,137.75 62.84,132.33 62.79,132.33 62.63,132.5 62.63,132.79 68.95,139.11 71.02,139.11 71.15,138.98 73.32,138.98 73.45,139.1 74.13,139.1 75.04,140.01 75.04,140.02 75.23,140.21 76.63,140.21
GND on IN4 (solid shape): 75.54,153.56 75.54,150.46 78.59,147.41 78.59,142.51 78,141.92 76.68,141.92 76.44,141.68 74.06,141.68 73.5,141.11 73.5,140.39 73.46,140.35 72.19,140.35 72.11,140.44 72.11,141.42 72.13,141.44 72.13,141.78 71.98,141.92 71.98,141.93 71.43,142.49 71.43,144.37 71.72,144.66 71.72,150.96 70.87,151.81 70.87,152.54 71.81,153.48 71.81,153.81 72.09,154.09 75.01,154.09
GND on IN4 (solid shape): 269.12,30.33 269.12,27.44 268.7,27.03 268.62,27.03 268.59,27.09 268.55,27.15 268.54,27.18 268.76,27.6 268.62,28.02 268.61,28.05 268.62,28.08 268.67,28.75 268.04,28.99 267.97,28.99 267.92,29.04 267.78,29.21 267.58,29.3 267.52,29.31 267.48,29.33 267.48,29.38 267.53,29.53 267.53,29.7 267.56,29.74 267.6,29.75 267.74,29.72 267.81,29.71 268.39,29.71 268.82,29.92 268.94,30.38 268.94,30.41 268.99,30.46
GND on IN4 (solid shape): outline of 883 points within 212.69,10.11 263.7,18
GND on IN4 (solid shape): outline of 1381 points within 257.94,98.11 270.14,129.87
GND on IN4 (solid shape): outline of 5609 points within 0.51,0.51 271.99,186.19
GND on GND4 (solid shape): outline of 3937 points within 0.51,0.51 271.99,186.19
GND_D-MIC L on TOP (solid shape): 177.52,150.58 177.58,150.67 177.7,150.65 178.25,150.33 178.88,150.37 178.97,150.36 179.02,150.29 179.03,150.23 179.06,150.16 179.06,150.06 178.94,150.06 178.94,149.21 178.39,149.21 177.52,150.08
GND_D-MIC L on TOP (solid shape): outline of 916 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on BOTTOM (solid shape): outline of 737 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on GND1 (solid shape): outline of 257 points within 162.5,144.71 187.59,152.69
GND_D-MIC L on IN1 (solid shape): outline of 497 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on GND2 (solid shape): outline of 257 points within 162.5,144.71 187.59,152.69
GND_D-MIC L on IN2 (solid shape): outline of 737 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on IN3 (solid shape): outline of 737 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on GND3 (solid shape): outline of 257 points within 162.5,144.71 187.59,152.69
GND_D-MIC L on IN4 (solid shape): outline of 737 points within 162.51,144.71 187.59,152.69
GND_D-MIC L on GND4 (solid shape): outline of 257 points within 162.5,144.71 187.59,152.69
GND_D-MIC R on TOP (solid shape): 208.19,146.98 208.19,145.92 208.02,145.75 206.96,145.75 206.86,145.85 206.86,147.4 206.91,147.46 207.72,147.46
GND_D-MIC R on TOP (solid shape): 209.94,148.97 209.94,147.34 209.73,147.13 209.1,147.13 208.63,147.6 208.63,148.98 208.77,149.12 209.79,149.12
GND_D-MIC R on TOP (solid shape): 198.63,152.69 198.33,152.48 198.12,152.19 191.11,152.19 191.11,145.21 208.63,145.21 210.18,145.22 210.19,146.77 210.19,152.19 201.08,152.19 200.87,152.48 200.57,152.69 202.29,152.69 210.2,152.69 210.55,152.55 210.69,152.2 210.69,145.2 210.55,144.85 210.2,144.71 191.1,144.71 190.75,144.85 190.61,145.2 190.61,152.2 190.75,152.55 191.1,152.69 196.95,152.69
GND_D-MIC R on BOTTOM (solid shape): outline of 800 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on GND1 (solid shape): outline of 208 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on IN1 (solid shape): outline of 723 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on GND2 (solid shape): outline of 203 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on IN2 (solid shape): outline of 801 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on IN3 (solid shape): outline of 801 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on GND3 (solid shape): outline of 203 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on IN4 (solid shape): outline of 660 points within 190.61,144.71 210.69,152.69
GND_D-MIC R on GND4 (solid shape): outline of 203 points within 190.61,144.71 210.69,152.69
GND_LED on TOP (solid shape): outline of 823 points within 162.51,155.5 207.49,163.19
GND_LED on BOTTOM (solid shape): outline of 857 points within 162.51,155.5 207.49,163.39
GND_LED on GND1 (solid shape): outline of 197 points within 162.51,155.71 207.49,163.19
GND_LED on IN1 (solid shape): outline of 774 points within 162.51,155.71 207.49,163.19
GND_LED on GND2 (solid shape): outline of 197 points within 162.51,155.71 207.49,163.19
GND_LED on IN2 (solid shape): outline of 841 points within 162.51,155.71 207.49,163.19
GND_LED on IN3 (solid shape): outline of 842 points within 162.51,155.71 207.49,163.19
GND_LED on GND3 (solid shape): outline of 197 points within 162.51,155.71 207.49,163.19
GND_LED on IN4 (solid shape): outline of 842 points within 162.51,155.71 207.49,163.19
GND_LED on GND4 (solid shape): outline of 197 points within 162.51,155.71 207.49,163.19
GND_PWR on TOP (solid shape): outline of 359 points within 173.68,169.67 188.23,176.93
GND_PWR on TOP (solid shape): outline of 1384 points within 162.51,166.21 219.99,186.19
GND_PWR on BOTTOM (solid shape): outline of 1510 points within 162.51,166.21 219.99,186.19
GND_PWR on GND1 (solid shape): outline of 276 points within 162.51,166.21 219.99,186.19
GND_PWR on IN1 (solid shape): outline of 1501 points within 162.51,166.21 219.99,186.19
GND_PWR on GND2 (solid shape): outline of 276 points within 162.51,166.21 219.99,186.19
GND_PWR on IN2 (solid shape): outline of 1464 points within 162.51,166.21 219.99,186.19
GND_PWR on IN3 (solid shape): outline of 1582 points within 162.51,166.21 219.99,186.19
GND_PWR on GND3 (solid shape): outline of 276 points within 162.51,166.21 219.99,186.19
GND_PWR on IN4 (solid shape): outline of 1580 points within 162.51,166.21 219.99,186.19
GND_PWR on GND4 (solid shape): outline of 276 points within 162.51,166.21 219.99,186.19
GND_SIGNAL on TOP (solid shape): 227,30.83 227.13,30.7 227.13,30.07 226.49,29.43 226.37,29.43 226.11,29.68 226.11,30.32 225.98,30.45 225.48,30.45 225.35,30.57 225.35,30.7 225.6,30.95 227,30.95
GND_SIGNAL on BOTTOM (solid shape): 227.13,31.34 227.13,29.81 227,29.68 225.48,29.68 225.22,29.94 225.22,31.59 225.48,31.84 226.62,31.84
GND_SIGNAL on IN3 (solid shape): outline of 976 points within 213.16,23.88 231.95,37.6
VCC0P9_CIO on BOTTOM (solid shape): 241.61,35.4 241.61,35.22 241.38,34.99 241.15,34.99 241.05,34.89 241.05,33.49 240.94,33.39 240.56,33.39 240.54,33.42 240.54,35.35 240.69,35.5 241.5,35.5
VCC0P9_DP on TOP (solid shape): 240.65,34.43 240.65,34.32 240.51,34.05 240.65,33.79 240.65,33.55 240.45,33.35 240.44,33.35 240.36,33.31 240.29,33.25 240.14,33.1 240.13,33.1 240.05,33.08 239.98,33.04 239.71,33.04 239.68,33.06 239.68,33.13 239.71,33.15 239.85,33.43 239.68,33.71 239.68,33.81 239.83,34.07 239.7,34.34 239.68,34.35 239.68,34.4 239.86,34.58 240.5,34.58
VCC0P9_DP on TOP (solid shape): 242.49,36.5 242.77,36.34 243.05,36.5 243.39,36.5 243.47,36.46 243.49,36.38 243.52,36.24 243.62,36.13 243.64,36.11 243.64,35.93 243.62,35.92 243.53,35.83 243.49,35.7 243.49,35.59 243.57,35.51 243.36,35.3 243.13,35.3 243.1,35.3 243.06,35.3 242.49,35.3 242.45,35.35 242.45,35.35 242.41,35.53 242.28,35.66 242.28,36.36 242.36,36.44 242.41,36.5
VCC0P9_DP on BOTTOM (solid shape): 243.51,36.36 243.48,36.34 243.48,35.88 243.74,35.63 243.74,35.14 243.75,35.13 243.75,34.15 243.74,34.11 243.74,34.06 243.64,33.95 243.29,33.95 243.23,34.01 243.23,35.58 243.15,35.65 243,35.65 242.97,35.68 242.27,35.68 242.23,35.68 242.12,35.7 242.01,35.68 242,35.68 241.96,35.68 241.88,35.76 241.88,36.11 242.04,36.27 242.04,36.29 242.06,36.33 242.25,36.37 242.37,36.45 242.45,36.49 242.52,36.45 243,36.43 243,36.91 242.97,36.99 243.01,37.06 243.14,37.31 243.03,37.57 242.99,37.64 243.02,37.72 243,38.18 242.54,38.17 242.39,38.17 242.39,38.51 243.51,38.51
VCC0P9_DP on IN3 (solid shape): outline of 254 points within 239.91,33.35 243.51,36.37
VCC0P9_PCIE on TOP (solid shape): 242.9,32.83 242.9,32.61 242.86,32.53 242.84,32.45 242.82,32.43 242.82,31.64 243.13,31.34 243.16,31.28 243.2,31.23 243.2,30.42 243.14,30.37 243.09,30.42 243,30.42 243,30.53 242.8,30.73 242.55,30.73 242.22,30.62 242.3,30.29 242.3,30.16 242.17,30.03 242.01,30.03 241.57,30.46 241.57,31.15 241.58,31.16 241.7,31.23 241.78,31.35 241.78,31.36 241.93,31.51 241.93,31.58 242.05,31.8 241.93,32.02 241.93,32.23 242.05,32.41 241.99,32.61 241.98,32.64 241.99,32.66 242,32.68 242,32.82 242.38,33.21 242.53,33.21
VCC0P9_PCIE on BOTTOM (solid shape): 243,33.46 243,33.32 242.7,33.02 242.7,32.66 242.7,32.66 242.7,32.19 242.58,32.19 242.58,31.69 242.56,31.69 242.56,31.63 242.54,31.6 242.54,31.12 242.7,30.95 242.86,30.95 243.02,30.8 243.02,30.54 242.94,30.46 242.72,30.46 242.64,30.39 242.58,30.39 242.58,30.3 242.51,30.23 242.51,29.77 242.44,29.57 242.5,29.36 242.51,29.35 242.51,29.31 242.63,29.19 242.63,28.87 242.59,28.82 242.35,28.82 242.27,28.91 242.19,28.91 242.15,28.96 242.15,29.48 242.14,29.5 242.14,29.92 241.96,30.1 241.96,32.88 242.58,33.51 242.96,33.51
VCC0P9_SVR on TOP (solid shape): 251.2,43.78 255.19,43.78 255.83,43.15 255.83,42.26 255.58,42 250.07,42 249.56,42.51 246.7,42.51 246.24,42.97 246.24,44.22 246.69,44.67 250.32,44.67
VCC0P9_SVR on TOP (solid shape): 243.81,35.17 243.93,35.07 244.09,35.04 244.13,35.03 244.15,35 244.23,34.85 244.4,34.79 244.5,34.79 244.64,34.93 244.81,34.93 245.04,34.67 245.14,34.46 245.35,34.36 245.37,34.36 245.69,34.04 245.75,33.89 245.75,33.6 245.7,33.42 245.75,33.24 245.75,32.9 245.72,32.83 245.72,32.75 245.67,32.7 245.59,32.68 245.52,32.64 245.47,32.56 245.44,32.49 245.44,32.47 245.42,32.45 245.33,32.45 245.25,32.43 245.03,32.43 244.91,32.56 244.91,33.86 244.65,34.11 244.65,34.41 244.47,34.64 244.2,34.55 244.16,34.52 243.98,34.52 243.94,34.56 243.72,34.65 243.52,34.52 243.33,34.52 243.29,34.56 243.07,34.65 242.87,34.52 242.74,34.52 242.41,34.85 242.39,34.9 242.35,34.94 242.32,34.98 242.32,35.1 242.35,35.14 242.39,35.17
VCC0P9_SVR on BOTTOM (solid shape): outline of 428 points within 245.03,32.26 252.6,44.53
VCC0P9_SVR on IN4 (solid shape): outline of 491 points within 244.61,31.4 251.39,44.83
VCCIO_BST on BOTTOM (solid shape): 75.41,160.27 75.41,159.94 76.3,159.05 76.3,158.61 76.53,158.37 76.87,158.37 76.99,158.25 76.99,158.04 76.96,158.02 75.56,158.02 74.56,159.01 74.56,160.27 74.62,160.32 75.35,160.32
VCCIO_BST_R on BOTTOM (solid shape): 75.58,161.96 75.58,161.27 75.45,161.15 74.47,161.15 74.32,161 74.32,160.53 74.18,160.39 73.57,160.39 73.51,160.46 73.51,161.18 73.53,161.2 73.53,161.51 73.94,161.92 74.25,161.92 74.42,162.09 75.45,162.09
VCCIO_LX on BOTTOM (solid shape): 72.87,161.11 72.87,160.37 73.02,160.21 74.12,160.21 74.28,160.05 74.28,159.64 74.27,159.64 74.27,158.97 75.51,157.74 78.18,157.74 78.2,157.72 78.2,157.54 78.16,157.5 77.49,157.5 77.45,157.46 77.45,156.77 77.42,156.74 76.3,156.74 75.92,156.36 75.92,154.36 75.81,154.25 74.53,154.25 74.43,154.35 74.43,155.01 74.3,155.14 71.88,155.14 71.81,155.22 71.81,161 72.03,161.23 72.74,161.23
VCCIO_O on BOTTOM (solid shape): 70.74,161.66 71.45,161.66 71.55,161.56 71.55,152.8 71.6,152.75 71.44,152.59 71.44,150.51 67.28,150.51 65.58,152.21 65.58,161.56 65.71,161.69 70.72,161.69
VCCIO_RC on BOTTOM (solid shape): 75.37,153.36 77.13,153.36 77.58,152.91 79.25,152.91 79.29,152.87 79.29,152.31 78.96,151.98 74.88,151.98 74.73,152.13 74.73,152.13 74.73,153.4 75.33,153.4
VIN on TOP (solid shape): 9.91,183.66 9.83,183.39 9.96,183.14 9.96,181.44 9.43,180.91 9.02,180.91 8.8,181.13 8.8,181.23 9.32,181.75 9.32,183.66
+1P2V on TOP (solid shape): 96.89,108.38 96.89,105.94 98.7,99.26 107.62,90.34 107.62,82.93 107.15,82.07 106.91,81.13 106.92,80.2 107.16,79.3 107.31,78.9 107.67,78.31 108.5,77.48 108.5,69.64 108.32,69.46 105.65,69.46 105.29,69.82 104.52,69.82 103.29,71.05 103.29,75.07 103,75.36 103,87.39 100.89,89.5 93.07,89.5 91.21,91.35 91.21,107.76 92.35,108.9 96.37,108.9
+1P2V on BOTTOM (solid shape): 97.95,106.46 97.95,106.46 99.79,100.23 107.51,92.51 107.51,83.57 106.98,82.84 106.61,82.02 106.37,81.78 106.37,79.19 106.94,78.61 107.13,78.31 107.34,78.03 107.9,77.45 108.56,77 108.56,76.99 108.76,76.8 108.76,73.98 108.76,73.97 108.76,72.66 108.51,72.4 104.32,72.4 104.06,72.66 104.06,74.94 103.81,75.2 102.03,75.2 101.02,76.21 101.02,87.67 98.56,90.13 90.74,90.13 90.32,90.54 90.32,109.23 95.17,109.23
+1P2V_CPU on TOP (solid shape): outline of 5094 points within 33.07,94.07 90.35,133.48
+1P2V_CPU on BOTTOM (solid shape): 57.98,128.25 57.98,128.24 58.01,128.17 58.06,128.11 58.06,127.91 58.01,127.85 57.97,127.76 57.96,127.75 57.81,127.75 57.75,127.7 57.74,127.69 57.64,127.63 57.56,127.53 57.54,127.5 57.33,127.5 56.85,127.98 56.71,127.98 56.63,127.99 56.53,127.97 56.41,127.9 56.34,127.79 56.34,127.78 56.29,127.73 56.13,127.73 55.63,128.24 55.63,128.52 55.7,128.59 57.63,128.59
+1P2V_CPU on BOTTOM (solid shape): 44.28,128.4 44.26,128.37 44.24,128.33 44.21,128.24 44.21,127.79 44.23,127.74 44.22,127.63 44.16,127.54 43.88,127.54 43.59,127.69 43.3,127.54 43.1,127.54 42.99,127.66 42.99,127.96 43.09,128.06 43.12,128.05 43.43,128.12 43.51,128.44 43.5,128.47 43.65,128.63 44.06,128.63
+1P2V_CPU on BOTTOM (solid shape): 37.8,129.08 37.8,128.57 37.44,128.21 37.22,128.21 37.17,128.26 37.08,128.31 36.95,128.33 36.86,128.31 36.73,128.31 36.38,127.96 36.37,127.96 36.3,127.9 36.24,127.83 36.24,127.82 36.2,127.78 35.91,127.78 35.88,127.85 35.83,127.91 35.83,128.07 35.89,128.12 35.94,128.18 35.99,128.23 35.99,128.62 36.09,128.72 36.57,128.72 36.58,128.72 36.69,128.69 36.81,128.72 36.82,128.72 37.03,128.72 37.32,129.01 37.4,129.07 37.47,129.15 37.72,129.15
+1P2V_CPU on BOTTOM (solid shape): 35.47,132.81 35.78,132.58 36.09,132.81 36.09,132.82 36.12,132.85 36.33,132.85 36.37,132.81 36.37,132.71 36.47,132.58 36.55,132.58 36.69,132.43 36.78,132.4 36.78,132.17 36.7,132.09 36.62,132.06 36.54,132.11 36.15,132.27 35.88,131.95 35.88,131.93 35.85,131.9 35.82,131.9 35.72,131.9 35.62,131.86 35.61,131.85 35.37,131.85 35.36,131.84 35.22,131.84 35.2,131.86 35.2,132.24 35.2,132.25 35.2,132.69 35.36,132.85 35.46,132.85
+1P2V_CPU on BOTTOM (solid shape): 33.65,129.63 33.68,129.5 33.77,129.4 33.81,129.32 33.77,129.24 33.68,128.85 34.06,128.71 34.15,128.7 34.2,128.62 34.2,128.34 34.09,128.24 33.1,128.24 33.03,128.31 33.03,128.46 33.09,128.54 33.1,128.64 33.1,128.66 33.13,128.71 33.15,128.71 33.34,128.95 33.22,129.24 33.18,129.32 33.22,129.4 33.31,129.5 33.34,129.63 33.35,129.67 33.64,129.67
+1P2V_CPU on BOTTOM (solid shape): 52.4,128.52 52.46,128.51 52.61,128.39 52.56,128.2 52.5,128.13 52.48,128.05 52.48,128.04 52.44,127.99 52.42,127.98 52.19,127.75 52.31,127.44 52.35,127.36 52.31,127.28 52.25,127.23 52.21,127.17 52.2,127.14 51.99,127.14 51.89,127.23 51.85,127.36 51.86,127.44 51.9,127.52 51.92,127.55 51.92,127.78 51.87,127.83 51.82,127.9 51.72,127.98 51.61,127.99 51.55,128.02 51.52,128.08 51.49,128.18 51.42,128.27 51.42,128.28 51.4,128.31 51.43,128.38 51.48,128.47 51.58,128.51 51.64,128.52 51.71,128.59 51.87,128.59 51.95,128.61 52.02,128.65 52.27,128.65
+1P2V_CPU on IN2 (solid shape): outline of 7482 points within 27.28,103.29 68.66,132.71
+1P2V_DUAL on TOP (solid shape): 39.78,109.67 39.78,108.32 40.59,107.51 42.65,107.51 42.84,107.32 42.84,105.01 42.7,104.87 36.98,104.87 36.42,105.43 36.42,109.9 36.91,110.38 39.07,110.38
+1P2V_DUAL on BOTTOM (solid shape): outline of 407 points within 52.91,48.2 108.85,71.89
+1P2V_DUAL on BOTTOM (solid shape): outline of 978 points within 37.77,76.56 89.71,109.31
+1P2V_DUAL on IN1 (solid shape): outline of 959 points within 58.6,62.74 103.4,69.04
+1P2V_DUAL on IN2 (solid shape): outline of 12520 points within 34.77,52.29 92.53,108.02
+1P2V_DUAL on IN3 (solid shape): outline of 12844 points within 34.77,52.6 93.74,107.89
+1P2V_DUAL on IN4 (solid shape): outline of 1667 points within 67.99,52.57 101.91,66.06
+1P05V_GPU on TOP (solid shape): 93.57,168.5 93.57,167.63 93.17,167.23 93.17,165.27 93.27,165.17 93.27,162.5 93.02,162.25 91.03,162.25 91.01,162.22 90.27,162.22 89.92,162.58 89.92,167.3 90.45,167.84 90.45,168.39 90.68,168.62 93.45,168.62
+1P05V_GPU on TOP (solid shape): outline of 195 points within 96.06,140.54 99.62,148.05
+1P05V_GPU on BOTTOM (solid shape): 94.16,165.7 94.16,165.45 93.07,164.36 93.07,162.57 92.68,162.18 90.49,162.18 89.97,162.71 89.97,165.19 90.6,165.83 94.03,165.83
+1P05V_GPU on BOTTOM (solid shape): outline of 178 points within 95.53,139.66 98.68,149.71
+1P05V_GPU on IN1 (solid shape): outline of 1620 points within 82.6,141.24 98.41,165.18
+2P5VPP on TOP (solid shape): outline of 423 points within 99.49,56.25 109.12,70.44
+2P5VPP on BOTTOM (solid shape): outline of 110 points within 97.49,63.38 102.15,69.92
+2P5VPP on IN1 (solid shape): outline of 191 points within 99.03,68.83 102.36,72.41
+A/D_DOCK_IN on TOP (solid shape): 21.45,117.38 21.45,112.35 21.99,111.81 21.99,108.15 22.4,107.73 22.4,105.76 22.86,105.3 22.86,103.88 22.56,103.58 15.94,103.58 15.67,103.85 15.67,108.17 16.18,108.68 16.82,108.68 17.2,109.06 17.2,111.22 16.82,111.6 16.82,118.11 17.32,118.62 20.21,118.62
+A/D_DOCK_IN_CON on TOP (solid shape): 23.28,101.21 23.28,99.66 14.04,90.42 11.58,90.42 11.42,90.59 11.42,92.48 11.41,92.49 11.41,94.31 11.88,94.79 11.9,94.79 13.05,95.93 13.14,96.01 13.22,96.11 13.35,96.24 13.35,98.03 14,98.68 14,99.84 14.28,100.12 14.44,100.12 14.44,100.28 15.07,100.9 15.07,102.26 15.19,102.38 22.12,102.38
+A/D_DOCK_IN_CON on BOTTOM (solid shape): 13.35,93.96 13.35,91.35 11.94,89.94 8.99,89.94 8.96,89.97 8.96,93.7 9.13,93.87 11.19,93.87 11.6,94.28 13.03,94.28
+A/D_DOCK_IN_Q on TOP (solid shape): 12.77,118.76 16.26,118.76 16.43,118.58 16.43,109.57 16.05,109.19 14.4,109.19 13.89,109.69 13.89,113.12 14.28,113.5 14.28,114.92 13.89,115.3 10.2,115.3 10.08,115.43 10.08,118.96 10.1,118.97 12.56,118.97
+A/D_DOCK_IN_Q on IN3 (solid shape): outline of 113 points within 37.28,57.33 38.76,61.77
+A/D_DOCK_IN_Q_Q on TOP (solid shape): 8.2,119.59 8.2,116.24 7.77,115.81 4.03,115.81 3.67,116.17 2.36,116.17 2.31,116.22 2.31,118.1 2.32,118.1 2.32,119.25 3.36,120.28 7.51,120.28
+AC_BAT_SYS on TOP (solid shape): 123.66,22.98 123.66,21.71 123.52,21.58 119.76,21.58 119.68,21.66 119.68,22.04 119.75,22.11 120.4,22.11 121.38,23.1 123.54,23.1
+AC_BAT_SYS on TOP (solid shape): 64.31,170.93 64.31,169.84 64.44,169.72 65.84,169.72 65.84,168.8 65.71,168.67 59.84,168.67 59.42,169.09 59.42,170.06 60.45,171.08 64.16,171.08
+AC_BAT_SYS on TOP (solid shape): 218.32,73.5 218.32,70.56 218.03,70.26 217.39,70.26 217.27,70.38 217.27,71.65 218.11,72.49 218.11,73.51 218.12,73.52 218.31,73.52
+AC_BAT_SYS on TOP (solid shape): 245.8,19.27 245.8,18.51 246.3,18 249.1,18 249.35,17.75 249.35,16.73 248.72,16.1 243.48,16.1 243.13,16.45 243.13,18.64 244.02,19.52 245.54,19.52
+AC_BAT_SYS on TOP (solid shape): 3.94,114.02 3.94,107.63 3.45,107.14 1.7,107.14 1.32,107.52 1.32,113.96 1.49,114.13 3.83,114.13
+AC_BAT_SYS on TOP (solid shape): 131.66,70.05 134.4,70.05 134.62,69.83 134.62,69.04 133.77,68.19 133.77,67.63 133.16,67.03 128.94,67.03 128.39,67.58 127.56,67.58 127.31,67.83 127.31,69.1 127.43,69.23 128.32,69.23 128.7,69.61 128.7,70.56 128.73,70.58 131.13,70.58
+AC_BAT_SYS on TOP (solid shape): 230.3,22.68 230.3,18.51 229.92,18.13 229.92,17.5 227.82,17.5 227.05,16.73 222.3,16.73 222.05,16.98 222.05,19.14 221.92,19.27 212.9,19.27 212.65,19.52 212.65,22.7 212.95,23 223.39,23 223.63,22.76 227.55,22.76 227.92,23.14 229.85,23.14
+AC_BAT_SYS on TOP (solid shape): 80.52,176.29 80.52,175.5 80.57,175.45 80.57,174.24 80.62,174.19 80.75,174.19 81.92,173.02 81.92,172.77 81.71,172.56 78.67,172.56 78.22,173 78.22,173.66 78.33,173.76 79.11,173.76 79.17,173.83 79.17,175.48 79.14,175.52 79.14,175.67 78.98,175.67 78.92,175.73 78.33,175.73 78.25,175.81 78.25,176.55 80.26,176.55
+AC_BAT_SYS on TOP (solid shape): 29.65,183.81 29.65,181.71 29.55,181.62 29.43,181.02 29.92,180.66 29.94,180.66 30.63,179.97 33.02,179.97 33.03,179.97 33.25,179.93 33.47,179.97 33.48,179.97 37.12,179.97 41.26,175.84 41.26,175.17 41.36,175.06 41.36,174.15 41.54,173.97 42.95,173.97 42.98,173.95 42.98,172.86 42.85,172.73 40.18,172.73 39.68,173.24 37.01,173.24 36.75,173.5 36.63,173.5 36.25,173.88 36.25,174.69 36.38,174.88 36.42,175.1 36.42,175.18 36.38,175.4 36.25,175.59 36.25,176.72 35.53,177.43 30.48,177.43 30.12,177.08 30.12,175.86 30.1,175.78 30.09,175.7 30.13,175.41 30.36,175.24 30.37,175.23 30.45,175.15 30.45,174.19 30.54,174.1 31.8,174.1 31.93,173.98 31.93,172.94 25.63,172.94 25.41,173.16 25.41,173.73 25.38,173.76 25.38,175.15 26.19,175.96 26.19,178.12 26.41,178.34 26.41,183.51 26.41,183.51 26.41,184.04 26.57,184.19 29.26,184.19
+AC_BAT_SYS on TOP (solid shape): outline of 442 points within 1.19,164.5 21.08,173.17
+AC_BAT_SYS on BOTTOM (solid shape): 55.13,185.32 55.13,184.18 54.88,183.92 53.99,183.92 53.86,184.05 53.86,185.32 53.99,185.45 55.01,185.45
+AC_BAT_SYS on BOTTOM (solid shape): 63.68,170.53 63.68,170.18 63.5,170 63.5,169.64 62.28,168.42 60.2,168.42 60,168.62 60,170.02 60.63,170.65 63.55,170.65
+AC_BAT_SYS on BOTTOM (solid shape): 39.91,175.53 39.9,175.52 39.9,173.34 39.8,173.24 37.01,173.24 36.5,173.75 36.5,175.61 36.68,175.79 39.65,175.79
+AC_BAT_SYS on BOTTOM (solid shape): 3.99,166.58 3.99,164.58 3.76,164.35 1.58,164.35 1.19,164.73 1.19,167.91 1.38,168.1 2.46,168.1
+AC_BAT_SYS on BOTTOM (solid shape): 128.71,29.93 128.71,22.59 127.8,21.67 120.47,21.67 120.29,21.84 120.29,22.33 121.87,23.92 121.87,26.03 122.77,26.92 122.77,30.14 124.4,31.77 126.88,31.77
+AC_BAT_SYS on BOTTOM (solid shape): 85.01,160.29 85.01,158.38 84.76,158.13 80.86,158.13 80.85,158.13 80.06,157.63 78.79,157.63 78.78,157.64 78.14,158.01 77.64,158.01 77.6,158.04 77.6,158.21 77.63,158.24 79.22,158.24 79.59,158.42 81.33,160.16 81.33,160.85 82.04,161.56 83.74,161.56
+AC_BAT_SYS on BOTTOM (solid shape): 29.25,175.5 29.24,175.42 29.24,175.38 29.24,175.12 29.19,174.53 29.69,174.23 29.77,174.23 29.77,172.94 29.64,172.81 27.48,172.81 27.36,172.94 27.36,175.48 27.61,175.73 29.01,175.73
+AC_BAT_SYS on BOTTOM (solid shape): 89.33,177 89.33,175.81 90.35,174.8 90.35,174.8 91.34,173.8 91.78,173.8 91.97,173.61 92.25,173.6 92.47,173.58 92.65,173.69 92.67,173.7 92.73,173.7 93.38,173.05 93.52,172.96 93.69,172.94 93.73,172.94 93.79,172.94 94.03,172.7 94.03,172.18 93.83,171.97 88.57,171.97 87.94,171.34 87.94,170.83 86.67,170.83 85.4,172.1 84.63,172.1 84.19,172.54 84.19,176.16 84.2,176.17 84.2,176.95 84.51,177.26 89.08,177.26
+AC_BAT_SYS on BOTTOM (solid shape): outline of 1028 points within 121.21,35.16 138.81,76.21
+AC_BAT_SYS on BOTTOM (solid shape): outline of 2406 points within 204.9,18.76 223.75,64.62
+AC_BAT_SYS on IN1 (solid shape): 127.75,21.54 116.88,21.54 116.88,23.45 127.75,23.45
+AC_BAT_SYS on IN1 (solid shape): 83.74,162.02 83.74,160.24 83.49,159.99 81.84,159.99 81.59,160.24 81.59,162.65 83.11,162.65
+AC_BAT_SYS on IN1 (solid shape): 216.84,21.21 216.84,19.08 216.32,18.56 213.18,18.56 212.76,18.98 212.76,21.74 212.99,21.97 216.08,21.97
+AC_BAT_SYS on IN1 (solid shape): 80.7,176.12 80.7,172.56 80.2,172.07 78.66,173.6 78.66,175.06 78.11,175.62 78.11,176.34 78.39,176.62 80.19,176.62
+AC_BAT_SYS on IN1 (solid shape): 3.42,168.24 3.42,166.19 5.13,164.48 5.13,163.34 4.88,163.08 2.21,163.08 1.32,163.97 1.32,168.54 1.8,169.02 2.64,169.02
+AC_BAT_SYS on IN1 (solid shape): 3.43,112.3 3.43,107.7 3.57,107.56 3.57,106.51 3.43,106.36 2.17,106.36 1.27,107.27 1.27,112.98 1.41,113.12 2.61,113.12
+AC_BAT_SYS on IN1 (solid shape): 3.25,60.81 3.94,60.12 20.2,60.12 22.23,58.09 22.23,52.17 22.22,51.95 22.23,51.73 22.23,49.42 25.27,46.38 25.27,41.9 25.95,41.23 25.95,38.89 25.62,38.56 23.41,38.56 22.87,39.09 22.87,42.17 23.28,42.57 23.74,42.57 24,42.83 24,45.85 20.96,48.89 20.96,57.56 19.68,58.85 2.4,58.85 1.3,59.96 1.3,64.96 1.65,65.32 3.25,65.32
+AC_BAT_SYS on IN1 (solid shape): 78.28,185.26 78.28,184.12 78.03,183.86 49.2,183.86 48.5,183.16 24.09,183.16 23.34,183.91 22.07,184.57 20.69,184.14 6.1,184.14 5.97,184.27 5.97,185.34 6.07,185.44 24.05,185.44 24.06,185.42 25.24,185.42 26.14,184.52 46.79,184.52 47.78,185.51 78.03,185.51
+AC_BAT_SYS on IN1 (solid shape): 42.24,28.29 42.24,26.76 41.4,25.92 32.44,25.92 32.31,26.05 32.31,27.6 38.24,27.6 38.25,27.52 38.26,27.44 38.28,27.37 38.31,27.3 38.34,27.23 38.38,27.16 38.43,27.1 38.49,27.04 38.55,26.99 38.61,26.95 38.68,26.91 38.75,26.88 38.83,26.86 38.9,26.85 38.98,26.84 39.06,26.84 39.14,26.85 39.21,26.87 39.29,26.9 39.36,26.93 39.42,26.97 39.49,27.02 39.54,27.07 39.59,27.13 39.64,27.19 39.68,27.26 39.71,27.33 39.73,27.41 39.75,27.48 39.76,27.56 39.76,27.64 39.75,27.72 39.73,27.79 39.71,27.87 39.68,27.94 39.64,28.01 39.59,28.07 39.54,28.13 39.49,28.18 39.42,28.23 39.36,28.27 39.29,28.3 39.21,28.33 39.14,28.35 39.06,28.36 38.98,28.36 38.9,28.35 38.83,28.34 38.75,28.32 38.68,28.29 38.61,28.25 38.55,28.21 38.49,28.16 38.43,28.1 38.38,28.04 38.34,27.97 38.31,27.9 38.28,27.83 38.26,27.75 38.25,27.68 38.24,27.6 32.31,27.6 32.31,28.59 32.44,28.72 36.5,28.72 37.25,29.47 41.06,29.47
+AC_BAT_SYS on GND2 (solid shape): outline of 123 points within 1.32,39.59 29.64,185.39
+AC_BAT_SYS on IN2 (solid shape): 62.92,170.8 62.92,169.35 62.67,169.1 59.18,169.1 58.98,169.3 58.98,170.58 59.01,170.58 59.4,170.96 62.75,170.96
+AC_BAT_SYS on IN2 (solid shape): 3.42,168.19 3.42,166.19 5.13,164.48 5.13,163.34 4.88,163.08 2.21,163.08 1.32,163.97 1.32,168.54 1.8,169.02 2.59,169.02
+AC_BAT_SYS on IN2 (solid shape): 3.45,114.28 3.45,107.32 3.42,107.28 3.42,106.47 3.12,106.17 2.44,106.17 1.29,107.32 1.29,114.94 1.42,115.07 2.67,115.07
+AC_BAT_SYS on IN2 (solid shape): 216.67,21.21 216.67,18.53 216.39,18.25 213.46,18.25 212.29,19.42 211.59,19.42 211.44,19.44 211.3,19.44 210.88,19.44 210.62,19.7 210.62,21.18 210.87,21.43 212.52,21.43 213.03,21.94 215.95,21.94
+AC_BAT_SYS on IN2 (solid shape): 40.89,176.73 41.02,176.73 41.58,176.17 41.58,176.04 41.17,175.63 41.17,174.82 40.87,174.51 36.88,174.51 36.74,174.65 36.74,175.72 37.15,176.13 39.76,176.13 40.41,176.78 40.84,176.78
+AC_BAT_SYS on IN2 (solid shape): 78.28,185.26 78.28,184.12 78.03,183.86 49.2,183.86 48.52,183.19 24.06,183.19 23.34,183.91 22.07,184.57 20.69,184.14 6.1,184.14 5.97,184.27 5.97,185.34 6.07,185.44 25.25,185.44 26.21,184.47 46.76,184.47 47.8,185.51 78.03,185.51
+AC_BAT_SYS on IN2 (solid shape): 3.23,62.21 3.23,60.81 3.92,60.11 5.32,60.11 20.17,60.11 20.44,59.83 20.49,59.83 22.23,58.1 22.23,52.1 22.22,51.95 22.23,51.8 22.23,49.43 25.25,46.4 25.25,38.56 23.41,38.56 22.87,39.09 22.87,42.17 23.28,42.57 23.98,42.57 23.98,45.88 20.96,48.9 20.96,52.39 20.96,52.46 20.96,54.93 20.96,55 20.96,57.57 19.67,58.86 2.4,58.86 1.3,59.96 1.3,64.96 1.65,65.32 3.23,65.32
+AC_BAT_SYS on IN2 (solid shape): 246.07,18 249.25,18 249.84,17.4 249.84,15.53 248.95,14.64 246.81,14.64 246.53,14.82 246.21,14.71 246.14,14.68 246.07,14.71 245.75,14.82 245.47,14.64 242.63,14.64 242.25,15.02 242.25,18.61 243.21,19.57 244.5,19.57
+AC_BAT_SYS on IN2 (solid shape): 42.24,28.29 42.24,26.76 41.4,25.92 32.44,25.92 32.31,26.05 32.31,27.62 38.24,27.62 38.24,27.54 38.25,27.46 38.27,27.39 38.3,27.31 38.33,27.24 38.37,27.18 38.42,27.11 38.47,27.06 38.53,27.01 38.59,26.96 38.66,26.92 38.73,26.89 38.81,26.87 38.88,26.85 38.96,26.84 39.04,26.84 39.12,26.85 39.19,26.87 39.27,26.89 39.34,26.92 39.41,26.96 39.47,27.01 39.53,27.06 39.58,27.11 39.63,27.18 39.67,27.24 39.7,27.31 39.73,27.39 39.75,27.46 39.76,27.54 39.76,27.62 39.75,27.7 39.74,27.77 39.72,27.85 39.69,27.92 39.65,27.99 39.61,28.05 39.56,28.11 39.5,28.17 39.44,28.22 39.37,28.26 39.3,28.29 39.23,28.32 39.15,28.34 39.08,28.35 39,28.36 38.92,28.35 38.84,28.34 38.77,28.32 38.7,28.29 38.63,28.26 38.56,28.22 38.5,28.17 38.44,28.11 38.39,28.05 38.35,27.99 38.31,27.92 38.28,27.85 38.26,27.77 38.25,27.7 38.24,27.62 32.31,27.62 32.31,28.59 32.36,28.64 35.18,28.64 35.26,28.72 36.5,28.72 37.25,29.47 41.06,29.47
+AC_BAT_SYS on IN3 (solid shape): 62.92,170.8 62.92,169.35 62.67,169.1 59.18,169.1 58.98,169.3 58.98,170.58 59.01,170.58 59.4,170.96 62.75,170.96
+AC_BAT_SYS on IN3 (solid shape): 3.45,114.29 3.45,107.32 3.33,107.19 1.42,107.19 1.29,107.32 1.29,114.94 1.42,115.07 2.68,115.07
+AC_BAT_SYS on IN3 (solid shape): 3.42,168.42 3.42,166.19 5.13,164.48 5.13,163.34 4.88,163.08 2.21,163.08 1.32,163.97 1.32,168.54 1.8,169.02 2.81,169.02
+AC_BAT_SYS on IN3 (solid shape): 40.31,176.32 40.31,176.24 40.87,175.68 40.87,175 40.38,174.51 36.88,174.51 36.5,174.89 36.5,175.68 37.46,176.64 39.99,176.64
+AC_BAT_SYS on IN3 (solid shape): 217.98,19.83 217.98,17.37 217.48,16.86 215.39,16.86 212.65,19.6 208.66,19.6 208.53,19.73 208.53,21.3 212.4,21.3 212.78,21.68 216.13,21.68
+AC_BAT_SYS on IN3 (solid shape): 78.28,185.26 78.28,184.12 78.03,183.86 49.2,183.86 48.57,183.23 24.02,183.23 23.34,183.91 22.07,184.57 20.69,184.14 6.1,184.14 5.97,184.27 5.97,185.34 6.07,185.44 25.4,185.44 26.31,184.52 46.86,184.52 47.85,185.51 78.03,185.51
+AC_BAT_SYS on IN3 (solid shape): 246.07,18 249.25,18 249.84,17.4 249.84,15.53 248.95,14.64 246.81,14.64 246.53,14.82 246.21,14.71 246.14,14.68 246.07,14.71 245.75,14.82 245.47,14.64 242.63,14.64 242.25,15.02 242.25,18.61 243.21,19.57 244.5,19.57
+AC_BAT_SYS on IN3 (solid shape): 3.23,60.8 3.86,60.16 4.15,60.16 4.17,60.19 20.15,60.19 22.23,58.11 22.23,52.1 22.22,51.95 22.23,51.8 22.23,49.4 24.24,47.39 24.27,47.39 25.25,46.4 25.25,41.95 25.32,41.88 25.32,38.56 23.41,38.56 22.87,39.09 22.87,42.17 23.28,42.57 23.98,42.57 23.98,45.88 23.74,46.12 23.71,46.12 20.96,48.88 20.96,52.39 20.96,52.46 20.96,54.93 20.96,55 20.96,57.59 19.63,58.92 2.34,58.92 1.3,59.96 1.3,64.96 1.65,65.32 3.23,65.32
+AC_BAT_SYS on IN3 (solid shape): 42.24,28.29 42.24,26.76 41.4,25.92 32.44,25.92 32.31,26.05 32.31,27.62 38.24,27.62 38.24,27.54 38.25,27.46 38.27,27.39 38.3,27.31 38.33,27.24 38.37,27.18 38.42,27.11 38.47,27.06 38.53,27.01 38.59,26.96 38.66,26.92 38.73,26.89 38.81,26.87 38.88,26.85 38.96,26.84 39.04,26.84 39.12,26.85 39.19,26.87 39.27,26.89 39.34,26.92 39.41,26.96 39.47,27.01 39.53,27.06 39.58,27.11 39.63,27.18 39.67,27.24 39.7,27.31 39.73,27.39 39.75,27.46 39.76,27.54 39.76,27.62 39.75,27.7 39.74,27.77 39.72,27.85 39.69,27.92 39.65,27.99 39.61,28.05 39.56,28.11 39.5,28.17 39.44,28.22 39.37,28.26 39.3,28.29 39.23,28.32 39.15,28.34 39.08,28.35 39,28.36 38.92,28.35 38.84,28.34 38.77,28.32 38.7,28.29 38.63,28.26 38.56,28.22 38.5,28.17 38.44,28.11 38.39,28.05 38.35,27.99 38.31,27.92 38.28,27.85 38.26,27.77 38.25,27.7 38.24,27.62 32.31,27.62 32.31,28.59 32.36,28.64 35.39,28.64 35.46,28.72 36.5,28.72 37.25,29.47 41.06,29.47
+AC_BAT_SYS on GND3 (solid shape): outline of 127 points within 1.32,39.59 29.64,185.39
+AC_BAT_SYS on IN4 (solid shape): 216.71,21.79 216.71,19.64 215.72,18.65 213.44,18.65 212.95,19.13 212.95,22.17 213.21,22.43 216.08,22.43
+AC_BAT_SYS on IN4 (solid shape): 3.45,114.3 3.45,107.32 3.33,107.19 1.42,107.19 1.29,107.32 1.29,114.94 1.42,115.07 2.69,115.07
+AC_BAT_SYS on IN4 (solid shape): 3.23,168.6 3.23,165.65 5.13,163.75 5.13,163.34 4.88,163.08 2.21,163.08 1.32,163.97 1.32,168.54 1.8,169.02 2.81,169.02
+AC_BAT_SYS on IN4 (solid shape): 3.28,60.9 4.01,60.16 20.17,60.16 22.23,58.1 22.23,56.22 22.23,56.22 22.23,52.17 22.22,51.95 22.23,51.73 22.23,49.39 25.25,46.38 25.25,41.85 25.95,41.15 25.95,38.89 25.62,38.56 23.41,38.56 22.87,39.09 22.87,42.17 23.28,42.57 23.57,42.57 23.98,42.98 23.98,45.85 20.96,48.87 20.96,57.58 19.65,58.89 3.77,58.89 2.36,58.9 1.3,59.96 1.3,64.96 1.65,65.32 3.28,65.32
+AC_BAT_SYS on IN4 (solid shape): 42.24,28.29 42.24,26.76 41.4,25.92 32.44,25.92 32.31,26.05 32.31,27.6 38.24,27.6 38.25,27.52 38.26,27.44 38.28,27.37 38.31,27.3 38.34,27.23 38.38,27.16 38.43,27.1 38.49,27.04 38.55,26.99 38.61,26.95 38.68,26.91 38.75,26.88 38.83,26.86 38.9,26.85 38.98,26.84 39.06,26.84 39.14,26.85 39.21,26.87 39.29,26.9 39.36,26.93 39.42,26.97 39.49,27.02 39.54,27.07 39.59,27.13 39.64,27.19 39.68,27.26 39.71,27.33 39.73,27.41 39.75,27.48 39.76,27.56 39.76,27.64 39.75,27.72 39.73,27.79 39.71,27.87 39.68,27.94 39.64,28.01 39.59,28.07 39.54,28.13 39.49,28.18 39.42,28.23 39.36,28.27 39.29,28.3 39.21,28.33 39.14,28.35 39.06,28.36 38.98,28.36 38.9,28.35 38.83,28.34 38.75,28.32 38.68,28.29 38.61,28.25 38.55,28.21 38.49,28.16 38.43,28.1 38.38,28.04 38.34,27.97 38.31,27.9 38.28,27.83 38.26,27.75 38.25,27.68 38.24,27.6 32.31,27.6 32.31,28.59 32.44,28.72 36.5,28.72 37.25,29.47 41.06,29.47
+AC_BAT_SYS on IN4 (solid shape): outline of 244 points within 5.97,175.7 89.43,185.51
+AC_BAT_SYS_FBVDDQ on TOP (solid shape): outline of 86 points within 157.98,85.31 173.28,89.12
+AC_BAT_SYS_FBVDDQ on TOP (solid shape): outline of 180 points within 128.49,70.02 142.71,78.75
+AC_BAT_SYS_FBVDDQ on BOTTOM (solid shape): 174.17,86.96 174.17,85.44 173.96,85.23 169.29,85.23 169.22,85.31 169.22,86.07 169.34,86.2 169.85,86.2 170.36,86.71 170.36,87.26 171.12,88.03 173.1,88.03
+AC_BAT_SYS_FBVDDQ on IN2 (solid shape): outline of 130 points within 144.35,87.33 158.75,92.53
+AC_BAT_SYS_FBVDDQ on IN4 (solid shape): 143.55,78.38 142.84,77.68 140.39,77.68 140.01,78.06 140.01,79.91 140.37,80.27 143.55,80.27
+AC_BAT_SYS_FBVDDQ on IN4 (solid shape): 146.82,90.54 146.82,88.63 146.22,88.03 144.57,88.03 144.42,88.18 144.42,90.18 144.94,90.69 146.67,90.69
+AC_BAT_SYS_NVVDD on TOP (solid shape): 156.9,101.06 155.75,99.92 153.75,99.92 152.22,98.38 150.55,98.38 150.06,98.86 150.06,100.96 150.55,101.44 150.55,105.04 150.67,105.17 155.5,105.17 155.67,105.34 155.67,105.92 155.88,106.14 156.9,106.14
+AC_BAT_SYS_NVVDD on TOP (solid shape): 132.81,85.77 134.69,85.77 136.83,83.63 136.83,79.27 137.97,78.13 137.97,75.11 137.93,75.02 137.84,75.01 137.41,74.84 137.45,74.38 137.48,74.31 137.45,74.24 137.15,73.95 137.06,73.92 136.99,73.97 136.41,74.24 136.02,73.74 135.99,73.67 135.92,73.64 131.54,73.64 130.93,74.25 128.68,74.25 128.52,74.41 128.52,75.94 128.54,75.98 128.58,75.99 128.74,76.02 128.88,76.09 129.16,76.09 129.46,75.99 129.77,76.09 130.05,76.09 130.35,75.99 130.66,76.09 130.94,76.09 131.24,75.99 131.55,76.09 132.45,76.09 132.48,76.12 132.6,76.12 132.6,76.24 132.67,76.31 132.67,76.34 132.7,76.37 132.7,77.01 132.84,77.14 133.42,77.14 133.69,77.42 133.69,77.53 133.7,77.54 133.78,77.83 133.69,78.11 133.69,78.42 133.78,78.71 133.69,79 133.69,80.45 133.53,80.61 133.53,80.88 132.67,81.74 131.61,81.74 131.12,81.25 126.8,81.25 126.54,81.5 125.02,81.5 124.51,80.99 124.51,79.72 119.81,79.72 119.56,79.98 119.56,80.61 119.58,80.63 119.58,81.68 119.82,81.92 120.54,81.92 121.08,82.46 121.08,85.56 121.21,85.69 121.59,85.69 121.72,85.82 132.77,85.82
+AC_BAT_SYS_NVVDD on IN4 (solid shape): 152.58,99.53 151.05,98.01 148.64,98.01 148.39,98.26 148.39,98.9 149.78,100.3 152.58,100.3
+AC_BAT_SYS_NVVDD on IN4 (solid shape): outline of 141 points within 134.29,76.54 144.2,91.36
+BAT on TOP (solid shape): 252.88,18.92 252.88,18.78 253.19,18.47 254.11,18.47 254.66,19.01 255.28,19.01 255.29,19.02 256.59,19.02 256.59,15.71 255.83,14.95 255.83,12.67 255.96,12.54 255.96,11.02 255.83,10.89 254.69,10.89 254.43,11.14 254.43,11.9 253.69,12.65 253.56,12.65 253.56,12.65 253.42,12.67 253.27,12.65 253.27,12.65 252.68,12.65 252.67,12.65 252.53,12.67 252.39,12.65 252.38,12.65 251.79,12.65 251.78,12.65 251.64,12.67 251.5,12.65 251.49,12.65 250.9,12.65 250.89,12.65 250.75,12.67 250.61,12.65 250.6,12.65 250.01,12.65 250,12.65 249.86,12.67 249.72,12.65 249.71,12.65 249.12,12.65 249.11,12.65 248.78,12.63 248.53,12.4 248.52,12.4 248.34,12.21 248.34,12.16 248.21,12.03 248.21,11.27 248.08,11.14 246.94,11.14 246.94,14.06 249.1,16.22 249.46,16.37 249.61,16.73 249.88,17.01 249.88,19.29 250.11,19.52 252.27,19.52
+BAT on IN3 (solid shape): outline of 152 points within 35.47,58.85 37.13,63.28
+BAT_CON on TOP (solid shape): 258.37,19.4 258.74,19.23 259.12,19.4 261.87,19.4 262.23,19.04 262.23,14.24 261.67,13.68 260.4,13.68 259.89,13.17 259.89,10.97 256.27,10.97 256.27,12.86 256.15,12.86 256.15,14.44 256.26,14.44 256.77,14.95 256.99,14.95 256.99,16.11 257.1,16.22 257.1,19.02 257.35,19.27 257.79,19.27 257.91,19.4
+BAT_CON on BOTTOM (solid shape): outline of 454 points within 231.55,10.9 261.54,23.64
+BAT_CON on IN2 (solid shape): outline of 352 points within 231.46,10.88 261.59,19.06
+BAT_CON on IN3 (solid shape): outline of 352 points within 231.46,10.88 261.59,19.23
+BAT_R on TOP (solid shape): 243.08,13.32 243.19,13.32 243.19,13.25 243.88,13.25 243.88,13.32 244.06,13.32 244.06,13.25 244.64,13.25 244.78,13.11 244.78,11.13 244.46,10.81 237.83,10.81 237.67,10.96 237.67,13.3 237.92,13.56 242.84,13.56
