# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TS_I2C_DATA: length 393.4
  TOP w0.102: CON4301.13 96.77,182.14 96.57,182.34 96.57,185.01 v2(96.32,185.26) ; v2(80.05,35.25) 80.05,39.16 71.21,48 v2(71.21,48.25)
  IN1 w0.102: v2(178.45,35.32) 177.92,35.86 177.17,35.86 176.99,35.68 176.99,34.36 176.72,34.09 174.97,34.09 174.73,33.84 174.44,33.84 174.07,33.47 154.61,33.47 154.27,33.81 145.01,33.81 144.46,33.27 142.27,33.27 141.27,34.27 135.57,34.27 134.2,32.91 130.78,32.91 130.35,32.48 122.83,32.48 122.61,32.71 116.18,32.71 115.67,33.22 114.02,33.22 112.55,34.69 110.17,34.69 107.33,37.53 82.07,37.53 80.05,35.51 v2(80.05,35.25)
  IN2 w0.102: v2(71.21,48.25) 70.19,49.27 52.93,49.27 47.84,54.35 40.94,54.35 38.38,56.91 38.38,60.19 37.97,60.6 37.97,60.84 37.11,61.71 37.11,63.29 35.49,64.91 34.52,64.91 33.24,66.19 33.24,68.36 29.26,72.34 29.26,73.83 30.07,74.64 30.07,86.5 20.78,95.8 20.78,121 16.38,125.4 16.38,130.14 18.91,132.67 18.91,136.87 19.38,137.34 19.38,143.65 19.1,143.93 19.1,144.42 19.54,144.85 20.28,144.85 20.9,145.47 20.9,145.84 21.19,146.13 21.19,149.46 20.95,149.7 20.29,149.7 20.07,149.92 20.07,150.36 20.98,151.28 20.98,153.04 25.44,157.5 28.5,157.5 29.69,158.69 34.09,158.69 35.51,160.12 35.51,166.78 34.53,167.76 33.55,167.76 31.9,169.4 31.9,171.54 32.84,172.48 32.84,175.91 33.12,176.19 35.21,176.19 36.52,177.5 38.92,177.5 39.88,178.47 40.17,178.47 40.66,178.96 45.38,178.96 45.38,178.96 47.51,178.96 49.21,180.65 74.06,180.65 75.43,179.28 78.22,179.28 80.47,181.52 80.47,182.68 81.98,184.2 87.31,184.2 87.65,183.86 v2(88.28,183.86)
  IN4 w0.102: v2(96.32,185.26) 96.32,183.74 95.05,182.47 92.35,182.47 91.85,181.96 88.32,181.96 88.29,181.98 88.26,181.98 87.86,182.38 87.86,182.42 87.81,182.47 87.81,183.39 v2(88.28,183.86)
  BOTTOM w0.089: U2000.AR44 176.38,41.53 175.94,41.09 175.94,40.81 175.65,40.51 175.65,39.96 176.68,38.92 177.12,38.92 177.97,38.07 178.18,38.07 178.52,37.73
  BOTTOM w0.102: R2314.2 178.35,34.11 178.05,34.41 178.05,34.91 v2(178.45,35.32) 179.25,36.12 179.25,36.47 178.66,37.06 178.66,37.6 178.52,37.73 ; v2(80.05,35.25) 80.05,34.98 v1(80.52,34.51)
UART0_DEBUG_RXD: length 44.5
  TOP w0.102: v2(193.29,28.36) 193.29,28.75 193.35,28.81 193.35,29.2 192.5,30.05 192.5,31.94 190.81,33.62 184.39,33.62 184.28,33.73 184.28,38.61 183.33,39.57 181.56,39.57 v1(181.03,40.1) 181.03,40.11 181.03,40.62 180.57,41.08 180.57,42.11 v2(180.32,42.36)
  BOTTOM w0.089: U2000.BA41 179.81,42.43 180.25,42.43 v2(180.32,42.36)
  BOTTOM w0.102: CON4402.4 204.36,26.34 200.11,22.1 194.89,22.1 193.57,23.41 193.57,27.42 193.29,27.7 v2(193.29,28.36)
UART0_DEBUG_TXD: length 45.3
  TOP w0.102: v2(192.95,28.98) 192.25,29.68 192.25,31.9 190.73,33.42 184.3,33.42 184.05,33.67 184.05,36.92 183.29,37.68 v1(183.29,38.27) 182.21,39.34 v2(180.39,39.34)
  BOTTOM w0.089: U2000.AV44 178,40.84 178.57,40.26
  BOTTOM w0.102: 178.57,40.26 179.26,39.58 180.16,39.58 v2(180.39,39.34) ; v2(192.95,28.98) 192.66,28.69 192.66,24.04 194.8,21.89 200.37,21.89 204.99,26.51 205.06,26.51 205.36,26.81 CON4402.2
USB2_COMP: length 8.2
  BOTTOM w0.089: 171.72,63.3 172.52,62.49 172.52,62.06 172.79,61.8 U2000.AG3
  BOTTOM w0.203: 171.72,63.3 171.36,63.66 171.36,64 170.96,64.4 170.96,64.7 170.62,65.04 168.86,65.04 v1(168.78,65.12) 168.73,65.17 R2526.2
USB2_ID: length 6.4
  BOTTOM w0.089: U2000.AG2 172.79,62.43 172.64,62.65 172.64,62.68 ; v1(169.9,66.18) 169.56,66.53
  BOTTOM w0.102: 172.64,62.68 172.11,63.22 172.11,63.34 171.63,63.82 171.63,64.07 171.2,64.5 171.2,64.8 170.72,65.29 170.54,65.29 169.9,65.93 v1(169.9,66.18) ; 169.56,66.53 R2001.2
USB2_VBUSSENSE: length 9.5
  TOP w0.102: R2000.1 170.38,65.29 170.89,64.78 170.89,62.82 170.56,62.49 v1(170.56,62.01) 170.56,61.71 170.89,61.38 170.89,60.12 v2(170.47,59.69)
  BOTTOM w0.102: v2(170.47,59.69) 170.92,59.24 170.92,58.97 U2000.AD10
USB3_RX_H_N1: length 6.9
  TOP w0.114: CON5500.5 260,48.5 259.81,48.32 259.24,48.32 258.82,47.89 258.82,47.46 258.55,47.19 258.05,47.19 257.92,47.32 U5500.10 U5500.1 256.47,47.32 256.34,47.19 256.06,47.19 255.68,47.56 255.3,47.56 RN5500.2
USB3_RX_H_N2: length 11.9
  TOP w0.114: CON5501.5 260,76.03 259.64,75.67 257.43,75.67 256.35,74.58 256.35,73.93 ; RN5503.2 252.96,72.2 253.68,72.2 254.13,71.75 U5502.1 U5502.10 255.93,71.75 256.07,71.62 256.2,71.62 256.35,71.76 256.35,73.93 ; 256.35,73.93 v1(256.11,73.93)
USB3_RX_H_P1: length 6.9
  TOP w0.114: CON5500.6 260,47.97 259.89,48.08 259.34,48.08 259.05,47.8 259.05,47.36 258.65,46.96 258.05,46.96 257.92,46.82 U5500.9 U5500.2 256.49,46.82 256.36,46.95 255.96,46.95 255.59,47.33 255.22,47.33 RN5500.4
USB3_RX_H_P2: length 12
  TOP w0.114: v1(257.51,75.05) 257.33,75.23 ; 257.33,75.23 256.59,74.49 256.59,71.67 256.3,71.38 256.06,71.38 255.94,71.25 U5502.9 U5502.2 254.49,71.25 254.23,71.52 254.03,71.52 253.58,71.97 253.11,71.97 RN5503.4 ; 257.33,75.23 257.53,75.43 259.67,75.43 260,75.1 CON5501.6
USB3_RX_N1: length 199.3
  TOP w0.114: 161.39,58.13 162.46,58.13 162.53,58.06 162.53,57.87 162.46,57.8 162.23,57.8 162.15,57.73 v2(162.15,57.5) ; 161.39,58.13 v1(161.39,57.9) ; 161.39,58.13 160.99,58.13 159.23,59.89 158.34,59.89 v2(157.91,60.32) ; v2(251.88,46.98) 251.93,46.93 252.16,46.93 252.31,47.08 252.31,47.35 252.54,47.59 252.91,47.59 253.24,47.92 L5500.4
  IN1 w0.089: v2(251.88,46.98) 252.26,46.98 252.35,47.07 252.35,48.97 252.12,49.19 250.16,49.19 249.41,48.44 249.41,47.72 249.66,47.47 249.66,45.6 250.95,44.31 250.95,37.43 248.99,35.48 248.49,35.48 247.52,34.51 247.52,28.87 246.11,27.46 235.8,27.46 234.97,26.62 232.36,26.62 232.28,26.7 229.78,26.7 226.39,30.09 224.92,30.09 224.25,29.43 220.92,29.43 217.88,26.39 217.88,25.22 217.4,24.73 207.09,24.73 206.93,24.89 206.93,25.28 206.88,25.33 206.76,25.33 206.71,25.28 206.71,25.18 206.65,25.13 206.53,25.13 206.47,25.18 v2(206.47,25.66)
  BOTTOM w0.114: v2(206.47,25.66) 206.47,25.46 206.54,25.39 206.79,25.39 206.88,25.31 206.88,25.14 201.61,19.88 160.28,19.88 155.75,24.41 155.75,25.25 153.1,27.89 148.65,27.89 144.59,31.96 144.59,39.73 144.95,40.09 144.95,46.11 142.35,48.71 142.35,56.11 143.52,57.28 146.42,57.28 147.86,58.72 147.86,60.32 148.18,60.64 157.87,60.64 157.91,60.59 v2(157.91,60.32) ; U2000.G13 162.15,57.43 v2(162.15,57.5)
USB3_RX_N2: length 131.1
  TOP w0.114: v2(244.55,72.43) 244.73,72.24 245.57,72.24 ; 245.57,72.24 v1(245.57,72.48) ; 245.57,72.24 249.16,72.24 249.34,72.06 250.45,72.06 250.84,72.45 L5503.4
  IN4 w0.089: v2(244.55,72.43) 244.55,72.34 244.36,72.15 244.13,72.15 243.88,71.89 243.88,69.34 243.46,68.93 243.46,65.42 241.61,63.57 241.61,60.69 240.98,60.05 240.13,60.05 239.41,59.34 237.74,59.34 236.79,58.39 233.48,58.39 231.67,56.58 227.22,56.58 226.32,55.67 219.35,55.67 218.07,54.38 217.2,54.38 215.99,53.17 208.51,53.17 206.34,50.99 202.62,50.99 200.61,53 200.61,54.98 196.14,59.45 189.03,59.45 187.03,61.44 187.03,64.69 184.78,66.95 183.69,66.95 183.13,67.51 170.15,67.51 168.45,65.8 168.45,63.16 167.19,61.89 165.18,61.89 164.24,60.95 164.24,60.29 164.06,60.11 161.07,60.11 160.07,59.11 160.07,58.55 159.66,58.14 156.78,58.14 156.54,58.37 156.54,58.83 v2(156.77,59.06)
  BOTTOM w0.089: U2000.C8 160.67,59.31 160.32,58.96 160.04,58.96 159.9,59.11 159.85,59.11
  BOTTOM w0.114: v2(156.77,59.06) 156.62,59.21 156.62,59.44 156.8,59.62 158.75,59.62 159.27,59.11 159.85,59.11
USB3_RX_N3: length 195.9
  IN1 w0.089: v2(158.52,58.81) 158.09,58.38 158.09,58.06 156.73,56.7 154.57,56.7 149.28,51.4 149.28,50.9 146.97,48.59 146.07,48.59 144.59,47.12 139.11,47.12 138.86,46.86 133.55,46.86 132.92,46.23 128.29,46.23 127.46,47.06 111.65,47.06 110.74,46.15 104.18,46.15 102.99,44.96 89.69,44.96 88.03,43.3 68.15,43.3 67.83,43.62 59.14,43.62 58.79,43.27 48.52,43.27 47.71,42.46 44.91,42.46 43.75,43.62 27.78,43.62 26.78,44.61 26.78,53.6 24.98,55.4 24.98,57.06 20.68,61.36 11.91,61.36 9.21,64.05 7.98,64.05 5.11,66.92 5.11,78 5.43,78.32 v7(6.07,78.32)
  BOTTOM w0.114: v2(158.52,58.81) 158.81,58.81 159.09,58.53 160.23,58.53 U2000.B10 ; CON6700.34 9,78.25 8.87,78.12 7.72,78.12 7.52,78.32 v7(6.07,78.32)
USB3_RX_N4: length 204.2
  IN1 w0.089: v2(161.47,58.8) 161.77,58.5 161.77,58.36 161.26,57.85 158.8,57.85 156.82,55.87 154.43,55.87 149.86,51.3 149.86,50.81 147.02,47.97 146.36,47.97 145.01,46.63 139.29,46.63 138.42,45.76 112.07,45.76 111.99,45.68 104.37,45.68 103.14,44.44 90.28,44.44 88.63,42.8 48.73,42.8 47.91,41.98 42.62,41.98 42.22,42.38 36.03,42.38 35.29,43.12 27.61,43.12 26.29,44.44 26.29,53.33 24.51,55.11 24.51,56.86 20.49,60.89 11.66,60.89 8.96,63.58 7.93,63.58 7.28,63.58 4.42,66.44 4.42,70.08 3.91,70.59 3.91,78.64 7.21,81.93 7.65,81.93 7.73,81.85 7.73,81.65 v2(7.54,81.46)
  BOTTOM w0.114: U2000.E11 161.94,57.93 162.13,57.93 162.24,58.04 162.24,58.3 162.14,58.4 161.96,58.4 161.56,58.8 v2(161.47,58.8) ; CON6700.43 9,82.75 8.89,82.64 8.3,82.64 7.73,82.07 7.73,81.65 v2(7.54,81.46)
USB3_RX_N5: length 215.7
  TOP w0.114: v2(163.7,56.53) 163.95,56.78 164.23,56.78 164.87,57.42 164.87,58.36 164.34,58.89 163.09,58.89 162.05,59.94 160.85,59.94 160.17,60.62 160.17,69.27 159.14,70.3 159.14,73.66 155.45,77.35 v2(155.45,77.61)
  IN2 w0.095: v2(98.68,184.6) 98.68,184.07 98.56,183.95 98.4,183.95 98.2,184.15 97.94,184.15 97.65,183.87 97.5,183.87 95.43,181.8 90.86,181.8 88.86,179.8 85.76,179.8 84.48,178.51 83.25,178.51 82.51,177.78 82.51,174.19 81.36,173.03 81.36,162.96 80.44,162.04 80.44,161.51 78.19,159.26 78.19,155.08 78.46,154.81 78.77,154.81 79.76,153.82 79.76,151.26 81.83,149.19 81.83,123.23 85.18,119.88 85.18,107.54 105.77,86.95 105.77,85.6 108.72,82.65 108.72,79.92 110.44,78.2 112.64,78.2 115.88,74.97 120.31,74.97 122.97,72.31 137.19,72.31 140.67,75.79 142.39,75.79 142.83,76.23 144.67,76.23 146.64,74.26 149.07,74.26 150.62,75.8 151.15,75.8 152.44,77.08 152.44,77.54 152.75,77.84 152.75,78.16 153.19,78.61 154.84,78.61 155.23,78.21 155.23,77.83 v2(155.45,77.61)
  BOTTOM w0.114: U2000.H15 163.7,56.43 v2(163.7,56.53) ; C4304.1 98.48,184.27 98.48,184.4 v2(98.68,184.6)
USB3_RX_N6: length 183.2
  IN1 w0.089: v2(164.01,57.5) 163.81,57.69 163.81,58.23 162.64,59.4 159.66,59.4 159.28,59.78 154.95,59.78 149.91,54.74 149.91,53.71 149.35,53.15 146.56,53.15 142.94,49.54 140.5,49.54 139.95,48.98 136.53,48.98 136.08,48.53 113.23,48.53 112.52,49.24 109.64,49.24 108.57,48.18 103.96,48.18 102.28,46.49 87.18,46.49 86.17,45.48 66.4,45.48 66,45.09 30.44,45.09 28.49,47.03 27.74,47.03 27.53,46.83 v2(27.53,46.18)
  BOTTOM w0.114: v2(27.53,46.18) 27.53,47.34 28.42,48.23 29.07,48.23 31.31,50.47 31.31,52.51 26.43,57.38 22.39,57.38 18.65,61.12 17.37,61.12 ; U2000.K15 164.44,56.41 164.44,57.06 v2(164.01,57.5) ; v1(17.37,60.88) 17.37,61.12 ; 17.37,61.12 15.2,61.12 13.68,62.64 12.23,62.64 11.12,63.75 CON6700.5
USB3_RX_P1: length 199.3
  TOP w0.114: v1(159.18,60.39) 159.18,60.12 ; 159.18,60.12 158.72,60.12 v2(158.52,60.32) ; 159.18,60.12 159.33,60.12 161.09,58.36 162.56,58.36 162.76,58.16 v2(162.76,57.5) ; v2(252.33,46.53) 252.54,46.75 252.54,47.25 252.64,47.35 252.83,47.35 253.12,47.07 L5500.1
  IN1 w0.089: v2(207.11,25.66) 207.11,24.96 207.17,24.91 217.32,24.91 217.7,25.29 217.7,26.46 220.85,29.6 224.18,29.6 224.84,30.27 226.46,30.27 229.85,26.88 232.35,26.88 232.43,26.8 234.89,26.8 235.73,27.64 246.03,27.64 247.34,28.94 247.34,34.58 248.41,35.65 248.92,35.65 250.77,37.51 250.77,44.23 249.48,45.52 249.48,47.4 249.23,47.65 249.23,48.51 250.09,49.37 252.2,49.37 252.53,49.04 252.53,46.73 v2(252.33,46.53)
  BOTTOM w0.114: U2000.H13 163.17,57.12 163.14,57.12 v2(162.76,57.5) ; v2(207.11,25.66) 207.11,25.05 201.71,19.65 160.18,19.65 155.51,24.31 155.51,25.15 153.01,27.66 148.56,27.66 144.36,31.86 144.36,39.83 144.71,40.19 144.71,46.02 142.11,48.62 142.11,56.21 143.42,57.52 146.32,57.52 147.63,58.82 147.63,60.42 148.08,60.88 157.96,60.88 v2(158.52,60.32)
USB3_RX_P2: length 131.1
  TOP w0.114: 247.32,72.01 244.79,72.01 v2(244.55,71.76) ; 247.32,72.01 v1(247.32,71.77) ; 247.32,72.01 249.06,72.01 249.24,71.83 250.55,71.83 250.56,71.81 250.59,71.81 250.81,71.6 L5503.1
  IN4 w0.089: v2(244.55,71.76) 244.34,71.97 244.21,71.97 244.06,71.82 244.06,69.27 243.64,68.85 243.64,65.35 241.79,63.5 241.79,60.61 241.05,59.88 240.2,59.88 239.49,59.16 237.82,59.16 236.86,58.21 233.55,58.21 231.74,56.4 227.3,56.4 226.39,55.49 219.43,55.49 218.14,54.21 217.28,54.21 216.06,52.99 208.59,52.99 206.41,50.81 202.54,50.81 200.43,52.92 200.43,54.91 196.07,59.27 188.95,59.27 186.86,61.37 186.86,64.62 184.7,66.77 183.62,66.77 183.06,67.33 170.23,67.33 168.63,65.73 168.63,63.09 167.26,61.71 165.25,61.71 164.41,60.88 164.41,60.22 164.14,59.94 161.15,59.94 160.25,59.04 160.25,58.48 159.73,57.97 156.7,57.97 156.37,58.3 156.37,58.83 v2(156.14,59.06)
  BOTTOM w0.089: 159.85,59.34 159.86,59.34 159.89,59.31 159.93,59.31 159.95,59.3 160.1,59.3 U2000.B8
  BOTTOM w0.114: v2(156.14,59.06) 156.39,59.31 156.39,59.54 156.7,59.86 158.85,59.86 159.37,59.34 159.85,59.34
USB3_RX_P3: length 195.9
  IN1 w0.089: v2(6.07,77.64) 5.78,77.64 5.74,77.68 5.74,78.09 5.68,78.15 5.51,78.15 5.29,77.92 5.29,67 8.05,64.23 9.29,64.23 11.98,61.53 20.75,61.53 25.16,57.13 25.16,55.48 26.96,53.67 26.96,44.68 27.85,43.79 43.83,43.79 44.98,42.64 47.64,42.64 48.44,43.45 58.72,43.45 59.07,43.79 67.9,43.79 68.22,43.48 87.96,43.48 89.62,45.14 102.91,45.14 104.1,46.33 110.67,46.33 111.58,47.23 127.54,47.23 128.36,46.41 132.85,46.41 133.48,47.04 138.79,47.04 139.04,47.29 144.52,47.29 146,48.77 146.9,48.77 149.1,50.97 149.1,51.48 154.5,56.88 156.66,56.88 157.91,58.13 157.91,58.81 v2(157.91,58.82)
  BOTTOM w0.114: v2(6.07,77.64) 6.34,77.64 6.44,77.74 6.44,78.01 6.52,78.09 7.42,78.09 7.63,77.89 8.89,77.89 9.03,77.75 CON6700.33 ; U2000.A9 159.76,58.77 159.18,58.77 158.72,59.23 158.32,59.23 v2(157.91,58.82)
USB3_RX_P4: length 204.2
  IN1 w0.089: v2(162.13,58.82) 161.95,58.63 161.95,58.29 161.34,57.68 158.88,57.68 156.89,55.69 154.51,55.69 150.04,51.22 150.04,50.74 147.09,47.8 146.43,47.8 145.09,46.45 139.36,46.45 138.5,45.59 112.14,45.59 112.06,45.5 104.45,45.5 103.21,44.27 90.35,44.27 88.7,42.62 48.8,42.62 47.98,41.8 42.55,41.8 42.15,42.2 35.96,42.2 35.22,42.94 27.54,42.94 26.11,44.36 26.11,53.26 24.33,55.03 24.33,56.79 20.41,60.71 11.58,60.71 8.89,63.4 7.93,63.4 7.2,63.4 4.24,66.36 4.24,70.01 3.73,70.52 3.73,78.71 7.14,82.11 7.72,82.11 7.91,81.92 7.91,81.78 v7(8.23,81.46)
  BOTTOM w0.114: CON6700.42 9.03,82.25 8.87,82.41 8.4,82.41 7.96,81.97 7.96,81.73 v7(8.23,81.46) ; U2000.G11 162.47,58.14 162.47,58.4 162.33,58.54 162.33,58.62 v2(162.13,58.82)
USB3_RX_P5: length 215.7
  TOP w0.114: v2(162.92,56.53) 163.4,57.02 164.13,57.02 164.64,57.52 164.64,58.26 164.24,58.66 163,58.66 161.95,59.71 160.76,59.71 159.94,60.53 159.94,69.17 158.9,70.2 158.9,73.56 155.21,77.26 154.85,77.61 v7(154.76,77.61)
  IN2 w0.095: v7(154.76,77.61) 155.02,77.88 155.02,78.12 154.75,78.4 153.28,78.4 152.95,78.07 152.95,77.76 152.65,77.45 152.65,77 151.24,75.59 150.7,75.59 149.16,74.05 146.55,74.05 144.59,76.02 142.91,76.02 142.48,75.58 140.76,75.58 137.27,72.1 122.89,72.1 120.23,74.76 115.79,74.76 112.56,77.99 110.36,77.99 108.51,79.84 108.51,82.57 105.56,85.52 105.56,86.87 84.97,107.45 84.97,119.79 81.62,123.14 81.62,149.1 79.55,151.17 79.55,153.73 78.69,154.6 78.37,154.6 77.98,154.99 77.98,159.34 80.23,161.6 80.23,162.13 81.15,163.04 81.15,173.11 82.3,174.27 82.3,177.87 83.16,178.72 84.39,178.72 85.68,180 88.77,180 90.78,182.01 95.34,182.01 97.41,184.08 97.57,184.08 v2(98.07,184.58)
  BOTTOM w0.114: v2(98.07,184.58) 97.58,184.09 C4303.1 ; v2(162.92,56.53) 162.92,56.41 U2000.G15
USB3_RX_P6: length 183.2
  IN1 w0.089: v2(163.37,57.5) 163.37,57.75 163.42,57.8 163.58,57.8 163.63,57.86 163.63,58.15 162.56,59.23 159.59,59.23 159.21,59.61 155.02,59.61 150.09,54.67 150.09,53.64 149.43,52.98 146.63,52.98 143.01,49.36 140.58,49.36 140.02,48.8 136.6,48.8 136.15,48.35 113.16,48.35 112.44,49.07 109.71,49.07 108.64,48 104.04,48 102.35,46.31 87.25,46.31 86.24,45.31 66.47,45.31 66.08,44.91 30.36,44.91 28.42,46.86 27.81,46.86 27.71,46.76 27.71,46.58 27.76,46.53 28.09,46.53 28.17,46.45 v2(28.17,46.18)
  BOTTOM w0.114: CON6700.6 10.39,64.25 10.45,64.19 10.45,64.05 10.52,63.98 11.22,63.98 12.32,62.88 13.78,62.88 15.3,61.36 15.65,61.36 ; v2(163.37,57.5) 163.92,56.94 U2000.K13 ; v2(28.17,46.18) 28.17,46.44 28.09,46.51 27.84,46.51 27.77,46.58 27.77,47.24 28.52,47.99 29.17,47.99 31.55,50.37 31.55,52.6 26.53,57.62 22.48,57.62 18.75,61.36 15.65,61.36 ; 15.65,61.36 v1(15.65,61.61)
USB3_TX_H_N1: length 12
  TOP w0.114: v1(257.51,43.63) 257.25,43.63 ; 257.25,43.63 257.25,42.57 257.51,42.32 259.7,42.32 260,42.62 CON5500.8 ; 257.25,43.63 257.25,43.96 257.37,44.08 258.42,44.08 258.81,44.47 258.81,45.37 258.52,45.67 258.07,45.67 257.92,45.82 U5500.7 U5500.4 256.47,45.82 255.92,45.27 255.52,45.27 255.21,45.58 L5502.3
USB3_TX_H_N2: length 8.7
  TOP w0.114: CON5501.8 260,69.92 259.77,69.69 258.48,69.69 258.03,70.15 256.14,70.15 256.03,70.25 U5502.7 U5502.4 254.54,70.25 254.41,70.12 254.08,70.12 253.42,69.46 253.26,69.46 252.95,69.77 L5505.3
USB3_TX_H_P1: length 12
  TOP w0.114: v1(257.56,41.85) 257.56,42.08 ; 257.56,42.08 257.41,42.08 257.02,42.47 257.02,44.06 257.27,44.32 258.32,44.32 258.57,44.57 258.57,45.28 258.42,45.43 258.03,45.43 257.92,45.32 U5500.6 U5500.5 256.3,45.32 256.02,45.04 255.52,45.04 255.22,44.73 L5502.2 ; 257.56,42.08 259.89,42.08 260,41.97 CON5500.9
USB3_TX_H_P2: length 9
  TOP w0.114: 257.48,69.91 256.11,69.91 255.96,69.75 U5502.6 U5502.5 254.55,69.75 254.41,69.89 254.18,69.89 253.52,69.23 253.08,69.23 L5505.2 ; 257.48,69.91 v1(257.48,69.69) ; 257.48,69.91 257.93,69.91 258.39,69.46 259.92,69.46 260,69.38 CON5501.9
USB3_TX_N1: length 172
  TOP w0.114: L5502.4 253.44,45.58 253.16,45.3 252.7,45.3 252.49,45.09 252.16,45.09 v2(252.01,45.23)
  IN1 w0.089: v2(252.01,45.23) 251.43,44.66 251.43,37.25 248.82,34.64 248.82,29.28 246.48,26.93 236.1,26.93 235.31,26.14 232,26.14 231.91,26.23 229.56,26.23 226.2,29.59 225.22,29.59 224.47,28.84 224.13,28.84 222.92,27.63 222.22,27.63 221.5,26.91 221.5,26.3 219.11,23.92 206.54,23.92 205.73,24.73 205.73,25.62 v2(205.8,25.69)
  BOTTOM w0.114: v2(205.8,25.69) 205.55,25.45 205.55,25.2 200.73,20.38 160.72,20.38 156.29,24.81 156.29,25.44 153.31,28.41 149.07,28.41 145.09,32.4 145.09,38.94 145.45,39.29 145.45,46.85 142.85,49.45 142.85,55.82 143.8,56.77 146.06,56.77 146.7,56.14 146.7,54.23 147.11,53.82 149.84,53.82 C2003.2
USB3_TX_N1_C: length 11.3
  BOTTOM w0.089: U2000.B14 160.3,56.33 160,56.33 159.93,56.26 159.62,56.26 159.3,56.58 157.21,56.58 156.16,55.53 155.47,55.53 155.36,55.64 155.34,55.64 155.33,55.65 155.29,55.65 155.26,55.68 155.25,55.68
  BOTTOM w0.114: 151.92,53.8 152.23,53.8 154.11,55.68 155.25,55.68 ; 151.92,53.8 v1(151.92,54.04) ; 151.92,53.8 151.12,53.8 C2003.1
USB3_TX_N2: length 135.6
  TOP w0.114: 244.13,71.01 248.02,71.01 249.87,69.16 250.38,69.16 250.44,69.23 250.44,69.39 250.15,69.69 250.15,69.82 250.26,69.93 250.39,69.93 250.58,69.75 RN5505.1 ; 244.13,71.01 v1(244.13,71.26) ; 244.13,71.01 v2(243.38,71.01)
  IN4 w0.089: v2(154.21,57.96) 154.33,58.08 154.33,58.49 158.19,62.35 162.15,62.35 163.73,63.92 164.95,63.92 169.19,68.17 183.05,68.17 183.56,68.67 184.46,68.67 184.93,68.19 186.29,68.19 187.68,66.8 187.68,61.74 187.83,61.59 193.04,61.59 194.34,60.29 196.22,60.29 201.31,55.2 201.31,53.26 202.9,51.67 205.94,51.67 208.47,54.2 215.9,54.2 217.09,55.39 217.83,55.39 218.84,56.41 226.04,56.41 227.26,57.62 231.7,57.62 233.23,59.16 236.48,59.16 237.31,59.99 239.14,59.99 239.86,60.7 240.62,60.7 240.8,60.88 240.8,63.72 242.56,65.49 242.56,70.19 v2(243.38,71.01)
  BOTTOM w0.114: v2(154.21,57.96) 154.21,59.55 154.06,59.7 149.25,59.7 148.98,59.44 148.98,58.93 149.15,58.77 149.3,58.77 C2005.2
USB3_TX_N2_C: length 11.4
  BOTTOM w0.114: v1(153.14,58.69) 152.97,58.53 ; 152.97,58.53 152.43,59.07 C2005.1 ; 152.97,58.53 153.47,58.03 153.52,58.03 154.12,57.43 155.62,57.43 156.42,58.22 159.63,58.22 U2000.B12
USB3_TX_N3: length 177.2
  IN1 w0.089: v2(148.54,55.55) 147.96,56.13 146.97,56.13 144.27,53.43 144.27,53.21 142.02,50.96 137.01,50.96 136.82,51.14 109.65,51.14 108.43,49.92 103.62,49.92 101.89,48.18 101.24,48.18 74.5,48.18 74.12,47.8 66.73,47.8 65.31,46.39 60.05,46.39 59.65,46.79 30.62,46.79 28.28,49.13 28.28,54.46 26.45,56.29 26.45,57.67 21.29,62.83 13.47,62.83 9.04,67.25 8.03,67.25 6.79,68.49 6.79,72.9 6.79,73.94 8.1,75.24 8.1,76.09 7.88,76.3 7.48,76.3 v7(7.24,76.55)
  BOTTOM w0.114: C2007.2 151.69,56.61 149.93,56.61 149.28,57.26 148.36,57.26 148.13,57.04 148.13,56.44 148.37,56.2 148.37,55.71 v2(148.54,55.55) ; CON6700.31 9.02,76.75 8.75,76.48 7.3,76.48 v7(7.24,76.55)
USB3_TX_N3_C: length 9
  BOTTOM w0.089: 158.67,57.39 159.3,57.39 159.59,57.11 160,57.11 160.03,57.14 160.53,57.14 U2000.C13
  BOTTOM w0.114: C2007.1 153.18,56.28 153.26,56.35 153.26,56.85 153.34,56.93 153.51,56.93 153.83,56.61 156,56.61 156.78,57.39 158.67,57.39
USB3_TX_N4: length 180.8
  IN1 w0.089: v2(148.59,54.37) 147.98,54.98 146.94,54.98 146.3,54.35 146.3,53.89 142.6,50.18 140.01,50.18 139.57,49.74 136.69,49.74 135.94,50.49 109.92,50.49 109.23,49.8 108.7,49.27 103.96,49.27 101.84,47.15 66.99,47.15 65.58,45.74 30.71,45.74 27.64,48.81 27.64,54.07 25.81,55.89 25.81,57.4 21.02,62.18 12.3,62.18 9.5,64.98 8.45,64.98 5.99,67.44 5.99,76.07 6.79,76.87 6.79,79.2 6.63,79.36 6.63,80.44 6.8,80.61 7.22,80.61 7.32,80.51 7.32,80.31 v7(7.09,80.08)
  BOTTOM w0.114: v2(148.59,54.37) 148.36,54.6 148.36,54.73 148.46,54.82 149.17,54.82 149.6,55.25 149.8,55.25 C2011.2 ; v7(7.09,80.08) 7.5,80.49 8.01,80.49 8.59,81.07 8.87,81.07 9.06,81.25 CON6700.40
USB3_TX_N4_C: length 10.1
  BOTTOM w0.089: U2000.A14 159.72,56.59 159.57,56.59 159.36,56.8 156.88,56.8 156.61,56.52 156.61,56.51 156.59,56.49 156.59,56.44 156.57,56.42
  BOTTOM w0.114: 156.57,56.42 156.14,55.99 153.95,55.99 153.23,55.28 151.92,55.28 151.74,55.47 151.41,55.47 151.31,55.36 151.31,55.03 151.23,54.96 C2011.1
USB3_TX_N5: length 234.3
  TOP w0.114: v2(143.72,75.52) 143.9,75.35 143.9,72.09 ; 143.9,72.09 v1(143.68,72.09) ; 143.9,72.09 143.9,70.76 144.81,69.85 144.81,66.3 144.51,66 144.51,55.47 144.68,55.29 144.68,54.77 145.93,53.52 145.99,53.46 145.99,52.39 145.99,52.39 145.99,52 146.32,51.68 146.81,51.68 147.12,51.37 v2(147.12,51.07)
  IN2 w0.095: v2(94.79,184.5) 94.99,184.3 95.54,184.3 95.76,184.09 95.76,183.44 94.81,182.49 90.58,182.49 88.68,180.59 85.59,180.59 84.21,179.21 82.9,179.21 81.82,178.13 81.82,174.48 80.32,172.97 80.32,163.82 78.53,162.03 78.53,160.61 77.39,159.47 77.39,150.91 80.75,147.55 80.75,123.29 84.29,119.74 84.29,107.46 105.08,86.67 105.08,85.32 108.03,82.37 108.03,79.64 109.75,77.93 109.75,74.08 110.69,73.13 110.69,65.97 111.48,65.18 120.25,65.18 124.04,61.38 129.67,61.38 130.92,62.63 132.07,62.63 133.47,64.03 134.12,64.03 134.46,64.36 134.46,68.13 135.5,69.17 135.5,70.58 135.98,71.06 137.19,71.06 139.98,73.86 141.12,73.86 142.3,75.03 143.75,75.03 143.92,75.2 143.92,75.32 v2(143.72,75.52)
  BOTTOM w0.089: 153.09,51.6 153.11,51.6 153.13,51.58 153.32,51.58 155.85,54.11 156.78,54.11 158.33,55.66 159.13,55.66 159.27,55.52 159.44,55.52 159.68,55.28 U2000.A16
  BOTTOM w0.114: v2(94.79,184.5) 95.07,184.5 95.35,184.79 95.75,184.79 95.76,184.79 96.05,184.79 96.25,184.59 96.25,184.28 C4311.1 ; 153.09,51.6 149.21,51.6 148.9,51.91 147.63,51.91 147.37,51.66 147.37,51.32 v2(147.12,51.07)
USB3_TX_N6: length 178.7
  IN1 w0.089: v2(147.29,52.43) 147.51,52.21 147.51,51.93 147.27,51.68 146.15,51.68 143.13,48.66 140.84,48.66 140.13,47.95 138.77,47.95 138.52,47.69 133.18,47.69 132.66,47.16 128.65,47.16 127.93,47.88 109.39,47.88 108.94,47.44 104.3,47.44 102.69,45.83 87.74,45.83 86.64,44.72 67.51,44.72 67.23,44.44 52.63,44.44 52.3,44.11 48.12,44.11 47.76,43.76 44.81,43.76 44.12,44.44 29.94,44.44 29.09,45.29 27.93,45.29 v2(27.52,44.89)
  BOTTOM w0.089: U2000.B15 160.1,55.78 159.82,55.78 159.7,55.9 159.44,55.9 159.12,56.21 157.37,56.21 155.75,54.6 155.38,54.6 153.71,52.93 153.09,52.93
  BOTTOM w0.114: 153.09,52.93 151.44,52.93 150.91,52.4 149.5,52.4 148.81,53.09 147.9,53.09 147.29,52.48 v2(147.29,52.43) ; 12.83,63.92 12.48,63.92 11.14,65.25 CON6700.8 ; 12.83,63.92 13.67,63.92 15.13,62.46 18.36,62.46 22.7,58.12 26.74,58.12 32.05,52.8 32.05,49.82 28.79,46.56 28.79,45.71 28.72,45.64 28.04,45.64 27.77,45.37 27.77,45.14 v2(27.52,44.89) ; 12.83,63.92 v1(12.83,63.67)
USB3_TX_P1: length 171.6
  TOP w0.114: L5502.1 253.42,44.73 253.08,45.07 252.8,45.07 252.59,44.86 252.27,44.86 v2(252.01,44.6)
  IN1 w0.089: v2(252.01,44.6) 251.97,44.64 251.67,44.64 251.61,44.58 251.61,37.18 249,34.56 249,29.2 246.55,26.76 236.18,26.76 235.38,25.96 231.93,25.96 231.83,26.05 229.49,26.05 226.13,29.41 225.29,29.41 224.55,28.67 224.2,28.67 222.99,27.45 222.3,27.45 221.68,26.83 221.68,26.23 219.19,23.74 206.46,23.74 205.55,24.66 205.55,25.33 205.49,25.39 205.22,25.39 205.17,25.44 v2(205.17,25.69)
  BOTTOM w0.114: v2(205.17,25.69) 205.32,25.54 205.32,25.29 200.64,20.61 160.81,20.61 156.52,24.9 156.52,25.54 153.41,28.65 149.58,28.65 ; C2002.2 149.68,53.59 147.01,53.59 146.46,54.14 146.46,56.04 145.97,56.54 143.9,56.54 143.08,55.73 143.08,49.55 145.68,46.95 145.68,39.2 145.32,38.84 145.32,32.5 149.17,28.65 149.58,28.65 ; 149.58,28.65 v1(149.58,28.9)
USB3_TX_P1_C: length 11.9
  BOTTOM w0.089: U2000.C14 160.85,56.41 160.58,56.14 160.08,56.14 160.01,56.07 159.54,56.07 159.22,56.39 157.29,56.39 156.24,55.34 155.39,55.34 155.28,55.45 155.25,55.45
  BOTTOM w0.114: 155.25,55.45 154.21,55.45 153.34,54.58 ; 153.34,54.58 152.32,53.56 151.23,53.56 C2002.1 ; 153.34,54.58 v1(153.52,54.4)
USB3_TX_P2: length 135.7
  TOP w0.114: 245.77,70.77 247.92,70.77 249.77,68.92 L5505.1 ; 245.77,70.77 v1(245.77,70.53) ; 245.77,70.77 243.76,70.77 v2(243.38,70.4)
  IN4 w0.089: v2(243.38,70.4) 243.02,70.4 242.74,70.11 242.74,65.42 240.98,63.65 240.98,60.81 240.69,60.52 239.93,60.52 239.22,59.81 237.38,59.81 236.55,58.98 233.31,58.98 231.78,57.45 227.33,57.45 226.11,56.23 218.91,56.23 217.9,55.22 217.17,55.22 215.97,54.02 208.55,54.02 206.02,51.49 202.83,51.49 201.13,53.19 201.13,55.12 196.14,60.11 194.26,60.11 192.97,61.41 187.76,61.41 187.5,61.66 187.5,66.73 186.22,68.01 184.86,68.01 184.38,68.49 183.63,68.49 183.12,67.99 169.26,67.99 165.02,63.75 163.8,63.75 162.23,62.17 158.26,62.17 154.51,58.42 154.51,58.29 v2(154.83,57.97)
  BOTTOM w0.114: v2(154.83,57.97) 154.83,58.2 154.74,58.29 154.51,58.29 154.44,58.36 154.44,59.65 154.16,59.94 149.15,59.94 148.75,59.54 148.75,58.83 149.05,58.53 149.25,58.53 C2004.2
USB3_TX_P2_C: length 11.4
  BOTTOM w0.114: U2000.A12 159.8,57.73 159.54,57.99 156.51,57.99 155.72,57.2 154.02,57.2 153.43,57.79 153.38,57.79 152.33,58.84 151.41,58.84 ; C2004.1 150.82,58.18 150.95,58.31 150.95,58.72 151.07,58.84 151.41,58.84 ; v1(151.41,58.59) 151.41,58.84
USB3_TX_P3: length 177.4
  IN1 w0.089: v2(7.26,75.86) 7.53,76.13 7.81,76.13 7.92,76.01 7.92,75.32 6.62,74.01 6.62,72.82 6.62,68.41 7.95,67.08 8.97,67.08 13.39,62.65 21.22,62.65 26.28,57.59 26.28,56.22 28.11,54.39 28.11,49.05 30.55,46.61 59.58,46.61 59.98,46.21 65.39,46.21 66.8,47.62 74.19,47.62 74.57,48 101.17,48 101.96,48 103.7,49.74 108.5,49.74 109.73,50.96 136.75,50.96 136.93,50.78 142.1,50.78 144.45,53.13 144.45,53.36 147.04,55.95 147.89,55.95 148,55.84 148,55.64 v2(147.9,55.55)
  BOTTOM w0.114: 150.39,56.84 150.03,56.84 149.38,57.5 148.26,57.5 147.9,57.14 147.9,56.35 148.14,56.11 148.14,55.78 v2(147.9,55.55) ; 150.39,56.84 151.7,56.84 C2006.2 ; 150.39,56.84 v1(150.39,57.09) ; CON6700.30 7.63,76.25 7.26,75.89 v2(7.26,75.86)
USB3_TX_P3_C: length 9
  BOTTOM w0.089: U2000.D13 160.87,57.33 159.95,57.33 159.92,57.3 159.66,57.3 159.38,57.58 158.77,57.58 158.76,57.59 158.72,57.59 158.69,57.62 158.67,57.62
  BOTTOM w0.114: C2006.1 153.6,57.16 153.92,56.84 155.9,56.84 156.68,57.62 158.67,57.62
USB3_TX_P4: length 180.8
  IN1 w0.089: v2(147.98,54.37) 147.98,54.73 147.9,54.81 147.02,54.81 146.48,54.27 146.48,53.81 142.67,50 140.08,50 139.64,49.57 136.61,49.57 135.87,50.31 110,50.31 109.41,49.73 108.77,49.09 104.04,49.09 101.92,46.97 67.07,46.97 65.66,45.56 30.63,45.56 27.46,48.73 27.46,53.99 25.63,55.82 25.63,57.32 20.95,62 12.22,62 9.43,64.8 8.37,64.8 5.81,67.36 5.81,76.14 6.61,76.94 6.61,79.13 6.45,79.29 6.45,80.51 6.73,80.79 7.29,80.79 7.49,80.59 7.49,80.36 v2(7.77,80.08)
  BOTTOM w0.114: C2009.2 149.73,55.49 149.5,55.49 149.07,55.06 148.36,55.06 148.13,54.83 148.13,54.52 v2(147.98,54.37) ; v2(7.77,80.08) 7.95,80.26 8.11,80.26 8.69,80.83 8.95,80.83 9.04,80.75 CON6700.39
USB3_TX_P4_C: length 10.1
  BOTTOM w0.089: U2000.B13 160.07,56.78 159.65,56.78 159.44,56.99 156.81,56.99 156.41,56.59
  BOTTOM w0.114: C2009.1 151.28,55.85 151.43,55.7 151.84,55.7 152.02,55.52 153.14,55.52 153.85,56.23 156.04,56.23 156.41,56.59
USB3_TX_P5: length 234.8
  TOP w0.114: 145.04,69.02 145.04,69.95 144.13,70.85 144.13,75.33 v2(144.33,75.52) ; 145.04,69.02 v1(145.26,69.02) ; 145.04,69.02 145.04,66.2 144.74,65.9 144.74,55.56 144.91,55.39 144.91,54.87 146.1,53.69 146.23,53.56 146.23,52.1 146.42,51.91 146.91,51.91 v2(147.75,51.07)
  IN2 w0.095: v2(94.79,183.89) 94.99,184.1 95.46,184.1 95.55,184 95.55,183.52 94.73,182.7 90.49,182.7 88.59,180.8 85.5,180.8 84.12,179.42 82.81,179.42 81.61,178.22 81.61,174.56 80.11,173.06 80.11,163.91 78.32,162.12 78.32,160.7 77.18,159.56 77.18,150.83 80.54,147.47 80.54,123.2 84.08,119.66 84.08,107.37 104.87,86.58 104.87,85.23 107.82,82.28 107.82,79.55 109.54,77.84 109.54,73.99 110.48,73.05 110.48,65.88 111.4,64.97 120.16,64.97 123.96,61.17 129.75,61.17 131,62.42 132.16,62.42 133.55,63.82 134.21,63.82 134.67,64.27 134.67,68.05 135.7,69.09 135.7,70.49 136.07,70.85 137.27,70.85 140.07,73.65 141.21,73.65 142.39,74.82 143.84,74.82 144.13,75.11 144.13,75.32 v2(144.33,75.52)
  BOTTOM w0.089: 153.09,51.36 153.17,51.36 153.19,51.39 153.4,51.39 155.93,53.92 156.86,53.92 158.41,55.47 159.05,55.47 159.19,55.33 159.36,55.33 159.65,55.03 159.91,55.03 159.92,55.04 160.07,55.04 U2000.B16
  BOTTOM w0.114: v2(94.79,183.89) 95.45,184.56 95.85,184.56 95.95,184.56 96.02,184.49 96.02,184.3 C4312.1 ; v2(147.75,51.07) 147.61,51.22 147.61,51.56 147.72,51.68 148.8,51.68 149.11,51.36 153.09,51.36
USB3_TX_P6: length 178.7
  IN1 w0.089: v2(147.9,52.44) 147.69,52.23 147.69,51.85 147.34,51.5 146.23,51.5 143.21,48.48 140.91,48.48 140.2,47.77 138.85,47.77 138.59,47.51 133.26,47.51 132.73,46.98 128.58,46.98 127.86,47.7 109.46,47.7 109.02,47.26 104.38,47.26 102.76,45.65 87.82,45.65 86.71,44.54 67.59,44.54 67.31,44.26 52.71,44.26 52.38,43.93 48.19,43.93 47.84,43.58 44.73,43.58 44.05,44.26 29.87,44.26 29.06,45.08 28.34,45.08 v2(28.15,44.89)
  BOTTOM w0.089: 153.21,52.69 153.26,52.74 153.79,52.74 155.46,54.41 155.83,54.41 157.45,56.02 159.04,56.02 159.36,55.7 159.62,55.7 159.74,55.59 160.42,55.59 U2000.C15
  BOTTOM w0.114: 17.58,62.69 15.23,62.69 13.77,64.15 12.58,64.15 11.24,65.48 10.53,65.48 10.27,65.75 CON6700.9 ; 17.58,62.69 18.45,62.69 22.8,58.35 26.83,58.35 32.28,52.9 32.28,49.72 29.03,46.46 29.03,45.61 28.82,45.4 28.13,45.4 28.01,45.28 28.01,45.04 28,45.04 v2(28.15,44.89) ; 17.58,62.69 v1(17.58,62.93) ; 153.21,52.69 151.53,52.69 151,52.16 149.4,52.16 148.71,52.85 148,52.85 147.9,52.76 v2(147.9,52.44)
USB5_3DCAM_A_DE0: length 1.8
  BOTTOM w0.114: U4301.16 95.49,179.53 95.17,179.85 95.17,179.98 R4311.2
USB5_3DCAM_A_DE1: length 3.9
  BOTTOM w0.102: R4310.2 94.21,183.22 v1(94.21,183.55)
  BOTTOM w0.114: R4310.2 95.38,182.05 95.38,180.67 95.53,180.53 U4301.18
USB5_3DCAM_A_EQ0: length 2.1
  BOTTOM w0.114: R4309.2 95.1,180.92 95.1,180.51 95.58,180.03 U4301.17
USB5_3DCAM_A_EQ1: length 1.5
  BOTTOM w0.114: R4306.2 95.21,179.03 U4301.15
USB5_3DCAM_B_DE0: length 1.9
  BOTTOM w0.102: R4307.2 100.82,180.16 100.51,180.16
  BOTTOM w0.114: 100.51,180.16 99.87,179.53 U4301.3
USB5_3DCAM_B_DE1: length 2.5
  BOTTOM w0.102: R4304.2 101.47,177.11 v1(101.7,177.11)
  BOTTOM w0.114: U4301.6 100.55,178.03 R4304.2
USB5_3DCAM_B_EQ0: length 2.4
  BOTTOM w0.102: R4302.2 100.51,181.32 100.13,180.94
  BOTTOM w0.114: 100.13,180.94 100.13,180.39 99.77,180.03 U4301.2
USB5_3DCAM_B_EQ1: length 1.8
  BOTTOM w0.114: R4303.2 100.58,179.03 U4301.4
USB5_3DCAM_PD#: length 280.3
  TOP w0.102: v1(94.79,167.48) 94.95,167.32 v2(95.43,167.32)
  IN1 w0.102: v2(99.9,38.14) 110.71,38.14 114.04,34.82 115.71,34.82 116.46,34.06 116.46,33.59 116.94,33.11 122.77,33.11 123,32.89 130.19,32.89 130.61,33.31 131.13,33.31 131.41,33.6 134.32,33.6 135.64,34.91 141.2,34.91 142.44,33.67 144.3,33.67 144.84,34.22 154.44,34.22 154.78,33.87 173.9,33.87 174.27,34.25 174.56,34.25 175.01,34.7 v2(175.68,34.7)
  IN3 w0.114: v2(101.6,177.87) 99.35,175.62 96.99,175.62 95.43,174.05 v2(95.43,167.32)
  IN4 w0.102: v2(95.43,167.32) 93.07,167.32 87.05,161.31 86.56,161.31 81.97,156.71 81.97,127.03 80.75,125.81 80.75,124.27 83.05,121.97 85.04,121.97 85.32,121.7 85.32,113.63 107.59,91.36 107.59,84.82 109.39,83.02 111.9,83.02 113.34,81.59 113.34,78.77 116.06,76.04 121.22,76.04 124.28,72.98 124.28,65.28 124.15,65.15 121.62,65.15 121.05,64.59 121.05,63.94 121.45,63.55 121.45,63.19 121.25,62.98 121.25,60.27 118.18,57.2 114.18,57.2 v2(112.68,55.69)
  BOTTOM w0.089: U2000.AJ44 173.49,40.77 173.75,40.52 173.75,38.99 174.66,38.07 174.66,37.73
  BOTTOM w0.102: v2(112.68,55.69) 112.68,54.8 104.45,46.58 103.05,46.58 100.76,44.29 100.76,41.85 99.9,40.99 v2(99.9,38.14) ; R4301.1 101.96,178.22 v2(101.6,177.87) ; v2(175.68,34.7) 175.82,34.7 176.11,34.99 176.11,35.5 176.01,35.6 176.01,36.29 R2361.2 175.35,36.95 175.34,36.95 174.66,37.62 174.66,37.73
USB5_3DCAM_PD#_R: length 4.2
  BOTTOM w0.102: v1(103.07,178.28) 102.27,179.08 101.22,179.08 101.09,178.95 R4301.2 100.2,178.66 100.07,178.53 U4301.5
USB5_3DCAM_REXT: length 2.4
  BOTTOM w0.102: 99.11,175.86 v1(98.86,176.12)
  BOTTOM w0.114: R4312.1 99.11,175.86 ; v1(98.86,176.12) 98.95,176.21 U4301.7
USB5_3DCAM_RXN1_C: length 2.2
  BOTTOM w0.114: U4301.23 98.45,181.52 98.32,181.65 98.32,182.01 98.17,182.15 98.17,182.76 C4304.2
USB5_3DCAM_RXN1_CON: length 9.5
  TOP w0.114: v2(90.73,185.13) 90.98,184.89 90.98,183.59 91.33,183.23 91.33,182.21 91.27,182.15 CON4301.2
  BOTTOM w0.114: v2(90.73,185.13) 90.98,184.88 90.98,184.71 90.98,184.61 90.86,184.48 90.86,183.9 U4302.6 U4302.5 90.75,182.5 90.82,182.42 90.82,182.26 90.72,182.15 89.98,182.15 89.72,181.89 89.72,181.82 89.71,181.81 89.71,181.58 89.61,181.48 89.49,181.48 89.29,181.27 L4302.2
USB5_3DCAM_RXN1_CON_C: length 14
  BOTTOM w0.114: L4302.1 89.29,178.39 89.46,178.21 89.46,177.87 ; U4301.8 98.45,177.24 98.19,176.97 98.19,176.77 96.41,174.99 93.94,174.99 93.75,175.18 90.83,175.18 89.97,176.04 89.97,177.21 89.46,177.71 89.46,177.87 ; 89.46,177.87 v1(89.24,177.87)
USB5_3DCAM_RXP1_C: length 2.2
  BOTTOM w0.114: U4301.22 97.95,181.55 98.08,181.68 98.08,181.91 97.94,182.06 97.94,182.69 C4303.2
USB5_3DCAM_RXP1_CON: length 9.5
  TOP w0.114: v2(91.41,185.16) 91.21,184.96 91.21,183.69 91.56,183.33 91.56,182.21 91.77,182.01 CON4301.3
  BOTTOM w0.114: v2(91.41,185.16) 91.22,184.96 91.22,184.51 91.09,184.38 91.09,183.95 U4302.7 U4302.4 91.24,182.35 90.82,181.92 90.08,181.92 89.95,181.8 89.95,181.51 90.14,181.32 L4302.3
USB5_3DCAM_RXP1_CON_C: length 14
  BOTTOM w0.114: 91.41,175.41 93.85,175.41 94.03,175.23 96.32,175.23 97.95,176.86 U4301.9 ; 91.41,175.41 90.93,175.41 90.2,176.14 90.2,177.31 89.7,177.81 89.7,178.31 89.52,178.48 89.52,178.64 89.6,178.72 89.84,178.72 89.99,178.56 90.16,178.56 90.23,178.64 90.23,178.79 90.14,178.88 L4302.4 ; 91.41,175.41 v1(91.41,175.63)
USB5_3DCAM_TEST: length 3.5
  TOP w0.102: v1(93.6,177.08) 93.6,177.45 v2(94.16,178.01)
  BOTTOM w0.102: 95.2,178.53 94.95,178.78 R4305.2 94.16,178.35 v2(94.16,178.01)
  BOTTOM w0.114: 95.2,178.53 U4301.14
USB5_3DCAM_TXN1_C: length 2.4
  BOTTOM w0.114: C4311.2 96.25,182.78 96.25,182.51 96.81,181.95 96.81,181.66 96.95,181.51 U4301.20
USB5_3DCAM_TXN1_CON: length 8.6
  TOP w0.114: CON4301.5 92.77,181.91 92.99,182.14 92.99,184.91 v2(92.73,185.18)
  BOTTOM w0.114: v2(92.73,185.18) 92.78,185.13 92.78,184.74 92.51,184.47 92.51,184.37 92.25,184.11 U4302.9 U4302.2 92.25,182.21 92,181.97 92,181.58 91.73,181.3 RN4301.1
USB5_3DCAM_TXN1_CON_C: length 4.1
  BOTTOM w0.114: L4301.3 91.7,178.79 91.91,178.58 91.91,178.11 91.6,177.8 91.6,177.56 ; 91.6,177.56 v1(91.38,177.56) ; 91.6,177.56 91.6,176.67 91.88,176.39 92.18,176.39 C4310.2
USB5_3DCAM_TXN1_Q: length 5.4
  BOTTOM w0.114: U4301.11 96.95,176.63 96.06,175.73 94.63,175.73 94.32,176.05 ; 94.32,176.05 93.98,176.39 93.47,176.39 C4310.1 ; 94.32,176.05 v1(94.16,175.89)
USB5_3DCAM_TXP1_C: length 2.4
  BOTTOM w0.114: U4301.19 96.45,181.44 96.57,181.56 96.57,181.86 96.02,182.41 96.02,182.76 C4312.2
USB5_3DCAM_TXP1_CON: length 8.7
  TOP w0.114: v2(93.44,185.2) 93.23,184.99 93.23,182.12 93.27,182.08 CON4301.6
  BOTTOM w0.114: RN4301.3 92.53,181.3 92.25,181.58 92.25,181.83 92.75,182.32 U4302.1 U4302.10 92.75,184.37 93.02,184.64 93.02,184.78 v2(93.44,185.2)
USB5_3DCAM_TXP1_CON_C: length 3.9
  BOTTOM w0.114: C4305.2 92.21,176.88 92.21,176.7 92.14,176.62 91.98,176.62 91.83,176.77 91.83,177.7 92.14,178.01 92.14,178.55 92.27,178.68 92.46,178.68 92.55,178.77 L4301.2
USB5_3DCAM_TXP1_Q: length 5.4
  BOTTOM w0.114: 95.89,175.97 95.97,175.97 96.72,176.72 96.72,176.88 96.62,176.98 96.55,176.98 96.45,177.07 U4301.12 ; 95.89,175.97 v1(95.89,176.19) ; 95.89,175.97 94.72,175.97 94.07,176.62 93.56,176.62 93.47,176.71 93.47,176.85 C4305.1
USB_CHG_CTL1: length 143.2
  TOP w0.102: v2(132.66,32) 133.06,32.4 v1(133.06,32.78) 132.66,32.78 131.58,33.86 131.58,34.62 131.28,34.92 129.72,34.92 129.52,34.72 129.52,34.54 129.17,34.2 128.79,34.2 128.46,34.52 128.05,34.52 127.82,34.75 U3001.106 ; v2(239.57,57.99) 239.31,57.72 R5202.1
  IN2 w0.102: v2(132.66,32) 133.55,31.11 145.75,31.11 145.97,31.33 159.57,31.33 159.65,31.41 163.33,31.41 166.52,28.22 169.72,28.22 170.16,27.78 183.16,27.78 183.68,27.26 190.11,27.26 191.47,28.62 191.92,28.62 192.86,27.68 195.86,27.68 196.53,28.35 198.26,28.35 198.6,28.7 198.6,29.56 199.44,30.4 203.2,30.4 204.78,31.97 206.11,31.97 207.58,33.45 208.98,33.45 209.87,34.33 211.06,34.33 212.04,35.31 212.04,39.7 214.14,41.8 214.47,41.8 214.94,42.27 214.94,42.81 215.84,43.72 216.31,43.72 217.08,44.49 217.08,47.54 217.55,48.01 217.55,48.12 219.72,50.29 219.72,54.24 220.56,55.08 221.51,55.08 223.52,57.09 223.52,58.28 224.27,59.04 225.15,59.04 226.81,60.7 228.12,60.7 230.68,58.13 239.43,58.13 v2(239.57,57.99)
USB_CHG_CTL2: length 3.6
  TOP w0.102: R5210.1 R5209.2 235.34,56.74 v1(236.29,57.68) 236.6,57.37 R5203.1
USB_CHG_CTL3: length 152.6
  TOP w0.102: v2(114.05,35.68) 114.67,35.06 115.47,35.06 116.46,34.06 116.46,32.73 118.29,30.9 118.92,30.9 119.12,30.7 U3001.81 ; R5204.1 231.78,57.37 231.09,58.06 227.59,58.06 226,56.47 224.09,56.47 222.3,58.26 220.14,58.26 219.63,58.77 219.63,59.97 219.38,60.23 219.38,60.83 218.32,61.89 v1(217.27,61.89) 217.21,61.82 214.05,61.82 v2(213.79,61.56)
  IN2 w0.102: v2(213.79,61.56) 213.79,61.04 211.51,58.76 211.51,57.49 210.4,56.39 210.4,50.79 209.18,49.57 209.18,46.19 209.37,46 209.37,43.1 207.82,41.55 206.88,41.55 203.38,38.04 194.16,38.04 193.7,37.58 184.96,37.58 184.11,36.73 168.46,36.73 167.23,37.96 159.53,37.96 158.84,37.27 147.61,37.27 146.95,36.61 139.58,36.61 139.26,36.29 124.89,36.29 123.58,34.98 116.27,34.98 115.98,35.27 114.45,35.27 v2(114.05,35.68)
USB_CHG_EN: length 153.7
  TOP w0.102: v2(133.45,32.01) 133.5,32.05 133.5,32.96 133.24,33.22 132.77,33.22 131.79,34.19 131.79,34.7 131.37,35.12 128.95,35.12 128.57,34.74 128.2,34.74 127.78,35.15 U3001.107 ; U5200.5 249.04,57.53 248.83,57.74 246.42,57.74 245.91,57.23 242.67,57.23 242.2,56.76 241.76,56.76 241.33,57.18 241.33,57.7 241.45,57.81 T5201.1 241.21,58.5 240.7,57.99 v2(240.21,57.99)
  IN2 w0.102: v2(133.45,32.01) 133.45,31.99 134.13,31.32 145.67,31.32 145.89,31.54 159.48,31.54 159.56,31.62 163.43,31.62 166.62,28.43 169.86,28.43 170.3,27.98 183.24,27.98 183.76,27.46 190.02,27.46 191.38,28.82 192.05,28.82 192.99,27.88 195.77,27.88 196.44,28.55 198.17,28.55 198.4,28.78 198.4,29.69 199.32,30.61 203.03,30.61 204.62,32.2 206.05,32.2 207.5,33.65 208.9,33.65 209.78,34.54 210.98,34.54 211.84,35.39 211.84,39.79 213.69,41.64 213.69,42.17 214.39,42.88 214.63,42.88 215.46,43.71 215.46,44.49 215.56,44.59 215.92,44.59 216.86,45.53 216.86,47.65 217.34,48.13 217.34,48.22 219.51,50.39 219.51,54.32 220.47,55.28 221.42,55.28 223.31,57.17 223.31,58.41 224.18,59.28 225.1,59.28 226.72,60.9 228.2,60.9 230.67,58.43 239.76,58.43 v2(240.21,57.99)
USB_PWEN: length 344.1
  TOP w0.102: v2(224.7,58.26) 224.7,58.02 v1(225.35,57.37) 225.38,57.4 226.59,57.4 227.45,58.27 238.29,58.27 238.51,58.49 240.63,58.49 241.15,59.01 242.3,59.01 242.9,59.61 242.9,62.92 243.26,63.27 244.25,63.27 244.91,62.61 R5501.2 245.33,62.31 U5501.4 ; U3001.80 118.72,30.52 118.54,30.7 118.12,30.7 114.59,34.23 113.41,34.23 113.06,33.88 v2(113.06,33.32) ; v2(33.33,40.61) v2(30.66,40.61)
  IN2 w0.102: v2(224.7,58.26) 224.7,57.26 221.3,53.86 221.3,49.72 219.03,47.45 219.03,45.31 218.35,44.62 218.35,39.19 218.22,39.07 218.22,38.37 217.81,37.96 217.81,37.23 217.23,36.64 214.83,36.64 211.49,33.3 210.3,33.3 208.68,31.69 208.42,31.69 204.05,27.32 196.96,27.32 196.07,26.43 183.34,26.43 182.82,26.95 169.82,26.95 169.38,27.4 166.18,27.4 163.76,29.82 162.7,29.82 162.01,30.51 146.32,30.51 146.09,30.29 133.21,30.29 132.77,30.73 122.72,30.73 122.25,30.25 114.52,30.25 112.74,32.03 112.74,33.01 v2(113.06,33.32)
  IN4 w0.102: v2(8.64,73.37) 8.64,73.38 10.01,74.75 10.01,76.01 11.3,77.31 12.62,77.31 14.58,79.26 15.69,79.26 15.89,79.47 21.13,79.47 22.66,77.94 22.66,74.9 23.04,74.52 23.04,71.72 22.3,70.99 22.3,68.32 22.74,67.89 23.11,67.89 24.03,66.97 24.03,62.63 31.45,55.21 31.45,41.39 v2(30.66,40.61) ; v2(33.33,40.61) 32.82,41.11 32.82,42 34.34,43.53 34.34,52.16 36,53.82 37.07,53.82 41.76,49.14 100.66,49.14 102.39,47.41 108.53,47.41 108.86,47.07 v2(108.86,46.77)
  BOTTOM w0.102: v2(108.86,46.77) 108.86,42.46 108.71,42.31 108.71,36.93 111.57,34.07 112.31,34.07 v2(113.06,33.32) ; CON6700.25 8.85,73.75 8.64,73.54 v2(8.64,73.37)
USBN1: length 96.1
  TOP w0.114: 244.06,58.81 243.53,58.28 242.7,58.28 242.22,57.8 242.06,57.8 v2(241.96,57.9) ; 244.06,58.81 v1(243.86,59.01) ; 244.06,58.81 244.65,59.4 250.41,59.4 250.85,58.96 250.85,58.64 251,58.49 U5200.2
  IN4 w0.089: v2(241.96,57.9) 241.56,57.5 241.35,57.5 240.07,56.22 235.54,56.22 231.35,52.03 218.11,52.03 216.62,50.54 212.54,50.54 211.4,49.41 208.18,49.41 206.53,47.75 205.02,47.75 204.69,48.07 200.65,48.07 198.94,49.77 197.18,49.77 193.31,53.65 193.31,55.04 192.78,55.56 191.77,55.56 190.84,56.49 188.81,56.49 187.27,58.03 186.74,58.03 185.69,59.07 184.53,59.07 183.5,60.11 183.5,61.32 181.94,62.88 181.81,62.88 181.46,63.24 181.46,64.35 180.97,64.84 178.33,64.84 177.85,65.32 177.37,65.32 173.25,61.2 v2(172.9,61.2)
  BOTTOM w0.114: v2(172.9,61.2) 172.54,60.84 U2000.AF5
USBN1_CHARGE: length 14.7
  TOP w0.114: U5200.11 251,54.99 250.87,54.86 250.87,54.73 252.65,52.94 252.65,52.68 253.24,52.09 ; v1(253.42,52.27) 253.24,52.09 ; 253.24,52.09 254.23,51.11 254.23,49.34 254.63,48.94 256.81,48.94 v2(256.81,48.94)
  BOTTOM w0.114: RN5501.1 255.47,45.8 255.69,46.02 255.69,48.28 256.25,48.84 256.71,48.84 v2(256.81,48.94)
USBN2: length 113.9
  IN4 w0.089: v2(246.41,72.73) 246.64,72.49 246.64,69.36 246.12,68.83 246.12,65.83 245.28,64.98 245.28,60.99 242.92,58.63 241.47,58.63 240.4,57.56 239.12,57.56 238.8,57.88 238.37,57.88 237.38,56.88 235.27,56.88 232.45,54.07 227,54.07 225.64,52.71 217.79,52.71 216.32,51.24 212.11,51.24 211.62,50.74 208.26,50.74 206.26,48.74 201.22,48.74 199.19,50.78 197.13,50.78 193.95,53.96 193.95,55.72 192.71,56.96 191.39,56.96 190.68,57.67 188.74,57.67 186.25,60.16 185.85,60.16 183.41,62.6 183.41,63.79 182.79,64.42 182.79,65.36 182.16,65.99 176.77,65.99 172.24,61.46 172.24,60.4 172.18,60.34 172.03,60.34 v2(171.76,60.61)
  BOTTOM w0.089: U2000.AD5 171.47,60.9 v2(171.76,60.61)
  BOTTOM w0.114: 251.28,73.5 251.28,73.38 251.54,73.11 251.71,73.11 251.91,72.92 251.91,72.73 251.76,72.58 251.76,72.37 251.84,72.28 L5504.4 ; 251.28,73.5 251.28,74.57 251.11,74.74 250.62,74.74 248.99,73.11 246.8,73.11 v2(246.41,72.73) ; 251.28,73.5 v1(251,73.5)
USBN3: length 204.5
  IN1 w0.089: v2(172.84,58.94) 172.64,58.74 171.5,58.74 171.25,58.99 171.25,61.28 170.66,61.87 165.89,61.87 164.2,60.18 160.54,60.18 159.64,61.08 156.69,61.08 156.18,60.57 154.57,60.57 151.28,57.28 147.85,57.28 147.48,56.92 145.27,56.92 144.65,56.3 144.65,54.92 143.33,53.6 143.33,53.37 142.02,52.06 125,52.06 124.65,52.41 116.91,52.41 116.41,51.91 109.17,51.91 108.02,50.77 103.38,50.77 101.56,48.95 74.97,48.95 74.97,48.95 74.18,48.95 66.79,48.95 64.99,47.16 61.31,47.16 60.35,48.12 54.63,48.12 54.13,47.62 51.46,47.62 50.9,48.18 49.47,48.18 48.85,47.56 38.05,47.56 37.4,48.21 30.3,48.21 29.06,49.46 29.06,54.78 27.23,56.61 27.23,57.99 21.61,63.6 13.79,63.6 9.36,68.03 8.35,68.03 7.57,68.81 7.57,73.07 9.45,74.95 9.45,79.11 9.04,79.52 8.47,79.52 v2(8.32,79.67)
  BOTTOM w0.089: 172.41,59.37 v2(172.84,58.94)
  BOTTOM w0.102: U2000.AG8 172.41,59.37
  BOTTOM w0.114: CON6700.37 8.94,79.75 8.71,79.52 8.47,79.52 v2(8.32,79.67)
USBN4: length 195.1
  IN1 w0.089: v2(170.49,64.53) 170.18,64.23 170.06,64.23 169.88,64.05 169.88,63.9 169.88,63.65 169.63,63.4 169.07,63.4 168.63,63.85 161.72,63.85 160.83,62.96 156.49,62.96 155.69,62.15 154.27,62.15 150.93,58.82 147.55,58.82 146.95,58.22 144.66,58.22 142.52,56.08 142.52,54.83 141.96,54.27 141.96,53.9 141.44,53.38 127.32,53.38 126.98,53.72 116.36,53.72 115.85,53.21 107.87,53.21 107.2,52.54 103.2,52.54 100.92,50.26 66.26,50.26 64.92,48.92 61.69,48.92 60.73,49.88 49.12,49.88 48.53,49.29 40.08,49.29 39.45,49.92 35.1,49.92 28.88,56.14 28.88,57.25 24.69,61.44 24.69,65.22 23.68,66.23 23.68,70.62 23.06,71.24 23.06,74.62 22.43,75.25 22.43,76.57 22,77 22,77.95 20.92,79.03 20.92,79.04 20.66,79.3 14.61,79.3 11.94,76.62 11.94,76.34 11.48,75.88 v7(11.06,75.88)
  BOTTOM w0.102: v2(170.49,64.53) 171.11,63.9 171.11,63.32 U2000.AE1
  BOTTOM w0.114: CON6700.28 10.51,75.25 10.77,75.51 10.77,75.59 v7(11.06,75.88)
USBN7: length 122.7
  IN4 w0.089: v2(245.14,80.05) 245.39,79.8 245.67,79.8 245.92,79.54 245.92,78.34 245.56,77.97 245.56,72.05 246.04,71.56 246.04,69.86 244.42,68.23 244.42,64.75 242.91,63.23 242.91,59.54 242.47,59.1 240.54,59.1 239.82,58.39 238.2,58.39 237.23,57.41 235.05,57.41 233.26,55.62 227.79,55.62 226.69,54.53 222.29,54.53 221.1,53.34 217.64,53.34 216.01,51.71 208.46,51.71 205.97,49.21 201.93,49.21 199.56,51.59 197.93,51.59 195.31,54.21 195.31,56.34 193.45,58.21 188.87,58.21 186.06,61.03 186.06,62.12 183.46,64.71 183.46,65.4 182.37,66.49 170.56,66.49 170.08,66.01 170.08,64.28 169.9,64.1 169.66,64.1 v2(169.47,63.91)
  BOTTOM w0.114: v2(245.14,80.05) 244.96,79.88 242.75,79.88 241.67,78.8 238.59,78.8 238.28,79.11 238.28,79.62 L5301.2 ; U2000.AB3 169.99,61.85 169.67,62.16 169.67,63.71 v2(169.47,63.91)
USBN7_C: length 9
  BOTTOM w0.114: CON5300.5 236.75,83.81 236.65,83.71 236.65,83.33 236.07,82.75 235.61,82.75 235.27,82.42 235.27,81.63 235.6,81.31 236.48,81.31 236.79,81.61 236.79,81.96 ; v1(236.54,81.96) 236.79,81.96 ; 236.79,81.96 236.79,82.12 237.27,82.6 238.02,82.6 238.28,82.34 238.28,81.95 L5301.1
USBN8: length 327.2
  TOP w0.114: v2(100.3,182.48) 100.3,182.19 100.27,182.15 CON4301.20
  IN2 w0.095: v2(204.9,45.68) 205.06,45.84 205.06,47.45 209.03,51.43 209.03,57.02 209.69,57.68 209.69,59.51 210.2,60.02 210.2,60.55 209.73,61.02 209.73,73.46 202.5,80.68 189.81,80.68 189.22,81.27 185.52,81.27 185.46,81.34 181.75,81.34 181.46,81.63 180.51,82.58 179.4,82.58 178.62,83.36 177.19,83.36 176.65,82.82 175.1,82.82 171.97,85.94 170.79,85.94 169.89,86.83 169.89,88.42 169.69,88.63 161.33,88.63 160.76,88.06 160.76,84.46 159.45,83.15 158.51,83.15 157.25,81.88 157.25,80.41 156.15,79.31 152.88,79.31 152.14,78.57 152.14,78.09 151.83,77.78 151.83,77.35 150.9,76.41 150.37,76.41 148.83,74.87 146.89,74.87 144.93,76.83 142.58,76.83 142.14,76.4 140.39,76.4 136.94,72.94 124.84,72.94 121.75,76.03 115.66,76.03 112.59,79.11 112.59,81.73 111.7,82.61 109.61,82.61 106.37,85.85 106.37,87.26 85.78,107.84 85.78,121.42 84.07,123.13 83.28,123.13 82.47,123.94 82.47,149.57 80.52,151.53 80.52,153.94 79.04,155.42 79.04,157.47 81.12,159.56 81.12,161.67 82.01,162.56 82.01,172.79 83.12,173.91 83.12,177.49 83.51,177.87 85.14,177.87 86.38,179.12 89.03,179.12 91.11,181.2 97.42,181.2 97.71,181.49 97.71,182.72 98.25,183.26 98.79,183.26 99.58,183.26 100.3,182.54 v2(100.3,182.48)
  IN4 w0.089: v2(175.15,59.64) 175.34,59.83 175.54,59.83 175.62,59.76 175.62,58.33 176.01,57.94 180.33,57.94 180.77,57.5 180.77,56.1 181.66,55.21 183.31,55.21 184.81,53.71 184.81,49.32 185.7,48.43 192.17,48.43 193.56,47.04 195.25,47.04 196.23,46.07 203.89,46.07 204.02,45.93 204.65,45.93 v2(204.9,45.68)
  BOTTOM w0.114: U2000.AL8 175.06,59.64 v2(175.15,59.64)
USBN9: length 243.5
  IN2 w0.095: v2(65.33,173.11) 65.18,173.27 65.18,174.19 65.84,174.84 74.46,174.84 75.37,175.76 77.16,175.76 78.81,174.1 78.81,166.3 77.49,164.98 77.49,161.09 75.82,159.42 75.82,150.84 79.72,146.93 79.72,122.86 83.25,119.33 83.25,107.03 104.06,86.22 104.06,84.9 107.01,81.94 107.01,79.21 108.59,77.63 108.59,73.75 109.67,72.67 109.67,64.14 112.95,60.86 121.01,60.86 121.51,60.36 130.47,60.36 131.71,61.61 132.5,61.61 133.89,63 134.55,63 135.52,63.96 135.52,66.26 137.83,68.57 137.83,70.14 140.52,72.83 149.15,72.83 149.96,73.65 153.15,73.65 155.94,76.44 156.84,76.44 157.18,76.78 157.18,77.37 v2(157.43,77.61)
  BOTTOM w0.114: L4500.1 53.86,173.98 54.16,173.67 54.16,172.09 56.47,169.79 58.6,169.79 ; v2(65.33,173.11) 65.14,172.92 65.14,172.63 64.47,171.96 62.82,171.96 62.15,171.28 60.27,171.28 58.77,169.79 58.6,169.79 ; U2000.AA1 169.3,62.86 169.3,63.31 168.19,64.41 168.19,68.41 168.88,69.1 168.88,75.28 166.3,77.87 160.65,77.87 159.76,76.98 157.41,76.98 157.24,77.15 157.24,77.43 v2(157.43,77.61) ; 58.6,169.79 v1(58.6,169.54)
USBN10: length 183.5
  IN1 w0.089: v2(174.07,59.53) 173.82,59.78 173.53,59.78 173.36,59.95 173.36,61.79 172.6,62.55 165.88,62.55 165.46,62.13 156.88,62.13 156.06,61.31 154.6,61.31 151.28,57.99 147.89,57.99 147.29,57.39 145.02,57.39 143.35,55.71 143.35,54.44 142.82,53.92 142.82,53.53 141.84,52.55 125.19,52.55 124.85,52.89 116.71,52.89 116.2,52.38 108.73,52.38 108.07,51.72 103.66,51.72 101.37,49.42 75.16,49.42 73.99,49.42 73.98,49.42 66.59,49.42 65.25,48.08 61.37,48.08 60.42,49.02 49.65,49.02 48.65,48.03 39.87,48.03 39.22,48.68 32.01,48.68 31.19,49.5 31.19,50.69 31.01,50.87 30.79,50.87 v2(30.64,50.72)
  BOTTOM w0.114: v2(30.64,50.72) 30.47,50.89 30,50.89 29.13,51.76 29.13,53.48 26.08,56.53 22.02,56.53 18.97,59.58 15.75,59.58 ; CON6700.2 10.26,62.25 10.39,62.38 10.56,62.38 11.16,61.78 13.3,61.78 15.5,59.58 15.75,59.58 ; 15.75,59.58 v1(15.75,59.3) ; U2000.AJ8 173.82,59.53 v2(174.07,59.53)
