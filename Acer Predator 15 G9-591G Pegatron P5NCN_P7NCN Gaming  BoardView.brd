# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_PCIE_TX2_N_C: length 12.6
  BOTTOM w0.089: U2000.C23 160.63,51.61 160.09,51.61 160,51.51 159.31,51.51 159.31,51.5
  BOTTOM w0.114: 159.31,51.5 157.61,51.5 156.26,50.15 156.26,49.1 154.41,47.25 154.41,45.47 153.66,44.72 C2016.2
TBT_PCIE_TX2_P: length 143.4
  TOP w0.089: 242.36,27.69 242.34,27.7 242.34,28.4 242.21,28.54 242.21,28.82 242.29,28.89 242.36,28.89 242.45,28.8 U1101.M23
  TOP w0.114: v2(243.36,21.43) 243.36,22.52 242.5,23.39 242.5,26.84 242.36,26.98 242.36,27.69
  IN4 w0.089: v2(243.36,21.43) 243.46,21.53 243.46,21.75 243.31,21.9 236.11,21.9 235.23,22.78 220.66,22.78 218.12,25.32 218.12,27.28 215.6,29.8 215.6,32.96 215.03,33.53 213.97,33.53 211.01,36.49 209.29,36.49 208.86,36.07 207.16,36.07 206.76,36.47 200.28,36.47 199.41,35.6 194.56,35.6 194.05,35.1 188.85,35.1 186.9,33.14 186.9,32.57 186.61,32.28 186.61,31.73 v2(186.8,31.54)
  BOTTOM w0.114: C2017.1 151.61,45.61 151.46,45.46 149.32,45.46 149.17,45.61 148.56,45.61 147.9,44.94 147.9,34.95 151.93,30.91 154.02,30.91 155.48,29.45 155.67,29.45 155.68,29.45 160.35,29.45 161.36,28.44 161.36,27.4 ; 161.36,27.4 161.36,25.52 163.44,23.44 181.72,23.44 183.37,25.09 183.37,27.95 184.51,29.09 184.96,29.09 186.56,30.7 186.56,31.3 v2(186.8,31.54) ; 161.36,27.4 v1(161.09,27.4)
TBT_PCIE_TX2_P_C: length 12.9
  BOTTOM w0.089: 159.31,51.74 159.34,51.71 159.93,51.71 160.01,51.8 160.31,51.8 U2000.B23
  BOTTOM w0.114: 154.17,45.99 154.17,47.35 156.03,49.2 156.03,50.25 157.52,51.74 159.31,51.74 ; 154.17,45.99 154.17,45.57 153.56,44.95 153.34,44.95 153.26,45.03 153.26,45.53 153.19,45.61 C2017.2 ; 154.17,45.99 v1(153.92,45.99)
TBT_PCIE_TX3_N: length 136.3
  TOP w0.089: U1101.H22 244.52,28.92 244.52,28.46 244.39,28.34 244.39,27.84 244.4,27.82
  TOP w0.114: 244.4,27.82 244.4,27.72 245.32,26.8 245.32,21.79 v2(245.55,21.56)
  IN4 w0.089: v2(185.13,32.52) 185.35,32.75 185.35,33.2 188.18,36.03 193.83,36.03 195.1,37.3 196.32,37.3 196.72,36.9 199.36,36.9 200.13,37.66 211.46,37.66 214.45,34.67 216.51,34.67 217.7,33.48 219.09,33.48 219.55,33.02 220.35,33.02 223.45,29.91 226.98,29.91 230.26,26.64 231.78,26.64 232.49,25.92 233.48,25.92 236.74,22.66 244.83,22.66 245.14,22.35 245.14,21.95 245.34,21.75 245.36,21.75 v2(245.55,21.56)
  BOTTOM w0.114: v2(185.13,32.52) 185.48,32.17 185.48,31.33 180.72,26.57 178.09,26.57 177.71,26.18 177.71,25.39 176.65,24.33 163.92,24.33 162.74,25.51 162.74,27.91 ; v1(162.99,27.91) 162.74,27.91 ; 162.74,27.91 162.74,28.54 160.6,30.68 155.6,30.68 154.48,31.8 152.34,31.8 148.82,35.32 148.82,36.31 149.33,36.82 149.33,42.66 148.82,43.17 148.82,43.84 149,44.02 149.33,44.02 149.41,43.94 149.41,43.77 C2018.1
TBT_PCIE_TX3_N_C: length 15.4
  BOTTOM w0.114: 151.82,43.91 151.56,43.91 151.33,43.67 151,43.67 150.9,43.58 C2018.2 ; 151.82,43.91 v1(151.82,43.65) ; 151.82,43.91 153.7,43.91 155,45.21 155,47.03 156.79,48.83 156.79,49.94 157.87,51.02 160.4,51.02 U2000.C24
TBT_PCIE_TX3_P: length 136.4
  TOP w0.089: 244.17,27.82 244.18,27.84 244.18,28.39 244.06,28.51 244.06,28.82 244.12,28.88 244.25,28.88 244.29,28.84 U1101.H23
  TOP w0.114: v2(244.91,21.58) 245.09,21.76 245.09,26.71 244.17,27.63 244.17,27.82
  IN4 w0.089: v2(185.74,32.52) 185.53,32.73 185.53,33.13 188.26,35.86 193.9,35.86 195.17,37.13 196.24,37.13 196.65,36.72 199.44,36.72 200.2,37.48 211.39,37.48 214.38,34.49 216.43,34.49 217.63,33.3 219.01,33.3 219.47,32.84 220.27,32.84 223.38,29.74 226.91,29.74 230.19,26.46 231.7,26.46 232.42,25.75 233.41,25.75 236.67,22.48 244.75,22.48 244.96,22.28 244.96,21.63 v2(244.91,21.58)
  BOTTOM w0.114: 162.5,25.87 162.5,25.41 163.82,24.1 176.75,24.1 177.94,25.29 177.94,26.08 178.19,26.33 180.82,26.33 185.72,31.23 185.72,32.49 v2(185.74,32.52) ; 162.5,25.87 v1(162.23,25.87) ; 162.5,25.87 162.5,28.44 160.51,30.44 155.51,30.44 154.38,31.56 152.24,31.56 148.58,35.22 148.58,36.41 149.09,36.92 149.09,42.57 148.58,43.07 148.58,43.94 148.9,44.26 149.4,44.26 C2019.1
TBT_PCIE_TX3_P_C: length 15.2
  BOTTOM w0.114: U2000.B24 160.12,51.26 157.77,51.26 156.56,50.04 156.56,48.92 154.76,47.13 154.76,45.31 153.6,44.14 151.46,44.14 151.23,43.91 150.93,43.91 150.88,43.97 150.88,44.16 150.99,44.27 150.99,44.39 150.92,44.46 C2019.2
TBT_PCIE_WAKE_N: length 73.7
  TOP w0.102: v1(193.73,41.98) 194.03,42.28 195.1,42.28 v2(195.45,41.93) ; U1101.W1 239.23,39.9 238.59,40.53 237.81,40.53 v2(237.45,40.89)
  IN1 w0.102: v2(192.61,58.82) 192.71,58.82 194.31,57.22 194.31,52.41 196.06,50.66 196.06,43.65 195.45,43.05 v2(195.45,41.93)
  IN4 w0.102: v2(237.45,40.89) 236.62,41.73 236.62,41.91 233.2,45.32 232.98,45.32 232.53,45.77 232.53,45.9 232.13,46.31 218.28,46.31 217.69,45.71 215.49,45.71 214.78,45 209.51,45 208.48,43.98 208.48,43.37 208.25,43.13 207.66,43.13 207.24,43.55 203.21,43.55 202.73,44.03 197.56,44.03 v2(195.45,41.93)
  BOTTOM w0.102: v2(192.61,58.82) 192.33,58.82 R2443.1 ; v2(237.45,40.89) 236.7,41.64 R1138.1
TBT_RBIAS: length 1.5
  TOP w0.102: U1101.H6 244.42,36.35 244.71,36.05 v4(244.71,36.05)
  BOTTOM w0.102: R1107.2 245.04,36.32 244.98,36.32 v4(244.71,36.05)
TBT_REFCLK_100_N: length 123.6
  TOP w0.114: 164.64,69 164.64,66.64 R2528.2 ; 164.64,69 164.64,71.39 166.53,73.27 169.64,73.27 169.93,72.99 169.93,72.57 v2(170.02,72.47) ; 164.64,69 v1(164.39,69) ; U1101.T19 240.17,30.82 v4(240.17,30.82)
  IN1 w0.089: v2(170.02,72.47) 170.02,72.76 172.14,74.88 176.27,74.88 177.34,73.8 183.1,73.8 184.18,74.88 186.5,74.88 187.39,73.99 188.28,73.99 189.05,74.75 211.66,74.75 215.19,71.23 215.19,65.93 216.56,64.56 219.43,64.56 220.62,63.37 220.62,57.91 221.13,57.4 221.13,47.6 227.97,40.77 227.97,39.22 229.48,37.71 229.48,34.17 229.95,33.69 231.39,33.69 231.79,33.29 231.79,29.74 232.46,29.07 234.64,29.07 235.98,30.41 237.37,30.41 238.42,29.37 239.6,29.37 240.13,29.9 240.13,30.45 240.17,30.49 v4(240.17,30.82)
TBT_REFCLK_100_N_R: length 7.4
  TOP w0.114: 164.66,64.41 164.66,62.6 164.32,62.25 163.3,62.25 163.15,62.4 162.3,62.4 162.06,62.16 162.06,61.87 v2(161.85,61.66) ; 164.66,64.41 v1(164.41,64.41) ; 164.66,64.41 164.66,65.15 R2528.1
  BOTTOM w0.114: U2000.E5 161.85,61.66 v2(161.85,61.66)
TBT_REFCLK_100_P: length 123.6
  TOP w0.114: 164.88,70.58 v1(165.12,70.58) ; 164.88,70.58 164.88,71.29 166.62,73.04 169.55,73.04 169.69,72.89 169.69,72.78 v2(169.39,72.47) ; 164.88,70.58 164.88,66.68 R2527.2 ; v4(239.52,30.82) 239.67,30.82 239.85,30.65 U1101.V19
  IN1 w0.089: v2(169.39,72.47) 169.8,72.89 169.9,72.89 172.07,75.05 176.34,75.05 177.42,73.98 183.03,73.98 184.1,75.05 186.58,75.05 187.47,74.16 188.21,74.16 188.98,74.93 211.73,74.93 215.37,71.3 215.37,66.01 216.64,64.74 219.51,64.74 220.8,63.45 220.8,57.99 221.31,57.48 221.31,47.68 228.14,40.84 228.14,39.29 229.65,37.78 229.65,34.24 230.03,33.87 231.46,33.87 231.96,33.37 231.96,29.82 232.53,29.25 234.57,29.25 235.91,30.59 237.45,30.59 238.49,29.55 239.53,29.55 239.95,29.97 239.95,30.47 239.9,30.52 239.58,30.52 239.52,30.58 v4(239.52,30.82)
TBT_REFCLK_100_P_R: length 7.3
  TOP w0.114: 164.03,62.02 164.41,62.02 164.9,62.5 164.9,65.14 R2527.1 ; 164.03,62.02 v1(164.03,61.79) ; 164.03,62.02 163.2,62.02 163.05,62.17 162.4,62.17 162.29,62.06 162.29,61.87 v2(162.5,61.66)
  BOTTOM w0.114: v2(162.5,61.66) 162.8,61.36 U2000.G4
TBT_RESET_N: length 11.9
  TOP w0.102: U1201.F11 242.14,53.85 v2(242.14,54.27)
  BOTTOM w0.102: v2(242.14,54.27) 241.91,54.27 240.7,55.49 236.47,55.49 235.08,54.1 R1162.2 232.48,54.1 v1(232.14,53.76)
TBT_RSENSE: length 1
  TOP w0.102: U1101.J6 243.75,36.36 244.06,36.67 v4(244.07,36.67)
  BOTTOM w0.102: R1107.1 244.15,36.75 v4(244.07,36.67)
TBT_SLP_S3_N: length 25.4
  TOP w0.102: U1101.D2 245.89,38.59 245.89,38.95 245.91,38.98 245.91,43.39 245.33,43.97 242.61,43.97 242,44.59 241.66,44.59 241.43,44.82 240.64,44.82 240.23,45.23 237.22,45.23 237.12,45.14 233.32,45.14 233.1,45.37 232.91,45.37 232.48,45.8 232.48,46.28 232.25,46.51 231.43,46.51 R1131.1 231.37,47.03 ; 231.37,47.03 230.07,47.03 229.74,47.36 229.74,48.51 v1(229.79,48.56) ; 231.37,47.03 R1153.1
TBT_SNK0_DDC_AUXN: length 5.7
  TOP w0.114: U1101.W11 239.2,34.38 v4(239.5,34.08)
  BOTTOM w0.114: 236.04,35.26 237.25,35.26 237.81,34.7 238.83,34.7 239.26,34.27 239.31,34.27 v4(239.5,34.08) ; 236.04,35.26 235.35,35.26 C1190.2 ; 236.04,35.26 v1(236.04,35.53)
TBT_SNK0_DDC_AUXP: length 5.7
  TOP w0.102: U1101.Y11 238.39,34.4 238.33,34.33 238.33,34.18 238.43,34.08 v4(238.89,34.08)
  BOTTOM w0.114: v1(238.13,34.21) 238.13,34.46 ; 238.13,34.46 237.71,34.46 237.41,34.76 237.15,35.02 235.44,35.02 C1189.2 ; 238.13,34.46 238.73,34.46 238.89,34.31 v4(238.89,34.08)
TBT_SNK0_DDC_CLK: length 12
  TOP w0.114: U1101.Y5 238.67,37 238.89,36.78 v4(238.89,36.7)
  IN1 w0.089: v4(238.89,36.7) 237.88,37.71 235.44,37.71 235.31,37.84 235.31,38.47 235.18,38.6 234.8,38.6 234.67,38.47 234.67,37.58 234.54,37.46 234.19,37.46 234.06,37.58 234.06,38.94 v2(234.05,38.96)
  BOTTOM w0.114: v1(238.73,38.24) 238.43,37.94 238.43,37.15 v4(238.89,36.7) ; R1109.1 v2(234.05,38.96) R1148.2
TBT_SNK0_DDC_DATA: length 11.2
  TOP w0.114: U1101.R4 241.26,37.54 241.26,37.5 v4(241.43,37.32)
  IN1 w0.089: v2(234.06,39.8) 234.84,39.8 236.34,38.3 237.74,38.3 237.74,38.31 239.66,38.31 240.28,37.69 240.37,37.69 240.73,37.32 v4(241.43,37.32)
  BOTTOM w0.114: R1149.2 234.02,39.84 v2(234.06,39.8) 234.1,39.84 R1110.1 234.7,40.68 v1(234.87,40.86)
TBT_SNK1_DDC_CLK: length 7.8
  TOP w0.102: U1101.Y8 238.55,35.7 v4(238.87,35.37)
  BOTTOM w0.102: v4(238.87,35.37) 238.74,35.37 238.22,35.89 237.26,35.89 237.04,36.11 236.55,36.11 236.32,36.34 236.32,36.75 236.96,37.38 236.96,37.84 236.86,37.94 R1143.1 236.58,37.84 236.07,37.33 v1(234.72,37.33)
TBT_SNK1_DDC_DATA: length 16.4
  TOP w0.102: U1101.N4 242.08,37.36 v4(242.08,37.32)
  IN4 w0.102: v2(232.72,43.02) 233.49,42.24 234.15,42.24 237.41,38.98 239.82,38.98 241.1,37.71 241.7,37.71 v4(242.08,37.32)
  BOTTOM w0.102: v2(232.72,43.02) 232.16,43.57 230.93,43.57 v1(230.61,43.25) 230.28,43.57 229.8,43.57 229.53,43.84 R1144.1
TBT_SRC_HPD: length 49.6
  TOP w0.102: U1101.G1 244.75,39.05 244.88,39.19 244.88,41.4 243.9,42.38 242.96,42.38 241.82,43.53 R1147.1 240.97,43.96 240.07,43.96 v2(239.9,44.14) ; v2(244.78,76.42) 244.48,76.72 R4816.1 R4800.2 243.56,78.63 v1(243.56,78.63)
  IN1 w0.102: v2(239.9,44.14) 241.39,44.14 242.55,45.3 242.57,45.3 243.56,46.28 243.56,46.56 244.54,47.54 244.54,54.16 246.61,56.23 246.61,63.38 247.62,64.39 247.62,73.45 244.78,76.29 v2(244.78,76.42)
TBT_SRC_ML0_N: length 69.9
  TOP w0.089: 241.1,39.68 241.16,39.62 241.16,39.16 241.29,39.04 241.29,38.68 241.22,38.61 241.11,38.61 241.07,38.65 U1101.R1
  TOP w0.102: v4(240.84,41.88) 240.69,41.72 240.69,41.27 240.84,41.11 240.71,40.98 240.71,40.07 241.1,39.68 ; C4805.1 250.06,100.22 249.94,100.35 249.58,100.35 v2(249.35,100.12)
  IN4 w0.089: v2(249.35,100.12) 249.35,100.14 248.95,100.54 248.85,100.54 247.94,99.63 247.94,96.42 248.09,96.27 248.09,90.2 246.96,89.06 246.96,81.34 247.81,80.49 247.81,76.24 248.67,75.39 248.67,58.24 246.11,55.68 246.11,53.42 244.56,51.87 244.56,47.77 244.03,47.24 243.37,47.24 240.7,44.58 240.7,42.02 v4(240.84,41.88)
TBT_SRC_ML0_P: length 69.9
  TOP w0.089: U1101.R2 241.01,38.35 240.83,38.53 240.83,38.99 240.97,39.13 240.97,39.49 240.93,39.54
  TOP w0.102: v2(249.35,100.76) 249.53,100.58 249.79,100.58 C4804.1 ; 240.93,39.54 240.48,39.98 240.48,40.97 C1193.2 240.46,41.24 240.46,41.75 v4(240.34,41.88)
  IN4 w0.089: v4(240.34,41.88) 240.49,42.03 240.49,44.67 243.28,47.46 243.94,47.46 244.34,47.86 244.34,51.96 245.89,53.51 245.89,55.77 248.45,58.33 248.45,75.3 247.59,76.15 247.59,80.4 246.74,81.25 246.74,89.15 247.88,90.29 247.88,96.18 247.73,96.33 247.73,99.72 248.76,100.76 v2(249.35,100.76)
TBT_SRC_ML1_N: length 68
  TOP w0.089: U1101.N1 241.99,38.67 242.04,38.62 242.11,38.62 242.21,38.72 242.21,39.03 242.08,39.16 242.08,39.63 242.11,39.66
  TOP w0.102: v2(249.35,97.64) 249.66,97.94 249.9,97.94 250.06,97.78 C4803.1 ; 242.11,39.66 C1194.1 v4(242.11,40.61)
  IN4 w0.089: v4(242.11,40.61) 241.99,40.73 241.98,40.73 241.95,40.77 241.95,43.04 243.49,44.58 243.49,44.89 245.7,47.1 245.7,51.58 247.69,53.57 248.79,53.57 249.49,54.27 249.49,76.77 248.69,77.56 248.69,78.32 248.8,78.43 249.14,78.43 249.45,78.74 249.45,79.52 248.69,80.28 248.69,80.76 247.78,81.67 247.78,88.71 248.33,89.26 248.85,89.26 249.21,89.62 249.21,96.25 248.9,96.56 248.9,97.96 248.96,98.03 249,98.03 249.35,97.67 v2(249.35,97.64)
TBT_SRC_ML1_P: length 68
  TOP w0.089: U1101.N2 241.76,38.57 241.76,39.02 241.89,39.14 241.89,39.54 241.85,39.58
  TOP w0.102: v2(249.35,98.31) 249.49,98.17 249.83,98.17 250.05,98.39 C4802.1 ; 241.85,39.58 241.61,39.82 C1194.2 v4(241.61,40.61)
  IN4 w0.089: v2(249.35,98.31) 249.28,98.24 248.87,98.24 248.68,98.05 248.68,96.47 248.99,96.16 248.99,89.71 248.76,89.47 248.24,89.47 247.56,88.8 247.56,81.58 248.48,80.67 248.48,80.19 249.23,79.43 249.23,78.83 249.05,78.64 248.71,78.64 248.48,78.41 248.48,77.47 249.27,76.68 249.27,54.36 248.7,53.79 247.6,53.79 245.49,51.67 245.49,47.19 243.27,44.98 243.27,44.67 241.73,43.13 241.73,40.73 v4(241.61,40.61)
TBT_SRC_ML2_N: length 64.5
  TOP w0.089: 242.97,39.62 242.97,39.61 243,39.58 243,39.11 243.14,38.97 243.14,38.71 243.04,38.62 242.97,38.62 242.91,38.68 U1101.L1
  TOP w0.102: 242.97,39.62 242.97,40.93 243.13,41.09 C1195.1 v4(243.13,41.62) ; v2(249.15,87.21) 249.34,87.41 249.62,87.41 249.94,87.09 C4801.1
  IN4 w0.089: v4(243.13,41.62) 243.37,41.86 243.37,41.92 243.3,41.98 242.88,41.98 242.84,42.02 242.84,42.35 243,42.51 244.09,42.51 244.75,43.17 244.75,44.83 246.81,46.9 246.81,51.49 247.96,52.64 249.1,52.64 250.66,54.19 250.66,79.59 250.88,79.82 251.26,79.82 251.53,80.08 251.53,80.86 251.29,81.09 249.91,81.09 248.59,82.41 248.59,84.12 248.68,84.2 251.6,84.2 251.86,84.46 251.86,84.98 251.6,85.23 248.68,85.23 248.59,85.32 248.59,87.08 248.84,87.33 249.03,87.33 v2(249.15,87.21)
TBT_SRC_ML2_P: length 64.5
  TOP w0.089: U1101.L2 242.68,38.57 242.68,39.02 242.81,39.15 242.81,39.5 242.74,39.57
  TOP w0.102: v2(249.15,87.87) 249.38,87.64 249.74,87.64 249.94,87.84 C4800.1 ; 242.74,39.57 242.74,41 C1195.2 v4(242.62,41.62)
  IN4 w0.089: v2(249.15,87.87) 248.82,87.55 248.76,87.55 248.37,87.17 248.37,85.23 248.59,85.02 251.51,85.02 251.64,84.89 251.64,84.55 251.51,84.42 248.59,84.42 248.37,84.21 248.37,82.32 249.82,80.87 251.2,80.87 251.31,80.77 251.31,80.17 251.18,80.03 250.79,80.03 250.44,79.68 250.44,54.28 249.01,52.85 247.87,52.85 246.6,51.58 246.6,46.99 244.53,44.92 244.53,43.26 244,42.73 242.91,42.73 242.62,42.44 v4(242.62,41.62)
TBT_SRC_ML3_N: length 64.4
  TOP w0.089: U1101.J1 243.83,38.68 243.87,38.64 243.98,38.64 244.05,38.71 244.05,39.01 243.93,39.13 243.93,39.57 244.02,39.65
  TOP w0.102: C4808.1 249.68,84.42 249.4,84.42 249.28,84.29 249.28,83.88 249.69,83.47 250.16,83.47 v2(250.57,83.06) ; v4(244.15,40.86) 244.02,40.74 244.02,40.22 C1196.1 244.02,39.97 244.02,39.65
  IN4 w0.089: v4(244.15,40.86) 243.97,41.03 243.97,41.19 245.64,42.86 245.64,44.57 249.25,48.18 249.25,51.59 251.84,54.17 251.84,67.3 251.75,67.39 251.75,68.51 252.04,68.79 252.04,69.61 252.13,69.69 253.3,69.69 253.52,69.91 253.52,70.51 253.3,70.72 252.13,70.72 252.04,70.81 252.04,71.23 252.13,71.32 253.35,71.32 253.57,71.53 253.57,72.13 253.35,72.35 252.13,72.35 252.04,72.44 252.04,77.97 252.25,78.18 255.03,78.18 255.28,78.43 255.28,81.78 255.03,82.03 250.59,82.03 250.25,82.37 250.25,82.71 250.57,83.02 v2(250.57,83.06)
TBT_SRC_ML3_P: length 64.5
  TOP w0.089: U1101.J2 243.6,38.57 243.6,39.02 243.74,39.15 243.74,39.64 243.79,39.69 243.79,39.7
  TOP w0.102: v2(249.94,83.06) 249.76,83.24 249.59,83.24 249.05,83.79 249.05,84.39 249.31,84.65 249.57,84.65 249.94,85.02 C4807.1 ; 243.79,39.7 243.79,39.95 243.64,40.1 243.64,40.1 243.79,40.25 243.79,40.71 v4(243.64,40.86)
  IN4 w0.089: v2(249.94,83.06) 250.04,82.96 250.04,82.28 250.5,81.82 254.94,81.82 255.06,81.69 255.06,78.52 254.94,78.4 252.16,78.4 251.82,78.06 251.82,72.35 252.04,72.13 253.26,72.13 253.35,72.04 253.35,71.62 253.26,71.54 252.04,71.54 251.82,71.32 251.82,70.72 252.04,70.51 253.21,70.51 253.3,70.42 253.3,70 253.21,69.91 252.04,69.91 251.82,69.7 251.82,68.88 251.54,68.6 251.54,67.3 251.62,67.21 251.62,54.26 249.03,51.68 249.03,48.27 245.43,44.66 245.43,42.95 243.76,41.28 243.76,40.98 v4(243.64,40.86)
TBT_TCK: length 17.9
  TOP w0.102: U1101.T4 240.48,37.65 v4(240.16,37.33)
  IN4 w0.102: v2(229.79,42.33) 229.79,42.26 231.19,40.86 234.49,40.86 235.24,40.11 235.24,38.95 236.29,37.9 237.56,37.9 237.97,38.3 239.67,38.3 240.16,37.81 v4(240.16,37.33)
  BOTTOM w0.102: T1103.1 228.09,43.22 228.98,42.33 v2(229.79,42.33) 229.87,42.26 R1114.2
TBT_TDI: length 8.6
  TOP w0.102: v4(238.86,37.31) 238.86,37.31 238.55,37.63 U1101.Y4
  BOTTOM w0.102: R1112.2 234.11,40.99 234.49,41.37 235.1,41.37 T1101.1 237.11,39.36 238.4,39.36 239.17,38.6 239.17,37.62 v4(238.86,37.31)
TBT_TDO: length 15
  TOP w0.102: v4(239.52,37.95) 239.22,37.65 U1101.W4
  IN4 w0.102: v2(228.86,41.03) 228.92,40.97 230.28,40.97 230.65,40.61 234.37,40.61 234.97,40 234.97,38.93 236.2,37.69 237.87,37.69 238.12,37.95 v4(239.52,37.95)
  BOTTOM w0.102: v2(228.86,41.03) 229.21,41.03 T1104.1 229.55,41.37 R1115.2
TBT_TEST_EN: length 20.2
  TOP w0.102: U1101.E1 245.71,38.85 245.71,43.13 245.07,43.77 242.51,43.77 241.89,44.38 241.56,44.38 241.34,44.61 240.57,44.61 240.15,45.03 239.32,45.03 239.22,44.92 234.23,44.92 v1(233.91,44.6) 233.54,44.6 233.29,44.85 232.03,44.85 231.37,45.51 R1128.1
TBT_TEST_PWG: length 7.2
  TOP w0.102: R1129.1 231.8,39.51 v1(232.69,39.51) 232.84,39.51 233.81,38.54 235.17,38.54 236.31,37.41 236.6,37.41 236.82,37.19 237.62,37.19 U1101.AB5
TBT_TMS: length 16.8
  TOP w0.102: v4(239.52,37.33) 239.52,37.33 U1101.V4
  IN4 w0.102: v4(239.52,37.33) 239.13,37.72 238.42,37.72 238.19,37.49 235.99,37.49 235.05,38.43 233.83,38.43 231.92,40.34 230.49,40.34 230.09,40.73 229.16,40.73 v2(228.78,40.35)
  BOTTOM w0.102: R1113.2 228.91,40.48 v2(228.78,40.35) 228.45,40.68 228.45,41.54 T1102.1
TBT_TMU_CLK_OUT: length 7.5
  TOP w0.089: 237.26,41.3 237.04,41.52
  TOP w0.102: U1101.V2 239.46,38.58 239.46,39.94 239.26,40.13 239.26,40.18 238.63,40.81 238.11,40.81 237.62,41.3 237.26,41.3 ; R1139.1 236.31,43.13 v1(236.63,42.82) 236.96,42.49 236.96,41.6 237.04,41.52
TBT_XTAL_25_IN: length 9.8
  TOP w0.102: 246.58,28.24 246.35,28.46 246.35,28.92 U1101.D22
  TOP w0.114: 246.58,28.24 248.28,26.54 248.92,26.54 249.28,26.18 249.59,26.18 250.02,25.75 C1130.1 251.09,25.49 X1101.1 252.41,24.14 v1(252.7,23.84)
TBT_XTAL_25_OUT: length 10
  TOP w0.102: 246.29,28.03 246.13,28.2 U1101.D23
  TOP w0.114: 246.29,28.03 248.15,26.18 248.66,26.18 249.1,25.75 C1131.1 249.82,25.07 249.82,23.37 248.99,22.53 X1101.3 248.89,21.53 248.84,21.49 v1(248.84,21.05)
TBTA_AUX_N: length 6
  TOP w0.102: v4(239.52,32.12) 239.2,32.45 U1101.W15
  BOTTOM w0.114: 235.86,31.97 236.09,32.19 237.12,32.19 237.83,31.48 239.01,31.48 239.27,31.74 239.27,31.87 v4(239.52,32.12) ; 235.86,31.97 v1(236.04,31.79) ; 235.86,31.97 235.51,31.62 235.21,31.62 C1136.2
TBTA_AUX_P: length 6
  TOP w0.102: U1101.Y15 238.71,32.45 238.87,32.29 v4(238.87,32.12)
  BOTTOM w0.114: v1(237.67,32.33) 237.49,32.15 ; 237.49,32.15 237.92,31.72 238.92,31.72 239.04,31.84 239.04,31.95 v4(238.87,32.12) ; 237.49,32.15 237.21,32.43 235.99,32.43 235.41,31.85 235.21,31.85 235.11,31.95 C1137.2
TBTA_CA2HD_0_N_CON: length 23.9
  TOP w0.089: U1101.A21 247.42,29.7 247.42,29.78 247.49,29.85 247.79,29.85 247.92,29.72 248.55,29.72 248.59,29.76 248.62,29.76
  TOP w0.102: 248.62,29.76 249.3,29.76 arc(249.54,29.74) 249.78,29.68 arc(250.11,29.53) 250.4,29.3 252.83,26.87 arc(252.99,26.77) 253.17,26.73 v2(253.37,26.73)
  BOTTOM w0.102: v2(253.37,26.73) 253.37,26.36 arc(253.41,26.19) 253.5,26.05 253.56,25.99 253.86,25.7 254.37,25.18 arc(255.59,24.36) 257.04,24.08 261.62,24.08 arc(261.72,24.1) 261.8,24.15 D1204.1 262.19,24.27 arc(262.35,24.16) 262.53,24.13 267.88,24.13 arc(268.11,24.22) CON1201.B10
TBTA_CA2HD_0_P_CON: length 23.9
  TOP w0.089: 248.62,29.53 247.87,29.53 247.73,29.39 247.27,29.39 U1101.B21
  TOP w0.102: 248.62,29.53 249.3,29.53 arc(249.51,29.51) 249.71,29.46 arc(250,29.33) 250.24,29.14 252.8,26.58 arc(252.89,26.44) v2(252.93,26.28)
  BOTTOM w0.102: v2(252.93,26.28) 252.93,26.28 252.95,26.28 254.21,25.02 arc(255.51,24.15) 257.04,23.85 261.55,23.85 arc(261.64,23.84) 261.72,23.82 arc(261.8,23.77) 261.87,23.71 D1203.1 262.29,23.77 arc(262.43,23.86) 262.6,23.9 267.95,23.9 arc(268.13,23.83) CON1201.B11
TBTA_CA2HD_1_N_CON: length 22.1
  TOP w0.089: U1101.B15 247.27,32.15 247.73,32.15 247.87,32.29 248.45,32.29 arc(248.65,32.33) 248.83,32.45 248.85,32.45
  TOP w0.102: 248.85,32.45 249.4,33 249.4,33 arc(249.45,33.04) 249.5,33.08 arc(249.8,33.25) 250.15,33.31 254.58,33.31 arc(255.82,33.06) 256.88,32.36 257.62,31.61 261.02,28.21 arc(261.34,27.99) 261.7,27.9 arc(261.74,27.9) 261.78,27.9 D1208.1 262.26,27.83 262.29,27.86 arc(262.39,27.93) 262.51,27.95 265.76,27.95 265.91,27.8 CON1201.A10
TBTA_CA2HD_1_P_CON: length 22.1
  TOP w0.089: U1101.A15 247.36,32.37 247.32,32.4 247.32,32.53 247.39,32.59 247.74,32.59 247.86,32.48 248.45,32.48 arc(248.58,32.51) 248.69,32.58 248.69,32.58 248.68,32.6 248.69,32.62
  TOP w0.102: CON1201.A11 265.88,28.3 265.76,28.18 262.47,28.18 arc(262.34,28.2) 262.24,28.28 D1207.1 261.72,28.13 arc(261.43,28.2) 261.19,28.37 257.78,31.78 257.04,32.52 arc(255.91,33.27) 254.58,33.54 250.15,33.54 arc(249.73,33.47) 249.36,33.26 arc(249.3,33.21) 249.24,33.16 248.69,32.62
TBTA_DPSRC_AUX_N: length 37.1
  TOP w0.076: v2(243.92,48.05) 243.74,48.23 243.74,48.94 U1201.J2
  IN1 w0.089: v2(243.92,48.05) 243.67,47.81 243.67,47.58 243.38,47.29 242.9,47.29 241.53,48.66 240.41,48.66 239.64,49.43 239.64,50.44 239.14,50.95 235.88,50.95 234.8,49.87 234.8,42.29 233.36,40.86 233.36,37.34 233.99,36.72 233.99,29.99 v2(234.05,29.93)
  BOTTOM w0.114: C1136.1 234.34,31.77 234.17,31.77 233.99,31.59 233.99,30.96 R1155.1 234.08,30.7 233.88,30.5 233.88,30.09 v2(234.05,29.93)
TBTA_DPSRC_AUX_P: length 37.2
  TOP w0.076: v2(243.31,48.07) 243.33,48.07 243.54,48.28 243.54,48.64 U1201.J1
  IN1 w0.089: v2(243.31,48.07) 243.49,47.89 243.49,47.66 243.3,47.46 242.98,47.46 241.61,48.84 240.48,48.84 239.82,49.5 239.82,50.52 239.21,51.13 235.8,51.13 234.62,49.94 234.62,42.37 233.18,40.93 233.18,37.27 233.81,36.64 233.81,30.27 233.57,30.03 233.57,30.02 v2(233.41,29.87)
  BOTTOM w0.114: v2(233.41,29.87) 233.65,30.1 233.65,30.41 R1154.1 233.75,31.1 233.75,31.68 234.07,32.01 234.38,32.01 C1137.1
TBTA_HD2CA_0_N_CON: length 17.1
  TOP w0.102: C1135.2 251.94,30.34 arc(252.01,30.3) 252.09,30.28 252.39,30.28 arc(253.38,30.08) 254.21,29.53 258.02,25.72 arc(259.73,24.57) 261.75,24.17 D1201.1 262.27,24.25 arc(262.39,24.17) 262.53,24.14 265.73,24.14 265.89,24.3 CON1201.A3
TBTA_HD2CA_0_P_CON: length 17.1
  TOP w0.102: C1134.2 251.96,29.99 arc(252.03,30.03) 252.11,30.05 252.39,30.05 arc(253.29,29.87) 254.05,29.36 257.86,25.55 arc(259.64,24.36) 261.75,23.94 arc(261.76,23.94) 261.78,23.94 261.81,23.94 262.05,23.7 D1202.1 262.23,23.82 arc(262.34,23.89) 262.47,23.91 265.81,23.91 265.92,23.8 CON1201.A2
TBTA_HD2CA_1_N_CON: length 18.3
  TOP w0.102: C1133.2 arc(251.82,31.46) 251.95,31.51 254.49,31.51 arc(254.67,31.44) v2(254.74,31.26)
  BOTTOM w0.102: CON1201.B3 267.98,27.87 arc(267.91,27.92) 267.83,27.93 264.63,27.93 arc(264.53,27.91) 264.44,27.86 D1205.1 arc(264.09,27.83) 263.85,27.93 263.1,27.93 arc(262.3,28.09) 261.61,28.55 260.41,29.75 arc(258.54,31) 256.33,31.44 254.93,31.44 arc(254.8,31.39) v2(254.74,31.26)
TBTA_HD2CA_1_P_CON: length 18.3
  TOP w0.102: C1132.2 arc(251.86,31.83) 252.07,31.74 254.59,31.74 arc(254.7,31.79) v2(254.74,31.89)
  BOTTOM w0.102: CON1201.B2 267.99,28.24 arc(267.9,28.18) 267.8,28.16 264.67,28.16 arc(264.51,28.19) 264.37,28.29 D1206.1 arc(264.1,28.25) 263.88,28.16 263.1,28.16 arc(262.38,28.3) 261.77,28.71 260.57,29.92 arc(258.62,31.22) 256.33,31.67 254.96,31.67 arc(254.81,31.74) v2(254.74,31.89)
TBTA_HPD: length 23.3
  TOP w0.076: U1201.C10 240.49,53.03 v4(240.72,52.8)
  TOP w0.102: v1(229.78,50.86) 229.78,49.94 v2(229.63,49.79)
  IN4 w0.102: v4(240.72,52.8) 240.72,52.29 240.84,52.16 240.84,51.08 240.61,50.84 240.05,50.84 239.59,51.31 237.66,51.31 237.16,50.81 237.16,49.13 237.08,49.05 233.11,49.05 232.37,49.79 v2(229.63,49.79)
  BOTTOM w0.102: R1121.1 230.51,45.36 230.05,45.81 R1120.1 229.21,46.13 228.79,46.55 228.79,48.35 229.45,49.01 229.45,49.61 v2(229.63,49.79)
TBTA_I2C_INT: length 38.9
  TOP w0.076: 239.7,48.02 239.7,48.05 239.79,48.14 239.79,48.15 240.02,48.38 240.03,48.38 240.35,48.7 U1201.C1
  TOP w0.102: v2(239.59,47.25) 239.59,47.91 239.7,48.02 ; v4(244.06,37.32) 244.04,37.33 244.04,37.33 243.75,37.63 U1101.J4
  IN4 w0.102: v2(239.59,47.25) 239.15,47.7 239.15,48.27 238.84,48.58 238.05,48.58 237.5,48.03 231.89,48.03 231.25,47.39 231.25,46.94 231.55,46.64 233.7,46.64 236.06,44.28 236.06,43.39 237.46,41.98 237.46,41.74 238.32,40.88 239.13,40.88 240.15,39.86 241.05,39.86 241.17,39.74 241.17,38.93 241.48,38.63 242.75,38.63 v4(244.06,37.32)
  BOTTOM w0.102: v2(239.59,47.25) 239.59,47.93 238.85,48.67 237.27,48.67 236.86,48.25 v1(233.96,48.25) 233.32,48.25 R1145.1
TBTA_LSRX: length 29.1
  TOP w0.076: 244.6,49.95 244.23,49.95 U1201.K4
  TOP w0.102: 247.89,37.21 247.91,37.19
  TOP w0.114: U1101.A4 247.73,37.21 247.89,37.21 ; v2(250.45,47.86) 250.29,47.69 246.93,47.69 246.06,48.56 246.06,48.76 244.87,49.95 244.6,49.95 ; v2(251.13,35.39) 251.2,35.32 R1122.1 251.77,35.63 251.56,35.83 250.87,35.83 250.39,36.31 250.09,36.31 250.02,36.38 248.71,36.38 247.91,37.19
  IN4 w0.076: v2(250.45,47.86) 250.45,47.03 250.76,46.72 251.49,46.72 252.92,45.29 252.92,37.83 252.05,36.96 252.05,36.31 v2(251.13,35.39)
  BOTTOM w0.114: v2(251.13,35.39) 251.13,36.01 v1(251.03,36.11)
TBTA_LSTX: length 25.7
  TOP w0.102: U1101.A5 247.79,36.97 247.91,36.85
  TOP w0.114: v2(249.97,48.26) 249.67,47.96 249.06,47.96 v1(248.87,48.15) 248.68,47.96 247.01,47.96 246.37,48.6 246.37,48.81 244.98,50.2 U1201.L4 ; v2(250.5,35.45) 250.32,35.63 R1118.1 249.35,36.14 248.62,36.14 247.91,36.85
  IN4 w0.076: v2(249.97,48.26) 249.97,47.15 250.62,46.5 251.39,46.5 252.68,45.21 252.68,37.98 251.72,37.02 251.72,36.68 v2(250.5,35.45)
TBTA_TX0_N: length 4.6
  TOP w0.089: U1101.B19 247.27,30.75 247.73,30.75 247.87,30.61 248.52,30.61 248.52,30.61 248.59,30.61
  TOP w0.102: 248.59,30.61 250.1,30.61 arc(250.32,30.56) 250.5,30.44 arc(250.68,30.32) 250.9,30.28 251.03,30.28 arc(251.19,30.35) C1135.1
TBTA_TX0_P: length 4.6
  TOP w0.089: U1101.A19 247.36,30.53 247.32,30.49 247.32,30.37 247.39,30.3 247.74,30.3 247.86,30.42 248.44,30.42 248.48,30.38 248.59,30.38
  TOP w0.102: 248.59,30.38 250.1,30.38 arc(250.23,30.35) 250.34,30.28 arc(250.6,30.11) 250.9,30.05 251.01,30.05 arc(251.19,29.98) C1134.1
TBTA_TX1_N: length 4.5
  TOP w0.089: 248.71,31.34 248.7,31.34 248.67,31.37 247.87,31.37 247.73,31.23 247.27,31.23 U1101.B17
  TOP w0.102: 248.71,31.34 249.05,31.34 arc(249.18,31.36) 249.29,31.44 arc(249.4,31.51) 249.53,31.54 251.05,31.54 arc(251.2,31.48) C1133.1
TBTA_TX1_P: length 4.6
  TOP w0.089: U1101.A17 247.37,31.45 247.33,31.5 247.33,31.62 247.38,31.67 247.74,31.67 247.86,31.56 248.59,31.56 248.6,31.57 248.71,31.57
  TOP w0.102: 248.71,31.57 249.05,31.57 arc(249.09,31.58) 249.13,31.6 arc(249.31,31.72) 249.53,31.77 251.03,31.77 arc(251.19,31.84) 251.26,32 C1132.1
TBTA_USB2_D_N: length 27.9
  TOP w0.076: U1201.K5 243.99,50.57 244.11,50.45 244.59,50.45 244.59,50.46 244.63,50.46
  TOP w0.102: U1101.D20 246.1,29.85 246.02,29.93 v4(246.02,30.17)
  TOP w0.114: v2(247.26,48.58) 247.45,48.77 247.45,49.04 247.3,49.19 246.79,49.19 245.57,50.41 245.01,50.41 244.96,50.46 244.63,50.46
  IN1 w0.089: v4(246.02,30.17) 245.85,30.17 245.75,30.07 245.75,29.94 246.05,29.63 246.12,29.63 246.32,29.63 246.51,29.83 246.51,34.87 247.62,35.98 247.62,37.99 245.9,39.72 245.76,39.72 245.58,39.9 245.58,45.85 247.55,47.82 247.55,48.29 v2(247.26,48.58)
TBTA_USB2_D_P: length 27.9
  TOP w0.102: v4(245.37,30.17) 245.69,29.85 U1101.E20
  TOP w0.114: U1201.L5 244.63,50.7 244.63,50.69 245.06,50.69 245.11,50.64 245.67,50.64 246.89,49.42 247.4,49.42 247.7,49.12 247.7,48.78 v2(247.9,48.58)
  IN1 w0.089: v4(245.37,30.17) 245.57,29.98 245.57,29.86 245.97,29.46 246.2,29.46 246.4,29.46 246.69,29.75 246.69,34.8 247.8,35.91 247.8,38.06 245.97,39.9 245.84,39.9 245.76,39.97 245.76,45.78 247.73,47.75 247.73,48.42 v2(247.9,48.58)
TBTA_USB2_RBIAS: length 4.1
  TOP w0.076: U1101.H19 244.56,30.66 244.59,30.66 v4(244.75,30.83)
  BOTTOM w0.102: v4(244.75,30.83) 244.75,29.94 v1(244.72,29.91) 244.72,29.12 244.27,28.67 244.27,27.83 R1123.2
TBTB_I2C_INT: length 20.5
  TOP w0.102: R1135.1 231.37,44.64 232.12,43.89 233.29,43.89 233.39,43.99 235.31,43.99 v1(235.66,44.34) 238.94,44.34 239.42,44.83 240.07,44.83 240.53,44.37 241.28,44.37 241.47,44.18 241.77,44.18 242.38,43.57 244.93,43.57 245.5,43 245.5,39.05 245.44,38.98 245.44,38.58 U1101.E2
TC: length 2.6
  TOP w0.102: U8702.13 123.4,70.92 R8736.1 v1(124.08,69.28)
TESTMODE: length 2.8
  TOP w0.089: R7008.1 95.38,140.05 v6(95.53,139.89) 95.77,139.65 v1(96.09,139.65)
  BOTTOM w0.102: v6(95.53,139.89) 95.56,139.87 96.34,139.87 U7000.BA23
THRO_CPU: length 238
  TOP w0.102: v2(117.68,37.74) 117.68,39.72 120.42,42.46 123.09,42.46 124,41.55 U3001.123
  IN2 w0.102: v2(7.84,151.81) 7.87,151.81 8.78,150.9 8.78,143.91 7.72,142.84 7.72,142.57 4.47,139.33 4.47,126.51 5.9,125.08 5.9,124.5 6.71,123.7 6.71,119.14 7.86,117.99 7.86,105.17 7.32,104.63 7.32,88.72 7.49,88.54 7.49,86.79 7.93,86.35 8.34,86.35 8.93,85.76 8.93,75.88 6.72,73.67 6.72,68.43 7.75,67.4 8.36,67.4 9.75,66.01 9.75,65.05 10.93,63.87 12.07,63.87 12.84,63.11 19.37,63.11 19.89,62.6 22.12,62.6 24.74,59.98 24.74,58.1 28.5,54.34 28.5,50.21 36.88,41.83 38.3,41.83 40.77,39.36 40.77,38.01 42.26,36.52 48.31,36.52 49.18,37.4 97.48,37.4 98.16,36.72 106.48,36.72 106.97,37.22 107.31,37.22 107.79,36.74 110.41,36.74 110.57,36.9 116.84,36.9 v2(117.68,37.74)
  BOTTOM w0.102: Q0702.1 6.77,152.86 7.82,151.81 v2(7.84,151.81) 8.8,151.81 9.2,152.2 v1(9.2,152.65)
TOUCHPANEL_EN: length 414.1
  TOP w0.102: v2(69.9,48.25) 69.9,48 78.22,39.68 78.22,35.25 v2(78.22,35.25) ; v2(97.71,185.26) 97.71,185.13 97.36,184.78 97.36,183.11 97.66,182.8 97.66,182.19 97.77,182.08 CON4301.15 ; R2471.2 187.58,43.23 187.53,43.18 v2(187.26,43.18) 187.2,43.25 182.97,43.25 182.53,43.68 181.5,43.68 181,44.19 181,44.4 180.61,44.79 179.54,44.79 v2(179.13,45.2)
  IN1 w0.102: v2(187.26,43.18) 187.26,42.82 184.22,39.77 183.4,39.77 182.85,39.23 182.85,38.89 183.09,38.65 183.43,38.65 183.53,38.75 184.21,38.75 184.68,38.28 184.68,35.18 183.17,33.67 177.81,33.67 177.4,33.25 175.06,33.25 174.65,32.83 173.89,32.83 173.79,32.73 173.79,32.45 173.5,32.16 168.62,32.16 168.09,31.63 167.33,31.63 166.73,32.22 160.6,32.22 159.97,32.86 152.04,32.86 150.36,31.18 130.61,31.18 129.76,30.33 117.82,30.33 115.34,32.81 110.45,32.81 106.13,37.12 83.09,37.12 80.81,34.84 78.62,34.84 v2(78.22,35.25)
  IN2 w0.102: v2(88.32,184.88) 88.04,184.6 81.82,184.6 80.06,182.85 80.06,182.68 80.06,181.69 78.06,179.68 75.7,179.68 74.3,181.09 48.99,181.09 47.95,180.05 45.16,180.05 44.48,179.36 40.49,179.36 40,178.87 39.71,178.87 38.75,177.91 36.35,177.91 35.04,176.59 32.79,176.59 32.41,176.21 30.2,176.21 29.79,175.8 29.79,172.97 28.58,171.75 26.46,171.75 24.16,169.44 24.16,167.63 26.34,165.45 26.34,158.98 19.64,152.28 19.64,151.08 19.45,150.89 19.45,145.62 18.69,144.87 18.69,143.76 18.97,143.48 18.97,137.51 18.51,137.04 18.51,132.84 15.98,130.31 15.98,125.23 20.37,120.84 20.37,95.63 29.67,86.33 29.67,74.81 28.86,74 28.86,72.18 32.84,68.2 32.84,65.98 36,62.81 36,61.6 36.12,61.49 36.24,61.49 36.24,61.48 36.76,61.48 37.29,60.95 37.29,57.17 40.51,53.95 47.68,53.95 48.91,52.71 48.91,51.69 49.16,51.44 50.18,51.44 52.86,48.76 69.39,48.76 v2(69.9,48.25)
  IN4 w0.102: v2(88.32,184.88) 87.68,184.88 87.17,184.37 87.17,181.45 88.06,180.56 88.7,180.56 89.59,181.45 92.76,181.45 93.14,181.83 95.17,181.83 97.08,183.74 97.08,184.62 v2(97.71,185.26)
  BOTTOM w0.089: v2(179.13,45.2) 179.5,45.57 U2000.BA35
  BOTTOM w0.102: v2(78.22,35.25) 78.22,35.36 v1(77.34,36.24)
TOUCHPANEL_INT#: length 409.5
  TOP w0.102: CON4301.12 96.27,182.76 96.19,182.83 96.19,184.75 v2(95.68,185.26) ; v2(80.66,35.26) 80.66,38.94 72.39,47.21 v2(72.39,48.25)
  IN1 w0.102: v2(186.95,43.98) 185.9,43.98 184.57,42.64 184.57,41.27 182.65,39.36 182.65,38.8 183.01,38.45 183.51,38.45 183.62,38.55 184.12,38.55 184.48,38.19 184.48,35.27 183.09,33.87 177.73,33.87 177.31,33.45 174.98,33.45 174.59,33.06 151.95,33.06 150.28,31.39 130.52,31.39 129.67,30.54 117.97,30.54 115.49,33.01 113.94,33.01 112.46,34.49 110.09,34.49 107.24,37.33 82.72,37.33 v2(80.66,35.26)
  IN2 w0.102: v2(88.44,183.23) 87.9,183.23 87.13,183.99 82.1,183.99 80.69,182.59 80.69,181.45 78.31,179.07 75.56,179.07 74.62,178.13 56.84,178.13 54.52,180.44 49.32,180.44 47.63,178.75 40.78,178.75 40.27,178.25 39.96,178.25 39,177.3 36.61,177.3 35.86,176.55 35.66,176.35 35.29,175.98 33.2,175.98 33.05,175.83 33.05,168.55 33.63,167.96 34.61,167.96 35.79,166.78 35.79,160.1 34.18,158.49 29.79,158.49 28.6,157.29 25.52,157.29 21.18,152.96 21.18,151.66 21.39,151.45 21.39,146.04 21.11,145.76 21.11,145.39 20.37,144.65 19.62,144.65 19.3,144.33 19.3,144.01 19.58,143.74 19.58,137.25 19.12,136.78 19.12,131.41 16.59,128.88 16.59,125.48 16.61,125.46 20.98,121.09 20.98,95.88 30.28,86.58 30.28,74.47 29.47,73.65 29.47,72.43 33.45,68.45 33.45,66.27 34.6,65.12 35.61,65.12 37.31,63.42 37.31,61.79 38.18,60.93 38.18,60.68 38.58,60.27 38.58,57 41.03,54.55 47.93,54.55 51.7,50.78 57.29,50.78 58.6,49.47 71.17,49.47 v2(72.39,48.25)
  IN4 w0.102: v2(95.68,185.26) 95.68,183.48 94.92,182.72 92.13,182.72 91.59,182.19 88.34,182.19 88.06,182.47 88.06,182.85 v2(88.44,183.23)
  BOTTOM w0.089: U2000.BC35 180.73,45.51 180.75,45.5 180.99,45.5 181.13,45.35 182.34,45.35 183.49,44.2 184.71,44.2
  BOTTOM w0.102: R2470.2 190.15,43.63 189.71,43.63 189.71,43.63 189.16,43.63 188.59,44.2 187.17,44.2 v2(186.95,43.98) 186.57,43.98 186.36,44.2 184.71,44.2 ; v2(80.66,35.26) 81.2,35.81 v1(81.2,36.49)
TOUCHPANEL_RST#: length 418
  TOP w0.102: v2(73,48.25) 73,47.03 81.15,38.88 81.15,35.18 80.78,34.8 79.27,34.8 v2(78.83,35.25) ; CON4301.11 95.77,184.54 v2(95.05,185.26) ; v2(179.76,45.2) 180.48,45.2 181.2,44.48 181.2,44.27 181.59,43.88 182.63,43.88 183.06,43.45 186.96,43.45 187.1,43.58 187.13,43.58 187.2,43.65 189.01,43.65 189.09,43.58 189.62,43.58 189.74,43.7 R2467.2 190.68,43.27 190.68,42.54 191.09,42.13 192.38,42.13 193.07,41.45 193.07,39.79 193.5,39.36 193.5,34.66 193.73,34.43 v2(193.73,33.88)
  IN1 w0.102: v2(78.83,35.25) 78.83,35.27 81.78,38.22 96.25,38.22 96.58,38.55 110.59,38.55 114.12,35.02 115.79,35.02 116.66,34.15 116.66,33.68 117.02,33.32 122.86,33.32 123.09,33.09 130.1,33.09 130.53,33.52 131.04,33.52 131.38,33.86 131.38,34.7 131.8,35.12 143.51,35.12 144.21,34.42 154.52,34.42 154.87,34.08 173.81,34.08 v2(174.42,34.69)
  IN2 w0.102: v2(193.73,33.88) 193.32,34.28 180.35,34.28 180.35,34.28 174.83,34.28 v2(174.42,34.69) ; v2(73,48.25) 71.58,49.67 60.1,49.67 58.79,50.98 51.79,50.98 48.01,54.76 41.19,54.76 38.79,57.16 38.79,60.36 38.38,60.77 38.38,62.64 35.7,65.32 34.69,65.32 33.65,66.36 33.65,69.22 33.76,69.33 33.76,75.4 30.48,78.68 30.48,86.67 21.18,95.97 21.18,121.17 16.79,125.57 16.79,128.8 19.32,131.33 19.32,136.7 19.84,137.22 19.84,141.78 20.06,142 20.84,142 21.31,142.47 21.31,145.67 21.6,145.96 21.6,151.53 21.39,151.74 21.39,152.85 25.43,156.89 25.44,156.89 25.65,157.09 28.72,157.09 29.89,158.26 34.23,158.26 36.02,160.05 36.02,167.57 35.13,168.46 35.13,169.66 34.61,170.17 34.61,173.4 35.74,174.53 35.74,176.14 36.69,177.09 39.09,177.09 40.04,178.05 40.36,178.05 40.86,178.55 47.8,178.55 49.38,180.13 50.43,180.13 52.01,178.55 54.94,178.55 55.57,177.92 74.7,177.92 75.65,178.87 78.39,178.87 80.95,181.42 80.95,182.47 82.27,183.79 87.05,183.79 88.24,182.59 v2(88.57,182.59)
  IN4 w0.102: v2(88.57,182.59) 91.49,182.59 91.87,182.97 94.79,182.97 95.43,183.61 95.43,184.88 v2(95.05,185.26)
  BOTTOM w0.089: U2000.BB36 180.01,45.62 179.76,45.37 v2(179.76,45.2)
  BOTTOM w0.102: v2(78.83,35.25) 78.85,35.22 78.85,34.68 v1(78.74,34.56)
TP_ATTN#: length 16.9
  BOTTOM w0.102: R2363.2 175.03,34.11 v1(174.7,33.77) 173.91,32.99 173.91,32.29 173.8,32.18 ; 173.8,32.18 173.8,31.96 174.94,30.82 176.05,30.82 176.25,30.62 176.72,30.62 176.95,30.4 CON3104.11 ; 173.8,32.18 173.26,31.64 172.81,31.64 172.44,31.27 172.44,30.73 172.13,30.42 168.05,30.42 167.94,30.52 R2382.2 ; R2382.2 166.56,30.52 Q2301.2 ; R2382.2 167.55,29.74 R2310.2
TP_ATTN#_Q: length 24.1
  BOTTOM w0.089: U2000.AH43 172.98,42.17 173.24,41.91 173.24,41.43 173.3,41.36 173.3,40.71 173.57,40.44 173.57,38.73 174.35,37.95 174.35,37.73
  BOTTOM w0.102: Q2301.3 165.53,29.46 165.93,29.86 165.93,31.23 166.19,31.49 167.45,31.49 R2382.1 167.92,31.39 168.58,30.73 169.93,30.73 v1(170.06,30.85) 170.17,30.96 170.17,31.3 170.89,32.01 R2381.2 171.32,31.72 171.45,31.59 172.48,31.59 172.78,31.89 173.22,31.89 173.71,32.38 173.71,33.88 174.09,34.26 174.57,34.26 175.08,34.77 175.08,36.81 174.35,37.55 174.35,37.73
TP_BL_EN: length 29.6
  TOP w0.102: v1(193.73,40.02) 193.73,40.76 v2(194.36,41.39) ; v2(178.41,46.42) 179,45.84 180.42,45.84 181.6,44.65 181.6,44.63 181.95,44.29 183.67,44.29 183.72,44.34 R2435.2
  IN2 w0.102: v2(178.41,46.42) 179.05,45.79 180.45,45.79 185.15,41.09 194.05,41.09 v2(194.36,41.39)
  BOTTOM w0.102: v2(194.36,41.39) 194.52,41.24 Q3107.1 ; v2(178.41,46.42) 178.41,46.7 U2000.AW33
TP_BTN#: length 78.6
  TOP w0.102: U3001.128 127.99,43.55 v1(128.65,44.21) 128.78,44.34 R3081.2 130.28,44.95 132.28,44.95 v2(133.15,44.09)
  IN2 w0.102: v2(129.11,31.55) 129.98,32.43 133.61,32.43 133.86,32.17 133.86,31.87 134.21,31.52 145.58,31.52 146.43,32.36 147.11,32.36 147.74,31.74 159.39,31.74 159.47,31.82 163.53,31.82 166.05,29.3 167.87,29.3 168.02,29.15 v2(168.02,28.94)
  BOTTOM w0.102: v2(168.02,28.94) 168.02,28.95 168,28.97 168,30.02 168.09,30.12 170.95,30.12 172.3,28.77 174.72,28.77 175.31,28.18 176.82,28.18 177.11,28.47 179.6,28.47 180.45,29.31 CON3104.4 ; v2(129.11,31.55) 130.31,32.76 130.31,37.18 133.15,40.01 v2(133.15,44.09)
TP_CHA_XMM3_S2: length 26.7
  TOP w0.102: v2(75.11,73.43) 75.12,73.42 75.38,73.42 75.72,73.75 75.72,74.04 75.36,74.39 75.36,74.77 75.88,75.28 CON1600.162
  IN3 w0.102: v2(80.29,83.7) 79.81,83.22 79.81,82.9 78.23,81.32 75.97,81.32 74.7,80.05 74.7,73.83 75.11,73.42 v2(75.11,73.43)
  BOTTOM w0.102: T1602.1 80.32,85.69 80.32,84.74 T1601.1 80.32,84.22 80.29,84.19 v2(80.29,83.7) ; CON1601.162 73.88,70.11 73.63,70.35 73.63,72.08 74.98,73.42 75.1,73.42 v2(75.11,73.43)
TP_CHA_XMM3_S3: length 16.8
  TOP w0.102: CON1600.165 76.63,69.88 76.45,70.06 76.45,71.34 77.7,72.58 77.7,73.4 v2(78.2,73.9)
  BOTTOM w0.102: v2(78.2,73.9) 78.03,73.9 76.23,75.71 75.74,75.71 75.24,76.21 74.73,76.21 74.63,76.32 CON1601.165 74.63,79.57 74.6,79.6 T1603.1 T1600.1
TP_CHB_XMM1_S2: length 16
  TOP w0.102: CON1700.162 75.88,64.26 75.16,63.54 75.16,61.74 74.87,61.45 74.87,60.68 v2(74.47,60.29)
  BOTTOM w0.102: v2(74.47,60.29) 73.88,59.69 CON1701.162 73.88,55.67 73.46,55.25 73.46,54.17 72.44,53.15 T1702.1 T1703.1
TP_CHB_XMM1_S3: length 21.4
  TOP w0.102: v2(81.84,53.03) 81.41,53.46 78.28,53.46 78.28,53.48 76.63,55.13 CON1700.165 76.63,58.13 76.76,58.27 76.76,61.69 v2(76.74,61.71)
  BOTTOM w0.102: T1700.1 T1701.1 82.37,52.49 v2(81.84,53.03) ; v2(76.74,61.71) 76.96,61.71 77.17,61.92 77.17,63 76.76,63.41 75.63,63.41 74.63,64.41 CON1701.165
TP_CK_48M_USB_SEVR_ONLY: length 11.2
  TOP w0.102: v2(175.95,55.49) 175.39,56.05 174.46,56.05 174.22,56.29 174.22,56.86 174.5,57.14 174.5,60.83 174.49,60.84 174.49,63.69 T2204.1
  BOTTOM w0.089: U2000.AR17 176.5,54.93 v2(175.95,55.49)
TP_CLK_I2C: length 11.9
  TOP w0.102: v2(174.34,32.43) v1(174.34,33.57) 174.34,34.02 174.84,34.52 174.84,36.33 174.97,36.46 175.02,36.46 R2313.2 174.92,37.14 174.55,37.14 174.43,37.26 174.43,38.15 175.13,38.85 175.13,39.3 175.58,39.75 U2301.3
  BOTTOM w0.102: v2(174.34,32.43) 174.94,32.43 175.15,32.22 175.44,32.22 175.59,32.07 R3151.2
TP_CLK_I2C_PCH: length 10.7
  TOP w0.102: R2379.2 174.86,37.99 175,38.13 175.43,38.13 175.58,38.28 U2301.4 175.58,39.26 175.7,39.38 176.83,39.38 177.08,39.63 177.08,40.42 177.22,40.56 177.22,42.47 176.82,42.88 176.82,44.12 177.2,44.5 v2(177.2,44.78) v1(177.65,45.23)
  BOTTOM w0.089: U2000.AR38 176.98,44.56 v2(177.2,44.78)
TP_DATA_I2C: length 10.5
  TOP w0.102: U2301.6 176.88,38.15 176.73,38 176.73,37.65 176.26,37.18 176.14,37.18 176.01,37.05 176.01,35.56 176.09,35.49 176.09,34.53 175.85,34.29 175.79,34.29 R2312.2 176.03,33.68 176.03,32.95 176.01,32.92 v2(176.01,32.64) 176.01,31.98 v1(175.92,31.89)
  IN2 w0.102: v2(177.46,32.66) 177.05,33.06 176.43,33.06 v2(176.01,32.64)
  BOTTOM w0.102: v2(177.46,32.66) 176.87,32.07 R3150.2
TP_DATA_I2C_PCH: length 9.7
  TOP w0.102: v2(176.67,39.79) 176.88,40 U2301.1 176.88,42.53 176.61,42.8 176.61,42.92 R2380.2
  BOTTOM w0.089: U2000.AT42 176.92,42.52 176.61,42.2 176.61,41.32 176.65,41.27 176.65,40.5 176.7,40.45 176.7,39.83 v2(176.67,39.79) 177.1,39.36 177.32,39.36 177.85,38.83 178.41,38.83 v1(179.07,38.17)
TP_EXIT_HOLDOFF#: length 2.6
  TOP w0.102: v2(179.86,54.24) 179.89,54.21 R2262.1 180.61,54.54 181.13,55.06 T2203.1
  BOTTOM w0.089: U2000.BB17 179.86,54.55 v2(179.86,54.24)
TP_GPD7_RSVD: length 16.4
  BOTTOM w0.089: 184.71,58.31 184.21,58.31 182.92,57.02 182.92,56.33 182.68,56.1 181.45,56.1 180.95,56.6 U2000.BD14
  BOTTOM w0.102: 184.71,58.31 187.58,58.31 187.76,58.49 189.27,58.49 189.32,58.44 190.12,58.44 190.17,58.39 192.76,58.39 194.18,59.81 T2410.1
TP_GPP_A17_ISH_GP7: length 13.5
  BOTTOM w0.089: 184.71,54.72 184.21,54.72 182.85,53.36 181.69,53.36 181.5,53.56 180.73,53.56 U2000.BC19
  BOTTOM w0.102: 184.71,54.72 187.35,54.72 187.8,55.17 190.34,55.17 R2240.2 190.92,55.43 191.65,55.43 191.73,55.34 v1(192.86,55.34)
TP_GPP_A20_ISH_GP2: length 11.7
  BOTTOM w0.089: 184.71,53.91 184.41,53.91 183.11,52.61 181.73,52.61 181.68,52.57 U2000.BD22
  BOTTOM w0.102: 184.71,53.91 187.02,53.91 187.48,53.44 189.12,53.44 189.33,53.23 R2241.2 190.5,52.28 v1(190.2,51.98)
TP_GPP_A23_ISH_GP5: length 8.1
  BOTTOM w0.089: U2000.BC22 180.62,52.57 180.87,52.81 181.15,52.81 181.22,52.75 181.61,52.75 181.67,52.8 183.05,52.8 184.36,54.11 184.71,54.11
  BOTTOM w0.102: 184.71,54.11 187.13,54.11 187.38,53.86 R2242.2
TP_GPP_B11: length 1.5
  TOP w0.102: T2400.1 175.57,50.74 v2(176.29,50.74)
  BOTTOM w0.089: U2000.AN24 175.74,51.29 v2(176.29,50.74)
TP_GPP_G0_TACH0: length 12.6
  BOTTOM w0.089: U2000.U43 167.85,41.82 167.7,41.67 167.7,41.42 167.73,41.39 167.73,40.95 167.41,40.63 167.41,40.07 167.41,40.07 167.41,39.92 166.5,39.01 165.96,38.47 164.98,38.47 164.24,37.73
  BOTTOM w0.102: 164.24,37.73 163.59,37.08 163.59,34.98 163.86,34.71 163.86,33.72 R2207.2 163.6,33.01 163.6,32.37 v1(163.73,32.24)
TP_GPP_H_18: length 9.9
  TOP w0.102: R2473.2 187.54,42.72 186.59,42.72 186.06,42.18 183.08,42.18 v1(182.7,42.56) 182.64,42.63 181.99,42.63 180.43,44.18 v2(180.35,44.18)
  BOTTOM w0.102: v2(180.35,44.18) 180.19,44.34 180.19,45.09 U2000.BC36
TP_LANPHYPC: length 8.2
  TOP w0.102: T2409.1 174.69,61.43 174.69,60.92 174.7,60.91 174.7,57.35 174.96,57.09 175.25,57.09 175.79,56.55 175.79,56.37 176.03,56.13 176.44,56.13 v2(176.84,56.53)
  BOTTOM w0.089: v2(176.84,56.53) 176.48,56.17 U2000.AR15
TP_LED_BLUE: length 73.9
  TOP w0.102: v1(170.59,29.66) 172.03,29.66 172.09,29.61 v2(172.09,29.61)
  IN1 w0.102: v2(197.26,29.68) 198.55,30.98 198.55,35.1 199.39,35.93 199.39,39.26 196.72,41.93 v2(196.72,44.86)
  IN2 w0.102: v2(172.09,29.61) 172.37,29.32 173.51,28.19 183.33,28.19 183.85,27.67 189.85,27.67 191.59,29.41 195.03,29.41 195.69,30.06 196.88,30.06 v2(197.26,29.68)
  IN4 w0.102: v2(196.72,44.86) 196.29,44.86 194.92,46.23 194.12,46.23 192.33,44.44 192.33,44.42 191.21,44.42 v2(189.89,45.73)
  BOTTOM w0.089: U2000.BD33 181.13,47.02 181.21,46.95 181.47,46.95 181.79,46.63 183.95,46.63 184.7,45.87 184.71,45.87
  BOTTOM w0.102: CON3104.5 179.95,29.1 179.52,28.67 177.01,28.67 176.72,28.38 175.4,28.38 174.8,28.97 172.72,28.97 172.09,29.61 v2(172.09,29.61) ; R2437.2 v2(189.89,45.73) 189.85,45.69 187.48,45.69 187.3,45.87 184.71,45.87
TP_LED_RED: length 72.7
  TOP w0.102: v2(172.69,29.61) 172.69,30.01 172.38,30.32 v1(172.21,30.32)
  IN1 w0.102: v2(197.97,29.65) 198.83,30.51 198.83,34.87 199.72,35.76 199.72,39.55 v2(197.14,42.13)
  IN2 w0.102: v2(197.97,29.65) 197.35,30.27 195.6,30.27 194.95,29.61 191.51,29.61 189.77,27.87 183.93,27.87 183.41,28.39 173.91,28.39 172.98,29.32 v2(172.69,29.61) ; v2(197.14,42.13) 196.94,42.34 194.3,42.34 193.46,41.5 185.31,41.5 184.33,42.48 v2(184.33,44.8)
  BOTTOM w0.089: U2000.BB33 180.03,46.86 180.84,46.05 181.09,46.05 181.23,45.91 183.47,45.91 184.33,45.06 v2(184.33,44.8) 184.66,44.8 184.71,44.85
  BOTTOM w0.102: 184.71,44.85 R2436.2 ; v2(172.69,29.61) 172.69,29.61 173.13,29.18 174.89,29.18 175.48,28.58 176.62,28.58 176.91,28.87 179.1,28.87 179.45,29.23 CON3104.6
TP_PCH_RSVD_BD1: length 8.6
  BOTTOM w0.089: U2000.BD1 181.07,64.36 180.52,64.91 180.52,66.39 180.74,66.61 181.17,66.61 181.25,66.69
  BOTTOM w0.102: T2500.1 181.57,69.92 181.57,68.34 181.38,68.16 181.38,66.82 181.25,66.69
TP_PCH_RSVD_BE2: length 4
  BOTTOM w0.089: T2501.1 180.88,65.96 180.88,64.8 181.25,64.43 181.25,63.09 181.43,62.91 U2000.BE2
TP_PS2_CLK: length 74
  TOP w0.102: R3073.2 122.1,25.63 v1(122.13,25.66) 122.13,26.04 122.36,26.27 122.36,27.76 122.52,27.91 122.52,28.45 122.32,28.65 U3001.89 122.32,31.32 122.01,31.63 121.42,31.63 v2(121.36,31.69)
  IN1 w0.102: v2(165.63,31.62) 166.03,31.22 168.26,31.22 168.79,31.76 174.54,31.76 174.99,32.21 175.63,32.21 176.07,31.77 179.41,31.77 v2(180.3,32.66)
  IN2 w0.102: v2(165.63,31.62) 165.23,31.21 164.79,31.21 163.97,32.02 159.39,32.02 159.31,31.94 147.96,31.94 147.33,32.57 146.35,32.57 145.5,31.72 135.43,31.72 133.97,33.18 123.43,33.18 121.88,31.63 121.42,31.63 v2(121.36,31.69)
  BOTTOM w0.102: v2(180.3,32.66) 180.11,32.47 C3103.1 180.11,31.09 D3102.1 179.85,31.08 178.95,30.17 CON3104.7
TP_PS2_DAT: length 76.8
  TOP w0.102: v2(121.31,32.3) 121.32,32.3 121.77,31.85 122.42,31.85 122.72,31.55 U3001.90 122.72,27.82 122.57,27.67 122.57,25.17 R3072.2 ; v2(165.02,31.62) 164.87,31.46 v1(164.24,31.46)
  IN1 w0.102: v2(165.02,31.62) 165.43,32.02 166.65,32.02 167.25,31.42 168.17,31.42 168.71,31.96 174.45,31.96 174.9,32.42 174.9,32.8 175.15,33.05 176.24,33.05 176.43,32.86 176.43,32.17 176.63,31.97 179.01,31.97 v2(179.69,32.66)
  IN2 w0.102: v2(165.02,31.62) 164.41,32.22 161.01,32.22 160.38,32.86 151.56,32.86 151.01,32.3 147.89,32.3 146.9,33.29 144.36,33.29 143.88,32.81 142.52,32.81 141.78,32.07 135.36,32.07 134.03,33.41 122.88,33.41 122.18,32.71 121.54,32.71 121.31,32.48 v2(121.31,32.3)
  BOTTOM w0.102: CON3104.8 178.45,30.45 178.77,30.76 D3101.1 178.77,31.88 C3102.1 179.06,32.02 v2(179.69,32.66)
TP_SENSOR: length 63.9
  TOP w0.102: v2(179.04,46.41) 179.41,46.04 180.51,46.04 181.8,44.75 181.8,44.73 182.03,44.49 183.45,44.49 183.92,44.96 183.92,44.98 184.15,45.2 185.35,45.2 185.48,45.33 v1(186.05,45.33) 186.83,45.33 187.24,45.73 R2434.2
  IN1 w0.102: v2(192.96,32.76) 193.57,33.37 193.79,33.37 194.23,33.81 194.23,34.9 193.6,35.53 193.6,41.21 194.27,41.88 v2(194.82,41.88)
  IN2 w0.102: v2(179.04,46.41) 180.11,46.41 185.22,41.3 193.59,41.3 194.22,41.93 194.77,41.93 v2(194.82,41.88)
  IN3 w0.102: v2(192.96,32.76) 192.45,32.76 190.73,31.04 174.77,31.04 174.35,31.46 173.86,31.46 v2(173.47,31.07)
  BOTTOM w0.089: U2000.BA33 179.04,46.44 v2(179.04,46.41)
  BOTTOM w0.102: CON3104.12 176.45,30.13 175.97,30.61 173.91,30.61 173.64,30.89 173.64,30.9 v2(173.47,31.07)
TP_SPI0_CS1#: length 5.1
  TOP w0.102: T2202.1 175.36,46.9 177.33,46.9 v2(177.8,46.43)
  BOTTOM w0.089: U2000.AW31 178.37,47.89 178.06,47.58 178.06,47.23 178.17,47.12 178.17,46.8 v2(177.8,46.43)
TP_SPI0_CS2#: length 2.9
  TOP w0.102: T2201.1 175.78,47.84 176.2,47.84 v2(176.66,47.37)
  BOTTOM w0.102: U2000.AT31 176.66,47.39 v2(176.66,47.37)
TS1#: length 142.7
  TOP w0.102: v2(133.38,29.07) 133.38,30.45 133.86,30.93 134.19,30.93 134.87,31.61 134.87,33.95 135.1,34.18 135.1,40.56 133.93,41.72 v1(133.53,41.72) JP9000.2
  IN2 w0.102: v2(133.38,29.07) 134.05,29.75 146.13,29.75 146.48,30.1 160.66,30.1 161.86,28.91 163.8,28.91 165.92,26.79 169.12,26.79 169.56,26.34 177.58,26.34 178.61,25.32 190.02,25.32 190.73,26.03 196.24,26.03 197.12,26.91 204.69,26.91 204.76,26.99 208.43,26.99 209.68,28.24 214.12,28.24 215.82,29.94 v2(216.89,29.94)
  BOTTOM w0.102: CON6000.5 242,23.81 241.93,23.88 241.47,23.88 241.39,23.81 240.88,23.81 240.46,24.22 235.03,24.22 234.67,24.58 234.67,25.19 233.93,25.93 232.74,25.93 231.99,25.17 231.99,22.23 231.73,21.98 231.73,20.79 231.4,20.46 230.56,20.46 R6001.2 229.39,20.47 221.35,20.47 217.49,24.33 217.49,29.34 v2(216.89,29.94)
TS_I2C_CLK: length 393.2
  TOP w0.102: v2(96.95,185.26) 96.95,184.98 97.16,184.77 97.16,183.02 97.46,182.72 97.46,182.15 97.27,181.96 CON4301.14 ; v2(70.59,48.25) 70.59,48 79.62,38.97 79.62,35.45 v2(79.44,35.27) ; v2(177.22,43.04) 177.42,42.84 177.42,40.48 177.28,40.34 177.28,38.16 176.99,37.86 176.99,37.62 176.43,37.06 R2315.2 176.85,36.34 176.85,35.56 176.92,35.49 176.92,35.1 v2(176.52,34.7)
  IN1 w0.102: v2(176.52,34.7) 176.11,34.29 174.89,34.29 174.64,34.05 174.36,34.05 173.98,33.67 154.7,33.67 154.35,34.02 144.93,34.02 144.38,33.47 142.36,33.47 141.12,34.71 135.72,34.71 134.4,33.39 131.49,33.39 131.21,33.11 130.7,33.11 130.27,32.68 122.92,32.68 122.69,32.91 116.35,32.91 114.65,34.61 113.95,34.61 110.83,37.73 81.58,37.73 79.44,35.59 v2(79.44,35.27)
  IN2 w0.102: v2(70.59,48.25) 69.78,49.07 52.84,49.07 47.76,54.15 40.86,54.15 37.49,57.51 37.49,61.04 36.91,61.62 36.91,62.59 34.79,64.71 34.43,64.71 33.04,66.11 33.04,68.28 29.06,72.26 29.06,73.92 29.87,74.73 29.87,86.42 20.57,95.71 20.57,120.92 16.18,125.31 16.18,130.22 18.71,132.75 18.71,136.95 19.18,137.42 19.18,143.57 18.9,143.85 18.9,144.79 19.65,145.54 19.65,150.23 20.78,151.36 20.78,153.13 26.57,158.92 32.02,158.92 34.75,161.64 34.75,166.27 30.05,170.97 30.05,175.77 30.29,176.01 32.5,176.01 32.87,176.39 35.13,176.39 36.44,177.7 38.83,177.7 39.8,178.67 40.09,178.67 40.58,179.16 47.42,179.16 49.11,180.85 74.2,180.85 75.58,179.48 78.14,179.48 80.26,181.6 80.26,182.76 81.9,184.4 88.67,184.4 v2(88.82,184.24)
  IN4 w0.102: v2(88.82,184.24) 88.62,184.44 88.14,184.44 87.43,183.74 87.43,181.7 88.32,180.81 88.57,180.81 89.51,181.75 92.38,181.75 92.71,182.08 95.05,182.08 96.57,183.61 96.57,184.88 v2(96.95,185.26)
  BOTTOM w0.089: U2000.AR41 177.22,43.04 v2(177.22,43.04)
  BOTTOM w0.102: v2(79.44,35.27) 79.44,35.95 79.3,36.09 v1(79.3,36.64)
