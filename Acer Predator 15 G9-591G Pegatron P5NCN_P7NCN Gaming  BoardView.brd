# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS: length 923.3
  TOP w0.178: U3001.11 121.12,46.07 121.44,46.39 121.44,46.67 121.94,47.16 122.56,47.16 122.83,47.44 C3009.1
  TOP w0.254: R2136.1 R2135.1 v2(156.01,35.32) ; R4518.1 40.46,181.36 v2(40.49,181.39) ; R3147.1 141.63,31.95 141.91,31.67 R3145.1 R3143.1 ; R4800.1 245.79,78.63 246.62,79.45 Q4801.1 247.49,79.45 247.68,79.26 249.53,79.26 250.16,79.9 252.12,79.9 252.38,79.64 Q4803.1 ; R3143.1 142.8,31.67 v2(143.48,32.35) ; R3143.1 R3141.1 ; R2206.1 R2203.1 184.27,57.04 v2(184.04,56.81) ; v2(189.31,60.9) 189.31,60.7 R2202.1 ; R5132.1 25.25,29.51 25.71,29.05 26.7,29.05 26.9,29.25 R5127.1 ; R2247.1 160.2,32.98 R2246.1 R6113.1 161.4,33.18 v2(161.4,32.65) ; v2(189.92,50.97) 189.92,51.4 189.56,51.76 188.74,51.76 R2419.1 R2251.1 ; v2(161.4,32.65) 162.18,32.65 162.23,32.7 ; v2(161.4,32.65) 161.4,31.67 160.96,31.23 R5134.1 ; 162.23,32.7 162.79,32.15 163.5,32.15 163.97,32.61 164.42,32.61 R2162.1 ; 162.23,32.7 R6117.1 ; U5000.1 170.11,76.89 170,77.01 C5000.2 ; R2365.1 166.83,32.91 167.1,32.64 v2(167.78,32.64) 168.38,33.24 R2144.1 ; 63.83,145.92 R0301.1 ; 63.83,145.92 64.31,146.4 67.92,146.4 68.44,146.92 68.44,147.51 69.14,148.21 70.26,148.21 72.12,150.06 72.66,150.06 73.67,151.07 76.99,151.07 77.45,151.53 v2(77.93,151.53) ; 63.83,145.92 63.83,146.12 63.68,146.27 61.98,146.27 61.85,146.14 R0306.1 ; R2128.1 181.41,71.1 v2(181.41,71.26) 181.05,71.26 R2151.1 ; C5000.2 170.2,77.6 172.9,77.6 173.66,76.84 173.66,73.7 173.58,73.63 R5011.1 ; C5000.2 v2(169.6,76.29) ; v2(40.64,109.72) 40.64,111.09 40.13,111.6 34.21,111.6 33.58,112.23 33.58,118.18 31.47,120.29 R5012.1 21.97,120.29 21.33,120.93 16.81,120.93 v2(15.56,122.18) ; v2(40.49,181.39) 40.75,181.65 43.29,181.65 43.61,181.32 R4501.1 R4587.2 43.82,180.36 44.3,179.88 R4504.1 ; v2(40.49,181.39) 40.05,181.83 38.74,181.83 38.43,182.14 38.43,183.58 R4593.1 39.71,183.12 40.65,183.12 41,183.46 C5600.1 ; v2(149.47,32.71) 149.47,32.55 148.45,31.53 148.45,27.34 147.45,26.34 147.45,24.89 R3149.1 ; v2(179.27,71.79) 179.27,71.03 R2153.1 ; v2(152.6,32.45) 152.6,32.81 152.04,33.37 R3104.1 ; v2(122.1,46.57) 122.49,46.57 123.01,47.09 C3009.1 ; R2129.1 182.83,70.78 182.78,70.78 v2(182.3,71.26) ; v2(141.15,53.81) 140.77,53.44 140.77,51.14 141.23,50.69 R9203.1 ; U2401.5 175.02,21.95 174.85,21.79 174.85,21.02 175.06,20.82 C2403.1 175.84,20.82 176.06,21.04 176.06,23.14 176.17,23.25 176.17,23.26 177.64,24.72 177.64,29.43 177.21,29.86 R6202.1 ; R3081.1 130.81,44.62 131.72,44.62 v2(132.26,44.08) ; v2(133.86,54.22) 132.02,54.22 130.85,53.05 129.91,53.05 128.96,52.1 R9200.1 ; R3112.2 158.14,30.73 157.86,31.01 157.35,31.01 v2(156.01,32.35) 156.01,32.38 155.5,32.89 R3105.1 ; v2(186.61,49.42) 186.45,49.42 186.34,49.53 R2403.1 ; R2131.1 v2(163.12,35.32) ; R2209.1 v2(162.23,37.35)
  TOP w0.279: U5800.7 251.46,127.92 251.46,128.41
  TOP w0.305: v2(106.58,52.98) 106.58,53.54 106.74,53.71 R1708.1 R1707.1 ; CON1700.255 99.13,56.05 99.41,55.77 100.26,55.77 v2(100.56,55.47) ; C1709.1 98.15,67.38 98.6,67.84 98.96,67.84 99.13,68 CON1600.255
  TOP w0.356: U2301.5 176.23,38.17 176.32,38.08 v2(176.32,37.81) ; R2380.1 176.33,41.96 176.23,41.86 U2301.2 176.23,40.37 v2(176.3,40.29)
  TOP w0.381: R3604.1 11.66,65.67 ; v2(97.78,66.55) 97.8,66.57 97.8,66.8 98.15,67.15 C1709.1 ; R4817.1 R4818.1 ; R3608.1 11.4,66.56
  TOP w0.432: 203.21,33.48 203.36,33.62 205.18,33.62 207.73,31.07 207.73,30.81 209.49,29.05 211.6,29.05 213.88,31.32 214.9,31.32 215.63,32.05 215.63,32.12 216.95,33.44 216.95,34.7 216.76,34.89 R1408.1 ; R5808.1 C5802.1 253.35,122.39 ; v2(176.32,37.81) 176.05,37.54 R2379.1 ; 251.46,128.41 C5801.1 ; R5001.1 R5002.1
  TOP w0.508: R3170.2 224.5,43.49 v2(225.1,42.89) ; 176.84,32.25 176.83,32.25 176.83,30.76 R6202.1 ; v2(236.27,100.68) 234.87,100.68 v2(230.41,105.14) 229.08,103.81 v2(229.08,101.72) ; R5127.1 27.23,29.61 29.57,31.95 31.14,31.95 33.09,33.9 38.01,33.9 41.83,37.73 41.83,39.62 v2(43.59,41.37) ; R4817.1 250.7,75.77 Q4802.1 v2(253.43,75.77) ; R5806.2 245.87,129.45 248.14,131.71 C5803.1 ; v2(189.92,83.51) 189.76,83.51 188.96,82.71 188.96,81.87 188.13,81.04 R5013.1 187.05,81.26 186.61,81.7 184.64,81.7 182.57,79.63 182.57,79.26 182.05,78.74 182.05,78.16 v2(181.51,77.61) 179.86,75.96 R5001.1 ; v2(21.85,75.81) 22.02,75.64 R3603.2 ; C5803.1 251.22,132.82 251.64,133.24 252.91,133.24 256.78,129.36 256.78,125.82 253.35,122.39 ; C5803.1 251.22,131.55 251.46,131.31 C5801.1 ; R3609.1 23.5,77.53 23.32,77.35 v2(23.32,76.99) v2(23.32,76.38) ; Q1202.1 221.63,63.85 223.83,63.85 224.27,63.41 Q1201.1 226.06,62.73 228.25,60.55 229.96,60.55 v3(230.15,60.35) ; v2(82.09,83.71) 82.65,84.27 87.96,84.27 88.32,83.91 v2(89.17,83.91) ; R3605.1 26.45,59.42 30.18,55.69 30.18,54.25 32.28,52.15 32.33,52.15 35.94,52.15 v3(36.12,51.97) ; C1707.2 C1708.1 106.68,52.87 v2(106.58,52.98) ; Q4803.1 253.49,79.07 v3(253.59,78.97) ; R5002.1 178.79,73.93 178.49,73.63 177.61,73.63 176.72,72.74 176.36,72.74 175.75,72.12 175.75,71.97 v2(175.81,71.91) 175.19,71.91 174.11,70.83 174.11,69.78 173.88,69.56 C2620.1 173.66,69.37 R2618.2 ; C5802.1 v2(252.15,120.39)
  TOP w0.762: 57.93,173.08 57.65,173.08 57.2,173.53 46.85,173.53 46.49,173.89 v2(46.49,179.65)
  TOP w1.524: 208.33,21.68 204.78,21.68 203.12,23.33 203.12,26.18 203.1,26.21
  IN1 w0.254: v2(181.51,77.61) 181.51,76.29 180.82,75.61 172.72,75.61 172.03,76.29 v2(169.6,76.29)
  IN1 w0.508: v2(252.15,120.39) 251.66,120.87 240.59,120.87 237.16,117.44 237.16,112.11 v3(236.14,111.09)
  IN1 w0.635: v2(46.49,179.65) 44.65,179.65 42.91,181.39 v2(40.49,181.39)
  IN1 w1.016: 91.77,169.58 91.77,168.48
  IN1 w1.27: 91.77,168.48 88.46,165.17 88.46,163.18 84.07,158.79 82.77,158.79 ; v2(77.93,151.53) 77.93,150.04 80.89,147.07
  IN1 w2.032: 199.94,57.02 203.62,57.02 ; 249.66,64 249.66,68.8 251.72,70.86 251.72,75.1 252.44,75.82 ; 196.77,59.87 199.22,57.42
  IN2 w0.254: v2(189.31,60.9) 186.92,58.51 185.74,58.51 v2(184.04,56.81) ; v2(186.61,49.42) 188.41,49.42 189.92,50.93 v2(189.92,50.97) ; v2(13.26,119.32) 13.26,121.25 14.19,122.18 v2(15.56,122.18)
  IN2 w0.508: v2(225.1,42.89) 228.27,46.07 230.56,46.07 231.45,45.18 232.41,45.18 v3(233.14,45.91)
  IN2 w1.524: 253.39,34.36 252.91,33.88 252.91,28.44 250.57,26.1 250.57,24.3 249.08,22.81 237.7,22.81 234.22,19.33 223.5,19.33 221.74,21.09 218.93,21.09 216.81,23.21 212.3,23.21
  IN3 w0.102: 178.6,57.65 178.61,57.29 ; 172.88,32.81 172.87,32.43 ; 189.34,54.33 189.8,54.33 ; 176.11,34.52 176.09,34.91 ; 175.87,46.88 176.25,46.96 ; 175.95,45.39 176.3,45.47 ; 178.9,43.44 179.21,43.38 ; 243.76,83.66 243.84,83.23 ; 177.45,69.44 177.45,69.05 ; 180.16,43.75 180.6,43.77
  IN3 w0.127: 186.92,43.53 187.3,43.65 ; 170.47,44.52 170.94,44.52 ; 191.69,44.39 192.23,44.44
  IN3 w0.508: v2(152.6,32.45) 150.63,32.45 150.37,32.71 v2(149.47,32.71) 149.47,32.45 149.23,32.2 148.06,32.2 146.66,33.6 144.73,33.6 v2(143.48,32.35) ; v2(11.86,67.4) 10.59,67.4 9.7,68.29 7.93,68.29 7.29,68.93 7.29,73.12 9.83,75.66 9.83,77.56 10.33,78.06 11.21,78.06 12.22,77.05 13.5,77.05 13.77,77.33 13.77,78.26 14.72,79.21 15.85,79.21 15.9,79.27 21.08,79.27 21.85,78.49 v2(21.85,75.81) ; v2(94.16,177.39) 94.79,177.39 95.17,177.77 95.28,177.77 95.29,177.78 95.8,177.78 95.81,177.77 96.19,177.77 96.83,177.13 v2(99.87,177.13) 100.64,177.89 100.64,178.02 101.4,178.78 101.4,180.56 102.29,181.45 v2(102.69,181.45)
  IN3 w0.762: 242.91,97.36 242.14,97.36 240.48,99.03 237.92,99.03 v2(236.27,100.68) 237.97,102.38 237.97,109.26 v3(236.14,111.09) ; v3(233.14,45.91) 232.4,45.16 231.65,45.16 229.77,47.05 229.77,48.81 230.61,49.65 230.61,55.66 230.16,56.1
  IN3 w1.016: v3(31.83,59.49) 31.83,58.92 33.84,56.92 35.13,56.92 36.14,55.91 36.14,52.13
  IN3 w2.54: 54.43,43.35 57.4,43.35
  IN4 w0.254: v2(189.92,50.97) 191.41,50.97 v2(192.2,50.18) ; v2(141.15,53.81) 141.15,54.45 140.9,54.7 134.29,54.7 133.86,54.27 v2(133.86,54.22)
  IN4 w0.508: v3(59.38,173.45) 59.38,174.72
  IN4 w1.016: 57.83,181.68 56.72,180.56 56.72,177.51 57.55,176.68 57.55,174.78 57.46,174.69
  IN4 w1.27: 92.53,177.02 88.82,173.31 79.79,173.31 ; 54.18,170.5 51.61,170.5 44.79,163.68 37.1,163.68 35.43,162.01 35.43,161.5 32.61,158.68 29.14,158.68 28.21,157.75 14.06,157.75 10.58,154.28 10.58,145.74 10.3,145.46 10.3,144.18 ; 73.57,175.36 71.97,176.95 61.61,176.95 59.38,174.72
  BOTTOM w0.254: R2497.1 197,46.75 196.6,47.16 196.6,48.44 194.55,50.49 194,50.49 193.7,50.18 v2(192.2,50.18) 192.13,50.26 R2449.1 R2405.1 ; v2(81.2,129.15) 81.41,129.35 R7010.1 ; 37.98,178.57 38.25,178.3 CON5602.18 ; CON4400.10 70.63,29.77 71.35,29.05 v2(71.35,28.95) ; R2204.1 156.59,33.24 156.85,32.98 R2249.1 R6119.1 R6123.1 159.03,32.98 159.16,32.86 R6121.1 160.45,32.86 R6103.1 161.2,32.86 v2(161.4,32.65) 161.6,32.86 R6101.1 ; R2204.1 v2(156.01,32.35) ; R2204.1 R2210.1 R6115.1 R2244.1 R2245.1 ; R2155.1 R2154.1 ; v2(102.69,181.45) 102.72,181.45 102.72,181.45 R4308.1 R4302.1 R4307.1 R4303.1 ; R2205.1 156.06,35.37 v2(156.01,35.32) ; v2(15.56,122.18) 14.48,123.26 R0704.1 ; v2(133.86,54.22) 133.86,53 132.72,51.86 132.72,45.99 132.26,45.53 v2(132.26,44.08) ; v2(170.63,32.63) 170.76,32.75 R2106.1 ; R2207.1 163.37,34.74 163.12,34.99 v2(163.12,35.32) R2131.1 ; v2(99.87,177.13) 100.05,176.95 R4304.1 ; R2132.1 v2(165.79,34.69) ; v2(189.92,83.51) 190.22,83.51 R5008.1 190.58,83.2 R5007.1 ; C1604.1 C1605.2 C1606.1 90.81,81.17 R1607.1 ; v2(167.78,32.64) 167.78,33.02 R2133.1 ; R5000.1 41.71,110.33 41.09,109.72 v2(40.64,109.72) 39.98,110.38 R5003.1 ; CON4400.12 69.63,29.77 69.97,29.43 70.23,29.43 70.74,28.92 v2(70.71,28.92) ; R1623.1 R1624.1 12.9,119.32 v2(13.26,119.32) ; R2360.1 177.26,33.14 177.26,33.14 176.97,32.86 176.97,32.79 v2(176.84,32.66) ; R2134.1 v2(166.68,35.32) ; v2(175.68,35.32) 175.68,35.33 175.53,35.48 R2361.1 ; R2404.1 v2(186.61,49.42)
  BOTTOM w0.305: v2(97.78,66.55) 97.31,66.55 97.13,66.37 CON1701.255 ; R1608.1 91.08,83.83 90.45,84.47 ; R1606.1 82.91,83.4 82.6,83.71 v2(82.09,83.71) 82.06,83.71 81.51,83.15 81.51,82.82 R1609.1 ; 90.27,83.98 C1604.1 ; R2152.1 179.38,68.19 v2(178.99,68.57) 178.49,68.06 R2451.1 ; 90.29,86.19 91.16,87.06 92.16,87.06 93.84,85.38 93.84,84.64 94.34,84.14 C1704.1 C1706.1 C1705.2 94.34,80.15 94.71,79.77 95.63,79.77 97.13,78.28 CON1601.255
  BOTTOM w0.381: v3(59.38,173.45) 59.38,173.97 R4526.1 ; R1604.1 R1605.1 94.51,89.44 94.33,89.63 91.51,89.63 90.29,88.42 90.29,86.19 ; R5603.1 47.14,180.1 46.69,179.65 v2(46.49,179.65) ; v2(94.16,177.39) 94.01,177.39 93.45,177.94 93.45,178.25 93.73,178.53 R4305.1 R4306.1 R4311.1 R4309.1 93.73,182.34 R4310.1
  BOTTOM w0.432: v2(230.41,105.14) 230.94,105.14 231.18,104.9 C5007.2 231.18,103.19 U5003.5 ; R1706.1 78.94,54.5 79.5,53.94 81.38,53.94 ; v2(106.58,52.98) 107.04,53.43 R1709.1 ; R5018.1 228.47,101.11 v2(229.08,101.72)
  BOTTOM w0.508: v2(58.86,183.08) 58.86,183.86 58.85,183.86 ; v2(152.6,32.45) 152.45,32.6 R2245.1 152.02,33.24 151.01,34.25 v2(151.01,35.23) ; R2154.1 v2(182.3,71.26) ; v2(106.58,52.98) 101.85,48.25 96.69,48.25 v2(96.04,47.6) ; R3632.1 23.22,69.49 23.85,68.85 25.17,68.85 ; 37.98,178.57 37.64,178.91 37.64,181.83 38.1,182.29 39.85,182.29 40.49,181.65 v2(40.49,181.39)
  BOTTOM w2.032: 27.05,77.77 27.05,81.22 27.82,81.99 27.82,94.79 23.75,98.86 23.75,101.16 ; 27.5,74.94 27.5,73.3
  vias: v2(6.4,108.55) v2(6.4,107.92) v2(9.98,142.04) v2(10.11,142.64) v2(10.62,130.01) v2(58.6,173.19) v2(70.4,124.86) v2(70.41,121.75) v2(79.16,121.35) v2(79.16,120.71) v2(92.38,72.38) v2(92.53,52.86) v2(93.14,52.86) v2(93.78,52.86) v2(95.83,42.82) v2(96.09,176.82) v2(96.44,42.82) v2(197.73,36.23) v2(198.35,36.25) v2(198.98,36.23) v2(209.51,22.23) v2(244.36,93.52) v2(251,93.95) v2(251,93.31) v2(253.62,80.65) v2(257.23,93.69) v2(257.23,92.93) v3(10.69,131.62) v3(24.46,103.46) v3(24.46,102.57) v3(29.88,62.61) v3(30.8,62.83) v3(37.01,51.97) v3(37.9,51.97) v3(71.41,40.04) v3(72.29,40.04) v3(73.16,40.04) v3(193.01,65.04) v3(193.88,65.04) v3(195.65,61.38) v3(196.59,61.38) v3(197.47,62.28) v3(197.47,61.38) v3(210.25,22.23) v3(217.16,59.95) v3(217.61,60.72) v3(218.03,59.95) v3(230.81,59.66) v3(231.04,60.59) v3(243.55,94.72) v3(244.38,95.12) v3(244.38,94.26) v3(247.83,62.96) v3(247.78,60.15) v3(252.68,35.43) v3(252.73,34.54) v3(253.61,79.86)
+3VS_CAM: length 2.2
  TOP w0.254: CON4500.31 55.25,182.15 v2(55.11,182.28)
  BOTTOM w0.102: R4502.2 57.4,185.08 T4508.1
+3VS_DACVDD: length 4
  TOP w0.152: C7229.1 98.4,137.71 97.99,138.12 97.18,138.12 v1(96.55,137.48)
  BOTTOM w0.35: v6(98.98,136.69) 98.98,135.98 U7000.AW18
+3VS_DMIC: length 19.1
  TOP w0.102: T4507.1 45.16,178.68 R4504.2
  TOP w0.254: CON4500.27 57.25,182 57.42,182.18 57.42,183 56.86,183.57 46.86,183.57 46.45,183.15 45.72,183.15 45.39,182.82 45.39,180.75 45.16,180.52 R4504.2
+3VS_DMIC L: length 9.1
  TOP w0.432: v5(171.27,151.12) v2(171.83,151.52) 172.34,151.52 SR300.1 172.47,150.87 172.81,150.53 172.96,150.53 173.2,150.29 CON300.4 ; CON302.6 v2(167.39,150.7)
  IN1 w0.432: v2(171.83,151.52) 168.22,151.52 v2(167.39,150.7)
+3VS_DMIC R: length 5.4
  TOP w0.102: SR400.1 203.9,151.31 v1(204.4,150.8)
  TOP w0.432: CON400.4 200.9,150.61 202,151.71 SR400.1
+3VS_DPSW: length 83.6
  TOP w0.178: v2(215.9,44.19) 215.44,44.19 215.02,43.76 U1401.25
  TOP w0.254: v2(204.62,42.61) 204.62,42.48 205.13,41.98 R1402.1 ; R1415.1 R1414.1 215.57,45.66 215.94,45.29 v2(215.94,45.22) ; R1407.1 205.47,44.54 204.84,44.54 v2(204.69,44.69) ; 212.27,35.45 212.02,35.7 U1401.6
  TOP w0.279: U1401.1 209.52,36.36 209.34,36.18 208.25,36.18 207.98,35.92 207.98,34.9 C1414.2 ; R1408.2 215.34,35.32 215.02,35.65 U1401.12 ; U1401.32 211.52,43.77 211.67,43.92 211.81,43.92 v2(212.02,44.14) ; U1401.36 209.52,43.46 209.24,43.73 209.22,43.73 209.09,43.86 v2(208.94,43.86)
  TOP w0.406: 212.27,35.45 C1413.1 212.47,34.61 212.84,34.24 212.84,32.27 v2(212.26,31.69)
  TOP w0.432: R1408.2 215.9,34.86 216.42,34.34 216.42,33.66 215.09,32.33 215.09,32.27 214.71,31.89 v2(214.57,31.89) ; C1414.2 207.39,34.48 206.98,34.07 206.98,32.86 208.18,31.67 209.72,31.67 R1405.1 R1403.1 211.36,31.69 v2(212.26,31.69)
  IN1 w0.254: v2(208.94,43.86) 208.26,44.54 205.09,44.54 204.94,44.69 v2(204.69,44.69) 204.52,44.69 204.01,44.19 204.01,43.22 v2(204.62,42.61) 204.7,42.53 204.7,41.06 203.89,40.25 202.39,40.25 201.85,39.72 201.85,38.14 202.9,37.1 202.9,35 203.66,34.23 204.71,34.23 206.81,32.14 211.82,32.14 v2(212.26,31.69) 214.37,31.69 v2(214.57,31.89) 215.16,32.48 215.16,34.69 211.54,38.32 211.54,43.65 v2(212.02,44.14) 212.98,45.1 214.99,45.1 v2(215.9,44.19)
  BOTTOM w0.102: v2(204.62,42.61) 204.5,42.61 204.09,43.02 v1(203.89,43.02)
  BOTTOM w0.254: v2(215.9,44.19) 215.94,44.23 v2(215.94,45.22)
+3VS_EDP: length 14.6
  TOP w0.254: R4525.1 43.99,182.16 v2(43.78,181.94)
  IN1 w0.762: 47.31,181.11 61.18,181.11
  vias: v2(61.37,182.64) v2(62,182.64)
+3VS_GSENSOR: length 5.7
  TOP w0.102: v1(253.45,123.49) 253.05,123.9 251.9,123.9 R5808.2 250.75,123.76 U5800.3
+3VS_HDMI: length 66.3
  TOP w0.254: R1306.1 205.51,56.2 v2(205.33,56.02) ; R1317.1 213.86,46.73 214.09,46.5 214.72,46.5 215.36,47.14 215.36,47.55 215.51,47.69 217.01,47.69 217.64,48.32 217.64,49.21 v2(217.86,49.43) ; v2(212.91,49.83) 212.53,49.45 212.01,49.45 211.49,48.93 211.49,48.21 R1304.1 211.28,47.44 211.28,46.69 210.85,46.26 209.83,46.26 209.22,46.87 R1308.1
  TOP w0.279: U1301.36 210.41,57.73 210.13,58 v2(209.14,58) 208.56,58 v1(208.48,58.08) 208.48,58.59 C1302.1 208.94,59.43 R1302.1 ; v2(210.36,49.85) 210.41,49.9 U1301.1 ; U1301.6 v2(212.91,49.83) ; U1301.25 215.91,57.29 216.08,57.47 216.3,57.47 216.98,58.14 v2(216.98,58.41) 216.98,59.18 R1314.1 216.25,60.9 215.7,61.44 R1316.1 R1320.1 ; U1301.32 212.41,57.83 212.34,57.89 v2(212.38,57.89) ; U1301.12 216.11,50.51 216.21,50.41 217.25,50.41 217.68,49.98
  TOP w0.432: C1301.2 217.68,49.98 217.86,49.8 v2(217.86,49.43)
  IN1 w0.508: v2(212.91,49.83) 210.39,49.83 v2(210.36,49.85) 205.33,54.88 v2(205.33,56.02) 206.5,56.02 206.93,55.59 208.18,55.59 209.14,56.55 v2(209.14,58) 212.27,58 v2(212.38,57.89) 212.5,57.78 213.96,57.78 213.96,57.77 214.46,57.77 214.47,57.78 216.58,57.78 216.98,58.17 216.98,58.41 v2(216.98,58.41)
  IN3 w0.254: v2(216.98,58.41) 216.98,58.16 218.08,57.06 218.08,52.08 217.75,51.75 217.75,50.07 217.86,49.97 v2(217.86,49.43)
+3VS_PWR: length 35
  TOP w0.254: v2(210.78,177.46) 210.91,177.33 PCON702.2 210.91,174.94 v1(210.9,174.94) ; CON402.18 186.7,175.05 v2(187.05,174.7) 187.05,174.35 PC700.1
  IN2 w0.254: v2(210.78,177.46) 209.5,177.46 207.04,179.92 189.39,179.92 188.37,178.9 188.37,176.02 v2(187.05,174.7)
+3VS_S0: length 33.1
  TOP w0.254: v2(227.57,38.7) 227.82,38.95 R1111.2 ; U1101.H9 244.4,35.05 v4(244.72,35.37) ; R1130.2 v2(243.06,43.15)
  IN1 w0.254: v4(244.72,35.37) 244.72,35.43 245.17,35.87 245.57,35.87 245.61,35.83 246.37,35.83 246.86,36.32 246.86,37.45 244.62,39.69 244.62,42.77 244.25,43.15 v2(243.06,43.15)
  IN3 w0.254: 246.61,36 245.35,36 v4(244.72,35.37)
  IN3 w0.508: 246.61,36 247.54,36 v2(248.84,37.3)
  IN4 w0.254: 228.18,38.93 228.18,41.56 229.59,42.97 v2(229.81,42.97)
  BOTTOM w0.254: C1188.1 244.78,35.31 v4(244.72,35.37) 244.72,35.42 245.54,36.24 246.24,36.24 246.72,36.72 R1134.2 ; v2(229.81,42.97) 229.8,42.98 R1144.2
  BOTTOM w0.381: v2(232.54,38.19) 232.54,38.11 232.72,37.94 R1143.2 235.71,38.55 235.56,38.7 R1109.2 R1110.2
  vias: v1(254.28,38.09) v2(226.94,38.7) v3(249.61,37.18)
+3VS_S0_TBT: length 1.2
  TOP w0.254: v4(241.5,33.42) 241.18,33.1 U1101.R13
  BOTTOM w0.406: C1187.1 241.64,33.55 v4(241.5,33.42)
  vias: v1(232.28,36.72) v2(234.52,36.65)
+3VS_SSD: length 8.5
  BOTTOM w0.305: CON5103.4 53.55,51.6 53.54,51.61 53.21,51.61 53.01,51.4 ; 52.58,51.53 53.15,52.1 CON5103.2 ; CON5103.72 55.79,34.6 55.93,34.46 55.93,33.93 ; 56.36,34.03 56.36,34.69 55.95,35.1 CON5103.70
  vias: v1(50.88,29.79) v1(52.81,29.76) v2(51.92,48.02) v2(52.5,50.3) v2(52.57,48.02) v2(53.2,50.3) v2(53.19,48.02) v2(54.52,33.45) v2(55.14,33.44) v2(55.76,33.43) v3(44.48,50.45) v3(45.35,50.45) v3(46.22,50.45)
+3VS_SSD_PCIE: length 21.2
  TOP w0.254: v2(57.07,31.56) 56.82,31.56 54.68,29.42 R5115.1
  IN1 w0.254: v2(57.07,31.56) 60.02,31.56 60.25,31.79 63.33,31.79 64.44,32.9 v2(64.44,33.57)
  BOTTOM w0.305: 63.87,52.1 CON5102.2 ; 64.01,48.28 64.19,48.1 CON5102.18 ; 63.86,51.6 CON5102.4 ; 63.94,48.6 CON5102.16 ; 63.89,49.1 CON5102.14 ; 64.02,49.6 CON5102.12
  vias: v1(67.08,29.99) v2(62.66,50.5) v2(63.28,50.5) v2(63.92,50.51) v2(65.1,33.55) v2(65.71,33.55)
+3VS_TP: length 141.1
  TOP w0.254: R3072.1 R3073.1 121.78,23.89 121.56,24.11 121.56,26.04 122.07,26.55 v2(122.07,28.22) ; R2313.1 175.12,35.7 175.12,34.4 175.11,34.39 175.11,33.73 R2312.1 175.09,33.24 174.82,32.97 174.82,32.09 175.16,31.75 v2(175.23,31.75)
  TOP w0.508: v2(222.45,43.67) 223.04,43.67 R3170.1
  IN1 w0.254: v2(122.07,28.22) 134.14,28.22 134.82,28.91 151.88,28.91 152.66,29.68 160.03,29.68 161.3,28.41 165.84,28.41 166.98,29.56 168.91,29.56 v2(169.05,29.42)
  IN1 w0.508: v2(175.23,31.75) 175.23,31.35 174.28,30.4 171.83,30.4 170.95,29.51 169.15,29.51 v2(169.05,29.42) ; v2(209.86,40.23) 210.6,40.96 210.6,44.89 211.98,46.27 214.7,46.27 215.59,47.17 218.11,47.17 219.95,45.32 219.95,44.32 220.6,43.67 v2(222.45,43.67)
  IN2 w0.381: v2(165.28,30.73) 166.24,30.73 167.31,29.66 168.81,29.66 v2(169.05,29.42)
  IN2 w0.508: v2(209.86,40.23) 209.13,39.5 209.13,36.47 208.15,35.49 205.38,35.49 204.67,34.78 202.94,34.78 202.39,34.23 201.15,34.23 201.01,34.38 200.07,34.38 199.5,33.8 196.51,33.8 194.14,31.44 190.75,31.44 189.96,30.65 177.96,30.65 176.85,31.75 v2(175.23,31.75)
  BOTTOM w0.381: Q2301.1 164.71,30.73 165.21,30.73 v2(165.28,30.73)
  BOTTOM w0.508: R3169.2 226.11,46.09 226.37,45.84 226.37,45 225.92,44.55 v1(225.92,43.6) 225.47,43.6 224.94,44.13 R3166.2 C3104.1 222.91,44.13 v2(222.45,43.67)
+3VS_TPM: length 30.3
  TOP w0.254: C6204.1 181.6,20.83 177.66,20.83 v1(177.47,20.64) 176.81,20.64 176.42,21.03 176.42,22.99 178.12,24.69 ; C6204.1 182.09,20.8 182.17,20.87 U6200.19 ; C6204.1 182.1,20.33 182.7,19.73 183.59,19.73 183.92,20.06 183.92,20.54 184.23,20.84 184.89,20.84 C6203.1 ; U6200.24 185.42,20.36 C6203.1 ; C6203.1 C6205.1
  TOP w0.381: U6200.10 182.17,29.61 C6202.1
  TOP w0.508: 178.12,24.69 178.12,28.6 178.55,29.02 R6202.2 179.21,30.38 179.67,29.93 C6206.1 181.85,29.93 C6202.1
+3VS_TYPEC: length 21.9
  TOP w0.203: U1201.B1 239.19,47.9 239.19,47.82 ; C1203.1 243.2,47.09 243.03,47.09 242.57,47.55 242.57,48.22 242.99,48.63 U1201.H1
  TOP w0.254: v1(231.38,49.88) 231.55,49.88 231.86,49.57 R1228.2
  TOP w0.432: 239.19,47.82 238.91,47.54 v2(238.18,47.54) 237.64,47.54 C1204.1
  TOP w0.508: R1230.2 R1228.2 ; R1230.2 R1232.2 R1231.2 v2(235.71,49.57) ; R1230.2 233.3,49.21 233.63,48.88 R1227.2 ; v2(242.68,45.98) 242.85,45.98 243.53,46.66 C1203.1
  IN1 w0.508: v2(242.68,45.98) 242.41,45.98 241.82,45.39 239.72,45.39 238.18,46.93 v2(238.18,47.54) 237.57,47.54 235.71,49.4 v2(235.71,49.57)
+3VS_VGA: length 15.1
  TOP w0.254: R4625.1 243.76,99.99 R4623.1
  TOP w0.279: U4601.12 248.42,102.55 v2(248.62,102.35) ; C4636.2 249.78,110.56 248.64,110.56 248.42,110.34 U4601.25 ; v2(244.27,112.49) 244.27,111.9 244.09,111.73 C4612.1 244.09,111.4 244.92,110.57 U4601.32 ; U4601.6 v2(245.42,102.33) ; v2(242.62,102.33) 242.92,102.63 U4601.1 ; v2(242.24,110.29) 242.28,110.33 242.79,110.33 242.92,110.2 U4601.36 ; R4627.1 v2(251.64,111.85)
  TOP w0.381: C4636.2 249.68,111.22 v2(249.38,111.22) ; R4621.1 239.9,111.35 v2(239.19,111.35) 238.43,111.35 238.05,110.96 R4601.1
  TOP w0.406: R4623.1 v2(244.53,99.41)
  BOTTOM w0.102: v2(244.53,99.41) v1(243.81,99.41)
  vias: v2(239.07,113.25) v2(239.07,112.62) v2(251.63,112.64) v2(256.46,104.61) v2(256.46,103.98) v2(258.12,95.98) v2(258.12,95.34)
+3VSUS: length 664.9
  TOP w0.203: v2(179.23,54.28) 179.25,54.28 180.03,55.06 180.34,55.06 181.05,55.77 181.56,55.77 181.89,55.44 181.89,55.26 182.15,55.01 C2616.1 C2617.1 183.19,54.77 v2(182.68,54.27)
  TOP w0.254: R2428.1 191.41,44.85 v2(191.95,44.85) ; R2411.1 186.18,51.5 186.03,51.65 R2410.1 v2(186.61,52.08) ; v2(186.61,44.85) 186.23,44.85 186.03,44.64 R2435.1 ; R2472.1 185.25,42.77 v2(185.25,42.75) ; R2316.1 172.46,32.65 v2(172.46,32.65) ; v2(167.56,35.32) R2108.1 R2119.1 ; 184.02,32.65 v2(184.02,32.66) 184.02,32.73 R2334.1 R2328.1 ; v2(192.2,49.57) 191.85,49.57 R2335.1 ; v2(189.41,60) v2(189.41,58.87) 189.02,58.87 R2442.1 ; R2407.1 194.64,48.27 195.25,48.88 195.25,49.67 194.92,50 R2406.1 192.58,51.07 v2(192.2,51.07) ; v2(174.42,35.32) R2303.1 ; R2370.1 178.16,31.98 178.56,32.39 178.56,32.84 178.66,32.95 R2331.1 ; R2331.1 177.99,33.24 177.97,33.26 v2(177.98,33.26) ; R2331.1 R2333.1 R2330.1 R2327.1 ; R2315.1 176.48,35.36 176.52,35.33 v2(176.52,35.32) ; R2422.1 186.51,52.97 v2(186.61,53.08) ; v2(177.53,35.33) 177.5,35.37 R2372.1 ; v2(186.61,46.37) R2431.1 R2401.1 ; R2107.1 v2(169.6,35.32) ; R2378.1 186.98,72.42 188.08,72.42 188.36,72.14 ; 191.95,42.61 191.9,42.56 191.36,42.56 R2416.1 ; 191.95,42.61 v2(191.95,43.98) ; 191.95,42.61 v2(191.95,42.56) ; R2447.1 181.28,66.36 v2(181.28,65.41) ; U9201.5 145.8,50.45 144.96,51.28 144.96,52.61 144.77,52.8 143.64,52.8 143.43,53.01 143.43,54.14 142.8,54.77 141.32,54.77 139.92,56.17 139.08,56.17 138.48,55.57 v2(138.48,53.87) 138.48,53.59 138.01,53.11 136.37,53.11 135.95,52.69 135.95,52.27 135.33,51.65 R9202.1 134.8,51.12 134.72,51.04 U9200.5 134.13,50.32 133.94,50.13 v2(133.94,49.78) ; v2(170.87,35.33) R2105.1 ; v2(189.28,49.16) 189.15,49.04 187.63,49.04 186.87,48.27 R2418.1 ; v2(165.79,35.32) R2164.1 ; v2(191.95,43.98) v2(191.95,44.85) ; v2(191.95,43.98) 191.39,43.98 R2467.1 ; v2(191.95,44.85) v2(191.95,45.86) 191.95,46.09 191.36,46.68 R2429.1 ; v2(189.31,44.85) 189.31,45.53 189.11,45.73 R2434.1 R2432.1 R2402.1 ; R2248.1 v2(160.45,34.81) ; R2309.1 173.3,32.6 v2(173.29,32.59) ; R2304.1 v2(173.53,35.32) ; R2123.1 156.9,34.46 v2(156.9,35.32) R2243.1 ; R2122.1 R2125.1 v2(164.9,35.32) 164.5,34.93 164.5,33.79 164.47,33.75 164.49,33.73 164.49,33.72 R2113.1 ; R2471.1 R2473.1 188.96,42.4 189.39,42.81 v2(189.39,42.81) ; v2(172.64,35.32) R2302.1
  TOP w0.305: R2259.1 165.25,40.95 v2(165.25,40.08)
  TOP w0.356: U0703.5 113.16,51.88 113.08,51.8 C0703.2 111.89,51.29 111.7,51.1 U0702.5
  TOP w0.432: v2(115.51,49.42) 115.51,49.51 114.52,50.5 114.52,50.95 114.19,51.29 C0702.1 C0703.2
  TOP w0.508: v2(188.04,78.28) 190.09,80.33 193.01,80.33 194.13,79.21 198.69,79.21 199.7,80.22 199.7,81.45 200.11,81.87 202.88,81.87 203.19,81.56 JP8109.1 ; R2617.2 172.34,68.92 172.19,69.07 C2621.1 172.82,71.09 172.82,71.5 173.22,71.9 173.84,71.9 174.17,72.23 174.17,77.96 174.68,78.47 180.25,78.47 180.53,78.76 180.53,79.42 181.01,79.9 v2(181.01,80.17) ; C2611.1 189.93,67.92 191.06,69.05 v2(191.06,70.5) 191.06,70.5 189.99,70.5 188.36,72.14 ; v2(187.35,32.2) 187.45,32.1 189.67,32.1 190.39,31.37 R3162.2 ; v2(245.42,55.97) 245.59,56.15 246.43,56.15 246.76,56.48 R5208.1 ; SP2601.2 v2(194.74,44.85) ; R2615.2 184.04,40.17 v2(184.05,40.18) ; v2(229.06,53.46) 229.06,52.14 229.29,51.91 230.16,51.91 230.42,51.66 230.42,49.95 231.21,49.15 231.6,49.15 231.99,48.76 231.99,48.42 232.82,47.59 233,47.59 v2(233.24,47.35)
  TOP w1.524: 215.32,89.07 214.62,88.37 212.94,88.37 209.75,85.18 208.54,85.18 206.64,83.29 206.64,80.53
  IN1 w0.508: v2(185.25,42.75) 185.25,41.38 v2(184.05,40.18) ; v2(229.06,53.46) 229.06,53.62 229.67,54.23 234.95,54.23 239.73,59 244.41,59 244.55,59.15
  IN1 w1.016: 243.84,89.07 245.58,89.07 246.95,87.7 246.95,79.99 243.92,76.96 243.92,74.92 245.43,73.41 245.43,72.46 246.2,71.68 246.2,65.55 244.55,63.9 244.55,59.15 245.16,58.54 245.16,56.23 v2(245.42,55.97) ; 184.67,33.32 187.86,36.5 187.86,36.52 187.87,36.53 187.87,40.52 188.42,41.06
  IN2 w0.102: 189.32,54.33 189.82,54.33 ; 186.94,43.5 187.3,43.65
  IN2 w0.508: v2(160.45,34.81) 160.45,35.95 160.51,36.01 ; v2(133.94,49.78) 133.8,49.91 130.06,49.91 128.95,48.8 123.76,48.8 123.19,48.23 118.61,48.23 118.4,48.43 116.22,48.43 115.51,49.14 v2(115.51,49.42) ; v2(164.9,35.32) 164.21,36.01 160.51,36.01 ; v2(143.08,34.33) 143.46,34.71 147.75,34.71 149.09,36.05 156.17,36.05 v2(156.9,35.32) 157.58,36.01 160.51,36.01 ; v2(185.24,67.61) 184.63,67 182.2,67 181.28,66.08 v2(181.28,65.41) ; v2(229.06,53.46) 228.62,53.9 222.98,53.9 v2(222.81,53.72)
  IN3 w0.508: v2(197.79,68.65) 197.79,70.02 197.16,70.66 197.16,71.05 196.81,71.39 193.32,71.39 192.43,70.5 v2(191.06,70.5) ; v2(17.31,80.07) 17.31,80.19 17.83,80.71 20.5,80.71 22.67,78.54 22.67,74.97 22.91,74.73 22.91,71.77 22.3,71.16 22.3,67.94 23.15,67.09 23.15,64.27 23.1,64.21 23.1,62.88 26.14,59.85 26.14,57.74 29.64,54.23 29.64,50.64 31.95,48.33 31.95,43.92 32.69,43.18 32.69,37.47 34.23,35.93 48.56,35.93 49.09,36.46 81.49,36.46 81.77,36.18 102.53,36.18 104.14,34.57 118.42,34.57 118.5,34.49 123.82,34.49 125.07,33.24 134.92,33.24 135.61,32.55 140.03,32.55 141.03,33.55 142.44,33.55 143.08,34.2 v2(143.08,34.33)
  IN4 w0.254: v2(186.61,53.08) v2(186.61,52.08) 186.61,50.81 186.87,50.56 ; v2(192.2,49.57) 191.31,49.57 190.96,49.93 189.54,49.93 189.28,49.67 v2(189.28,49.16) 187.88,50.56 186.87,50.56 ; 186.87,50.56 186.61,50.31 v2(186.61,50.05)
  IN4 w0.305: v2(165.25,40.08) 165.25,35.6
  IN4 w0.508: v2(188.04,78.28) 186.88,78.28 185.71,77.11 183.64,77.11 183.01,77.73 183.01,78.17 v2(181.01,80.17) ; v2(17.31,80.07) 17.31,81.59 13.49,85.41 10.57,85.41 9.73,86.25 9.73,88.33 7.21,90.85 7.21,113.17 6.63,113.76 v2(6.4,113.76)
  IN4 w1.524: 242,89.99 239.93,92.06 236.4,92.06 235.84,91.51 231.99,91.51
  BOTTOM w0.203: U2000.BA20 179.23,53.95 179.23,54.28 v2(179.23,54.28)
  BOTTOM w0.254: R2444.1 189.17,59.11 v2(189.41,58.87) ; v2(189.28,52.57) 189.28,52.85 189.15,52.97 R2408.1 R2409.1 ; v2(194.77,43.16) 194.55,42.94 R2463.1 R2415.1 ; R2115.1 164.9,34.1 v2(164.9,35.32) R2125.1 ; v2(138.48,53.87) 140.18,52.16 140.18,48.67 137.34,45.83 137.34,41.01 143.08,35.27 v2(143.08,34.33) ; R4411.1 9.83,116.93 6.91,114.01 6.66,114.01 v2(6.4,113.76) ; v2(173.29,32.59) 173.25,32.63 173.25,33.24 ; R2420.1 v2(186.61,53.08) ; R2164.1 v2(165.79,35.32) ; v2(189.41,60) 189.37,59.96 R2446.1 R2445.1 ; R2120.1 169.93,32.71 v2(170,32.64) ; U2403.5 191.84,69.28 191.9,69.34 C2404.2 191.9,70.32 191.72,70.5 v2(191.06,70.5) 189.52,70.5 188.94,71.08 188.94,71.82 188.24,72.52 188.24,73.18 187.92,73.5 187.92,75.75 188.04,75.86 v2(188.04,78.28) ; R2108.1 v2(167.56,35.32) ; R2400.1 186.41,50.26 v2(186.61,50.05) ; R2412.1 R2423.1 186.51,52.19 v2(186.61,52.08) ; v2(173.53,35.32) R2304.1 ; R2466.1 192.46,42.05 v2(191.95,42.56) ; R2103.1 R2104.1 ; R2103.1 173.25,33.24 ; R2103.1 172.43,32.68 v2(172.46,32.65) 172.18,32.36 R2381.1 ; v2(176.52,35.32) 176.52,35.55 176.43,35.64 R2319.1 ; v2(184.02,32) 183.24,32 182.87,32.36 182.87,32.92 R2332.1 R2327.1 R2369.1 ; R2318.1 177.65,35.44 v2(177.53,35.33) ; 173.25,33.24 R2102.1 ; R2414.1 191.95,42.28 v2(191.95,42.56) ; R2437.1 191.82,45.73 v2(191.95,45.86) ; R3621.1 14.22,78.78 14.53,79.09 16.59,79.09 16.97,79.47 16.97,79.72 v2(17.31,80.07) ; R2417.1 191.92,42.59 v2(191.95,42.56) ; v2(184.02,32.66) 184.02,32.81 R2329.1 ; R2107.1 v2(169.6,35.32) ; v2(191.95,43.98) R2470.1 ; v2(177.98,33.26) 177.97,33.26 178,33.24 178.11,33.24 178.12,33.25 R2314.1 ; v2(170.87,35.33) R2105.1 ; v2(175.31,32.64) 175.67,32.99 R2363.1 R2317.1 ; R2433.1 194.62,44.72 v2(194.74,44.85) 194.74,44.84 194.9,44.84 195.38,44.37 195.38,44.26 R2464.1 ; R2371.1 v2(180.52,35.32) ; v2(192.2,51.07) 192.03,51.24 R2421.1 ; v2(172.64,35.32) R2302.1 ; v2(181.41,35.32) R2358.1 ; v2(174.42,35.32) R2100.1 ; v2(191.95,44.85) R2469.1
  BOTTOM w0.356: U2402.5 194.91,68.25 195.25,67.91 C2405.2 196.22,68.27 196.4,68.46 197.6,68.46 v2(197.79,68.65)
  BOTTOM w0.406: U2404.5 202.32,46.74 201.3,45.71 198.35,45.71 v2(198.25,45.61)
  BOTTOM w0.508: v2(245.42,55.97) 245.64,55.75 245.64,49.43 246.65,48.42 246.65,44.1 248.25,42.5 248.25,41.01 ; v2(186.61,46.37) R2431.1 ; R3167.1 220.6,53.54 221.23,54.17 222.36,54.17 v2(222.81,53.72) 223.18,54.09 226.07,54.09 ; v2(183.52,34.88) 183.53,34.88 183.79,35.15 183.79,35.26 R2603.1 ; R3309.1 222.14,92.85 v2(221.31,92.85) ; R2436.1 v2(186.61,44.85) ; R2465.1 v2(189.31,44.85)
  vias: v3(201.02,65.4) v3(215.19,90.39) v3(216.1,90.39) v3(243.61,89.68) v3(243.59,88.81)
+3VSUS_LAN: length 43
  TOP w0.229: U3300.1 230.54,91.56 230.77,91.33 v2(230.77,91.08) ; v2(227.69,96.53) U3300.16
  TOP w0.254: v2(238.75,87.77) R3307.1 238.1,88.36 238.05,88.41 R3301.2
  IN3 w0.508: v2(227.69,96.53) 228.28,97.12 232.59,97.12 233.07,97.6 233.51,97.6 234.16,96.96 234.16,96.14 233.43,95.4 233.43,94.61 233.78,94.25 233.78,92.94 233.81,92.92 233.81,92.41 233.37,91.97 231.66,91.97 v2(230.77,91.08)
  IN4 w0.508: v2(238.75,87.77) 237.46,87.77 235.37,85.68 230.04,85.68 228.68,87.04 228.68,88.38 230.77,90.48 v2(230.77,91.08)
  BOTTOM w0.508: C3312.1 231.32,90.94 ; v2(227.69,96.53) v1(227.08,95.93) 226.75,95.6 C3322.1 225.24,95.1 C3309.1 224.59,94.25 224.24,93.9 C3311.1 R3309.2
+3VSUS_LC: length 21.5
  TOP w0.254: U1101.R6 240.83,36.67 v4(240.82,36.67)
  IN4 w0.254: v4(240.82,36.67) 240.82,37.57 239.7,38.69 237.8,38.69 237.33,38.21 236.39,38.21 235.52,39.08 235.52,40.22 235.51,40.24 235.51,40.47 234.15,41.83 233.18,41.83 232.08,42.94 v2(232.08,43.02)
  BOTTOM w0.254: v2(232.08,43.02) 232.08,42.95 231.39,42.26 R1114.1 R1115.1 R1113.1 231.5,40.48 231.89,40.86 232.79,40.86 R1112.1 ; v4(240.82,36.67) 240.82,37.74 240.61,37.94 C1185.1 240.34,37.94 240,38.27 v1(240,39.44)
+3VSUS_PGPPA: length 49.1
  TOP w0.508: SP2601.1 193.47,44.49 193.78,44.8 C2630.1 194.17,45.57 194.41,45.57 v2(194.62,45.77) 194.89,46.05 194.89,46.88 v1(194.78,46.99) 194.52,47.26 R2239.1
  IN1 w0.254: v2(189.54,54.75) v2(189.54,53.91)
  IN1 w0.381: v2(193.22,52.44) 194.2,51.46 194.2,48.27 194.2,48.27 194.2,46.19 v2(194.62,45.77)
  IN4 w0.254: v2(186.61,56.2) 186.6,56.19 v2(186.6,55.35) 186.6,55.27 187.12,54.75 v2(189.54,54.75) v2(191.95,54.75)
  IN4 w0.381: v2(193.22,52.44) 192.94,52.44 192.17,53.21 191.62,53.21 191.26,53.56 191.26,54.07 v2(191.95,54.75)
  IN4 w0.508: v2(179.13,47.3) 179.13,47.54 179.51,47.92 180.02,47.92 182.45,45.48 187.52,45.48 187.96,45.04 187.96,43.97 188.51,43.43 190.6,43.43 190.74,43.28 192.77,43.28 193.98,44.49 193.98,45.14 v2(194.62,45.77)
  BOTTOM w0.254: R2250.1 v2(186.61,56.2) ; U2000.BA31 179.45,47.76 179.13,47.45 v2(179.13,47.3) ; v2(189.54,53.91) 189.49,53.86 R2242.1 ; R2241.1 R2238.1 R2240.1 191.69,55.01 v2(191.95,54.75) ; R2237.1 v2(189.54,54.75) ; R2236.1 v2(186.6,55.35)
+3VSUS_SPI: length 50.5
  TOP w0.508: v2(199.24,26.13) 199.65,26.13 199.85,25.93 ; R3124.1 195.91,26.23 195.91,24.76 ; 199.85,25.93 199.85,24.81 198.85,23.81 v1(198.22,23.81) 197.72,23.81 C3100.1 195.91,24.76 ; 199.85,25.93 200.33,25.93 200.63,26.24 200.63,31.13 200.79,31.29 C3101.1 199.57,31.79 199.19,32.18 U3101.8 199.19,34.47 198.98,34.67 197.49,34.67 196.78,35.39 196.78,37.63 197.42,38.27 199.16,38.27 200.1,39.21 200.1,42.05 199.14,43.01 199.14,43.88 198.73,44.29 197.31,44.29 R3116.1 ; 195.91,24.76 194.79,23.63 D3104.3
  IN3 w0.508: v2(199.24,26.13) 204.4,26.13 205.87,27.6 v2(206.58,27.6)
  BOTTOM w0.254: CON4402.1 205.86,27.85 205.46,28.25 C4404.2 205.44,28.48 204.86,27.83 CON4402.3
  BOTTOM w0.432: v2(206.58,27.6) 206.58,27.81 205.91,28.48 C4404.2
+3VSUS_SX: length 34.1
  TOP w0.254: R1135.2 R1132.2 ; R1132.2 229.78,43.91 229.44,44.25 229.44,45.89 230.12,46.58 R1131.2 ; R1132.2 230.51,43.45 230.84,43.11 230.84,42.85 231.18,42.51 232.44,42.51 R1146.2 R1161.1 232.36,41.37 v2(231.95,41.37) ; R1140.2 239.42,43.13 239.19,43.36 v2(239.19,43.53) ; v2(237.62,43.43) 237.62,42.87 R1141.2 ; U1101.F8 245.06,35.7 v4(245.37,35.39)
  IN1 w0.508: v4(245.37,35.39) 245.37,34.99 245.05,34.67 243.83,34.67 243.41,35.09 243.41,38.11 242.94,38.58 240.53,38.58 239.96,39.14 237.44,39.14 236.83,39.76 236.83,42.56 237.44,43.17 237.44,43.25 v2(237.62,43.43)
  BOTTOM w0.254: R1138.2 235.84,42.59 ; 235.51,44.16 235.16,44.16 234.36,44.97 233.07,44.97 232.45,45.59 232.45,46.52 R1145.2
  vias: v1(235.76,43.4)
+3VSUS_TPM: length 6.2
  TOP w0.203: R6201.2 v1(182.83,29.93)
  TOP w0.305: R6201.2 C6201.1 185.34,29.93 185.57,30.16 186.22,30.16 C6200.1 186.23,29.33 186.03,29.13 185.57,29.13 185.42,28.97 U6200.5
+5V_FAN0: length 2.2
  BOTTOM w0.508: v2(28.3,118.24) 29.47,118.24 29.87,117.85 C5003.1
  vias: v1(27.94,119.35)
+5V_FAN1: length 18.6
  BOTTOM w0.508: v3(183.55,79.5) 182.66,78.61 175.13,78.61 174,77.49 174,75.79 173.76,75.55 C5001.1 173.76,74.18 174.88,73.05 CON5001.4
  vias: v1(183.74,76.87)
+5V_LED: length 3.8
  TOP w0.254: CON1.6 184.55,156.98 v1(184.03,156.46) 184,156.43 183.1,156.43 182.59,156.95 LR800.2
+5V_LED_RLED1_Q2: length 6.3
  TOP w0.254: v1(188.16,156.74) 189.51,156.74 v2(190.17,157.4) LQ803.3
  BOTTOM w0.254: LLED802.2 192.3,158.19 191.51,157.4 v2(190.17,157.4)
+5V_LED_RLED2: length 7.2
  TOP w0.102: v2(194.62,159.59) 194.62,158.99 v1(194.72,158.89)
  TOP w0.254: LR802.1 197.05,162.02 v2(194.62,159.59)
  BOTTOM w0.254: LLED802.1 192.85,159.95 193.22,159.59 v2(194.62,159.59)
+5V_RLED1: length 6.8
  TOP w0.254: v1(180.69,156.44) 180.69,156.77 181.25,157.32 LR800.1 181.25,158.02 181.47,158.24 v2(181.84,158.24)
  BOTTOM w0.254: LLED800.1 178.83,159.95 179.96,158.82 181.23,158.82 181.84,158.21 v2(181.84,158.24)
+5V_RLED1_Q: length 6.7
  TOP w0.254: v2(177.09,157.83) LQ800.3 173.71,157.83 173.38,157.5 v1(172.67,157.5)
  BOTTOM w0.254: LLED800.2 178.3,158.13 178,157.83 v2(177.09,157.83)
+5V_RYLED_R: length 14.4
  TOP w0.254: v1(174.22,161.06) LQ801.3 v2(176.96,161.06)
  IN1 w0.254: v2(186.61,159.73) 185.57,159.73 184.5,160.81 177.21,160.81 v2(176.96,161.06)
  BOTTOM w0.254: v2(186.61,159.73) 186.61,159.2 186.36,158.94 LLED801.2
+5V_RYLED_R1: length 18.4
  TOP w0.254: LR803.1 174.17,161.69 174.3,161.82 v2(174.3,162.32) 174.21,162.4 v1(170.87,162.4)
  BOTTOM w0.254: v2(174.3,162.32) 174.31,162.33 184.84,162.33 185.81,161.36 LLED801.1
+5V_RYLED_Y: length 13.9
  TOP w0.254: v2(193.65,161.05) LQ802.3 195.06,161.05 v1(196.37,162.36)
  BOTTOM w0.254: LLED803.2 184.8,158.5 185.09,158.21 186.88,158.21 188.56,159.89 189.18,159.89 190.33,161.05 v2(193.65,161.05)
+5V_RYLED_Y1: length 8.8
  TOP w0.254: v1(180.49,158.9) 180.69,159.1 180.69,161.27 v2(180.54,161.42) 180.54,161.75 180.24,162.05 LR801.1
  BOTTOM w0.254: LLED803.1 183.88,160.88 181.08,160.88 v2(180.54,161.42)
+5V_USB:
  vias: v1(252.02,61.02) v3(258.77,66.3) v3(258.77,65.37) v3(259,67.15)
+5VA: length 478.8
  TOP w0.508: 224.79,70.86 225.35,71.42 225.35,80.91 226.37,81.93 231.49,81.93 235.18,85.62 239.57,85.62 R5302.2
  IN1 w0.508: v2(14.7,182.61) 15.38,181.93 19.08,181.93 21.34,179.67 37.47,179.67 38.21,180.41 42.04,180.41 42.34,180.12 v2(42.34,179.8) ; v2(69.77,35.32) 51.92,35.32 51.51,34.92 45.73,34.92 45.4,35.24 41.35,35.24 40.53,34.43 34.98,34.43 v2(34.67,34.74) ; v2(38.33,50.86) 35.48,50.86 30.75,55.59 30.75,56.85 27.79,59.81 27.79,66.46 24.79,69.46 24.79,70.66 23.96,71.49 23.96,77.22 20.14,81.03 11.74,81.03 11.25,81.52 9.46,81.52 8.06,82.92 6.8,82.92 6.03,82.15 4.62,82.15 4.23,82.54 v2(3.92,82.54)
  IN2 w0.508: v2(3.92,82.54) 3.92,84.32 4.27,84.66 4.27,91.37 5.83,92.93 5.83,107.1 5.79,107.14 5.79,111.47 4.54,112.72 4.54,124.53 3.45,125.62 3.45,139.75 6.7,142.99 6.7,143.26 7.77,144.33 7.77,146.4 6.58,147.59 6.58,173.24 3.25,176.57 3.25,181.5 4.37,182.61 v2(14.7,182.61) ; v2(223.55,69.77) 223.98,69.33 223.98,66.08 221.33,63.43 221.33,59.45 218.77,56.88 218.77,52.46 216.33,50.03 216.33,49.53 215.03,48.23 215.03,45.88 214.75,45.6 214.75,43.91 214.34,43.5 214.01,43.5 213.08,42.57 213.08,41.93 211.23,40.07 211.23,35.65 210.73,35.15 209.53,35.15 208.64,34.26 205.87,34.26 205.18,33.56 203.44,33.56 202.63,32.75 201.82,32.75 201.34,32.27 199.67,32.27 198.44,31.04 195.51,31.04 194.69,30.22 191.26,30.22 190.47,29.43 176.86,29.43 175.84,30.45 167.64,30.45 166.45,31.64 166.45,32.86 165.84,33.47 151.11,33.47 150.68,33.9 144.1,33.9 143.64,33.44 140.92,33.44 140.03,32.55 137.11,32.55 134.42,35.25 126.14,35.25 124.73,33.83 122.65,33.83 121.93,33.11 115.69,33.11 115.19,33.61 115.19,34.04 114.64,34.59 111.53,34.59 111.48,34.53 98.33,34.53 96.92,35.95 70.4,35.95 v2(69.77,35.32)
  IN4 w0.508: v2(34.67,34.74) 32.89,36.52 32.89,38.7 33.58,39.39 33.88,39.39 36.04,41.55 36.04,45.13 37.85,46.93 37.85,50.38 v2(38.33,50.86)
  BOTTOM w0.279: v2(42.34,179.8) 42.34,179.29 42.75,178.88 CON5602.27
+5VA_LED: length 18.1
  TOP w0.254: v2(180.18,159.85) 180.18,160.53 180,160.71 LR801.2 ; LR803.2 171.18,161.69 v2(171.12,161.64) 170.99,161.51 v1(170.99,160.49) ; CON1.7 184.05,158.31 183.9,158.47 v2(183.08,158.47)
  IN1 w0.254: v2(183.08,158.47) 181.69,159.86 180.19,159.86 v2(180.18,159.85) 176.74,159.85 174.91,161.69 171.18,161.69 v2(171.12,161.64)
+5VA_PWR: length 15.7
  TOP w0.254: PCON700.2 174.5,170.75 174.96,170.29 181.4,170.29 v1(181.97,170.86) 182.2,171.09 CON402.27
+5VO: length 216.2
  TOP w0.203: U9103.4 234.78,61.48 234.54,61.71 233.58,61.71 ; U9103.6 234.66,60.68 ; C9114.1 U9101.4 ; U9103.7 234.68,60.28
  TOP w0.381: v2(135.6,68.18) 134.76,68.18 134.51,67.92 SR8302.1
  TOP w0.432: C9132.1 234.82,59.81 ; C9114.1 196.6,70.2 v2(196.67,70.12)
  TOP w0.508: R8400.1 176.45,24.7 176.89,25.14 176.89,29.1 175.61,30.37 174.45,30.37 174.04,29.96 v2(174.04,29.61) ; v2(156.9,69.79) 159.11,67.58 v2(159.11,63.67)
  TOP w1.016: 225.99,65.3 226,65.29 ; 226,65.29 226.66,64.64 ; 226,65.29 213.21,65.29 v3(213.08,65.17)
  IN1 w0.508: v2(196.67,70.12) 202.77,70.12 207.72,65.17 v3(213.08,65.17) ; v2(156.9,69.79) 156.55,70.13 153.56,70.13 151.51,68.08 145.94,68.08 144.5,66.65 143.82,66.65 v2(142.95,65.78)
  IN2 w0.508: v2(196.67,70.12) 196.88,69.92 196.88,69.36 196.19,68.67 188.18,68.67 184.29,64.78 180.35,64.78 179.88,64.31 179.88,63.39 179.38,62.88 174.45,62.88 174.17,62.6 169.49,62.6 168.23,63.87 162.21,63.87 161.46,63.11 159.67,63.11 v2(159.11,63.67)
  IN3 w0.508: v3(213.08,65.17) 212.27,64.36 212.27,58.8 211.77,58.3 211.77,56.53 212.87,55.44 212.87,50.8 213.52,50.15 213.52,48.27 213.79,47.99 213.79,45.3 212.91,44.41 212.91,43.91 213.34,43.48 214.05,43.48 214.53,42.99 v2(214.53,42.44) 213.54,42.44 209.7,38.6 203.63,38.6 202.36,37.33 202.36,37.07 201.73,36.44 200.81,36.44 198.29,33.92 196.82,33.92 193.96,31.06 192.08,31.06 192.08,31.06 191.58,31.06 191.16,30.63 174.71,30.63 174.04,29.96 v2(174.04,29.61)
  IN4 w0.508: v2(142.95,65.78) 140.25,65.78 138.66,67.37 136.33,67.37 135.6,68.1 v2(135.6,68.18)
  BOTTOM w0.203: 143.69,64.4 U9100.4
  BOTTOM w0.254: U9102.4 219.21,85.23 v2(219.25,85.27)
  BOTTOM w0.457: 143.69,64.4 143.8,64.51 C9105.1 143.23,65.45 142.95,65.73 v2(142.95,65.78)
  BOTTOM w0.508: 216.57,36.51 216.57,34.75 216.88,34.44 216.88,33.82 217.43,33.27 218.76,33.27 219.47,32.56 R8820.2 ; 216.57,36.51 217.54,36.51 218,36.97 C8830.1 218.71,37.07 U8801.5 ; 216.57,36.51 216.57,36.75 215.42,37.89 215.42,41.87 214.86,42.44 v2(214.53,42.44)
  vias: v2(219.41,83.38) v3(226.26,80.36) v3(226.26,79.47) v3(226.26,78.58) v3(227.15,80.36) v3(227.15,79.47) v3(227.15,78.58) v3(228.27,80.91) v3(229.16,80.91) v3(230.05,80.91) v3(230.94,80.91) v3(230.94,80.02) v3(230.94,79.14)
+5VO_1_1:
  vias: v1(244.32,69.49)
+5VO_1_2:
  vias: v1(241.81,64.05)
+5VO_2_2:
  vias: v1(249.5,68.19)
+5VS: length 552.7
  TOP w0.254: C8070.2 69.94,169.06 69.13,169.06 68.83,168.76 U8003.29
  TOP w0.279: U8001.29 v2(46.31,172.98)
  TOP w0.305: C80082.2 12.43,164.72 U8006.29 ; v2(65.71,171.82) 65.94,171.82 66.71,171.05 U8003.3 ; U8004.3 21.88,172.15 v2(21.97,172.24) ; v2(9.07,167.15) 9.16,167.06 9.16,167.04 9.2,167.04 9.32,166.92 9.34,166.92 9.43,166.83 9.43,166.41 U8006.3 ; C80025.2 24.78,169.8 U8004.29 ; v2(32.44,175.61) 32.81,175.24 U8002.3 ; U8002.29 35.47,173.1 v2(35.47,173.11) ; U8001.3 43.73,175.29 43.69,175.33 v2(43.69,175.46) ; v2(21.97,172.24) 22,172.24 v2(21.97,172.24)
  TOP w0.381: v2(175.84,89.65) 175.72,89.78 R8905.1 ; v2(70.46,166.91) 70.64,167.09 C8070.2
  TOP w0.457: C80082.2 12.37,164.48 12.85,164 v2(12.85,163.82) ; C80025.2 24.92,169.76 25.25,169.44 v2(25.25,169.2)
  TOP w0.508: v3(33.58,41.77) 32.38,42.97 R5137.2 ; v2(245.14,80.66) 246.05,81.57 246.05,82.98 Q4804.2 ; R4314.2 100.09,178.66 99.01,177.58 96.25,177.58 95.59,178.24 R4313.1 ; v2(140.51,91.66) 140.51,95.09 141.4,95.98 141.4,96.61 142.67,97.88 143.11,97.88 143.12,97.9 ; R8714.2 152.43,83.61 v2(152.43,86.3) ; v2(198.37,26.1) 198.37,26.33 198.81,26.76 R3714.2
  TOP w0.762: 22.53,61.94 22.53,59.53 24.65,57.41 26.16,57.41 29.31,54.26 29.31,54.25 29.41,54.14 29.41,53.95 29.52,53.84 29.52,53.08 30.43,52.16 v2(30.66,52.16)
  TOP w1.016: v3(24.46,104.6) 24.84,104.6 26.06,103.39 26.06,100.76 24.73,99.44 24.73,97.11 21.74,94.12 20.36,94.12 17.84,91.6 17.84,85.32 16.4,83.88 13.63,83.88
  IN1 w0.508: v2(54.92,172.69) 54.92,171.67 53.77,170.53 51.23,170.53 v3(49.71,172.05)
  IN1 w1.016: 90.77,179.29 85.6,179.29 84.55,178.25 81.99,178.25 80.7,179.54 77.43,179.54 76,178.11 v3(76,174.76)
  IN2 w0.102: 250.65,48.28 250.9,48 ; 240.06,42.16 240.44,42.33
  IN2 w0.254: v2(9.07,167.15) 8.55,167.66 8.55,168.76 9.42,169.63 9.42,171.43 9.21,171.65 9.21,175.87 6.24,178.83 5.69,178.83 5.39,179.14 v2(5.39,181.5)
  IN2 w0.508: v2(140.51,91.66) 141.24,91.66 144.23,88.67 147.62,88.67 149.99,86.3 v2(152.43,86.3) ; v2(175.84,89.65) 176.07,89.65 178.26,87.46 179.46,87.46 181.38,85.54 184.13,85.54 186.22,83.46 188.71,83.46 v2(188.89,83.63)
  IN2 w1.016: 224.63,84.8 228.15,84.8 ; v3(76,174.76) 75.42,174.19 75.42,173.56 74.41,172.55 71.24,172.55 ; 225.22,81.81 227.76,81.81 ; 65.31,167.93 58.67,167.93 55.04,164.3 52.5,164.3 50.22,166.59 50.22,169.64 49.71,170.15 v3(49.71,172.05) ; v3(24.46,104.6) 25.83,105.97 25.83,117.01
  IN2 w3.048: 67.11,31.51 67.13,31.54 67.51,31.16 81.83,31.16 82.16,31.49 87.73,31.49 88.34,30.88 88.27,30.81 ; 199.31,23.38 207.89,23.38 210.36,25.85 214.4,25.85 216.35,27.8 218.57,27.8 ; 165.84,23.66 177.64,23.66 177.92,23.38 197.58,23.38 197.59,23.39 ; 147.31,25.69 148.33,26.71 152.4,26.71 155.73,23.38 158.04,23.38 ; 49.16,31.92 35.25,31.92
  IN3 w1.524: 31.42,52.93 33.07,51.27 33.07,45.19 34.3,43.96 34.3,43.57 34.3,43.57 ; 13.52,81.56 14.85,82.9 22.07,82.9 25.07,79.9 25.07,78.05 ; 28.27,58.08 27.25,59.09 27.25,60.4 26.21,61.44 ; 9.73,165.14 10.54,164.33 10.54,156.28 9.53,155.27 9.53,143.76 8.86,143.08 8.86,136.09 15.85,129.1 15.85,125.75 23.19,118.41 24.21,118.41 ; 24.64,67.53 24.64,64.55
  IN4 w0.254: v2(8.4,183.47) 8.4,182.88 8.29,182.77 6.66,182.77 v2(5.39,181.5)
  IN4 w0.508: v2(152.43,86.3) 153.02,86.3 153.52,86.8 153.52,87.44 155.83,89.76 171.92,89.76 172.93,88.75 175.24,88.75 175.58,88.42 177.89,88.42 179.68,86.63 180.75,86.63 182.5,84.88 183.21,84.88 184.2,83.89
  IN4 w1.016: 213.86,82.67 211.65,84.88 208.31,84.88 205.69,82.25 191.99,82.25 190.43,80.69 186.87,80.69
  BOTTOM w0.203: v1(19.3,167.63) 19.3,167.23 v2(18.82,166.74)
  BOTTOM w0.254: v2(9.07,167.15) 9.05,167.15 8.36,167.84 8.36,168.54 R8006.1 R8007.1 7.93,168.7 7.59,168.37 R8034.1 ; v2(141.22,26.19) 141.22,26.39 140.75,26.87 CON3110.1 ; CON3104.2 181.45,29.23 180.05,27.83 177.39,27.83 177.1,27.54 174.91,27.54 174.32,28.14 167.81,28.14 v3(165.5,25.83) ; v2(5.39,181.5) 5.39,181.17 R8032.1 ; v2(11.21,167.77) 12.28,167.77 12.8,168.29 12.8,169.72 R8008.1 ; v2(8.4,183.47) 8.35,183.43 SR8000.2 ; C80066.2 70.53,167.6 70.53,168.46 70.4,168.58 U8005.6
  BOTTOM w0.279: CON5602.26 42.25,176.49 42.36,176.38 43.67,176.38 43.86,176.2 43.86,175.62 v2(43.69,175.46)
  BOTTOM w0.305: v2(141.22,26.19) 141.82,26.78 141.82,27.53 141.35,28 140.46,28 140.25,27.78 CON3110.2
  BOTTOM w0.381: v2(24.83,177.93) 25.1,177.67 R8091.1 R8076.2 ; v2(70.46,166.91) C80066.2
  BOTTOM w0.432: v2(21.97,172.24) 21.97,172.44 22.03,172.5 R80103.1
  BOTTOM w0.457: D5000.3 39.64,113.47 38.95,114.15 34.64,114.15 29.76,119.02 28.18,119.02 26.55,117.39 v2(24.94,117.39) ; v2(9.07,167.15) 9.4,166.82 C80019.2 ; v2(21.97,172.24) 21.84,172.11 C80064.2
  BOTTOM w0.508: C8066.2 32.77,175.27 v2(32.44,175.61) ; v2(65.71,171.82) 65.87,171.98 C8067.2 ; v2(54.92,172.69) 55.25,173.02 C4543.1 55.68,173.41 56.38,174.11 U4502.3 ; R4503.1 50.71,173.05 v3(49.71,172.05) 48.95,172.81 46.79,172.81 46.62,172.98 v2(46.31,172.98) 46.03,173.26 C8068.2 44.3,173.57 43.69,174.18 C8065.2 v2(43.69,175.46) ; D5002.3 189.36,84.11 v2(188.89,83.63) ; C8069.2 35.15,173.45 35.47,173.13 v2(35.47,173.11)
  vias: v2(12.74,83.73) v2(13.01,78.63) v2(13.56,78.94) v2(18.82,166.13) v2(24.94,118) v2(24.94,116.78) v2(92.89,178.02) v2(93.02,178.66) v2(183.91,77.86) v3(12.91,84.45) v3(34.06,40.91) v3(34.46,41.77) v3(164.59,25.83) v3(184.61,78.15) v3(214.54,81.96) v3(214.56,82.86) v3(215.43,82.9) v3(215.48,81.93)
+5VS_3DCAM:
  vias: v1(93.91,179.91)
+5VS_AVDD: length 2.9
  TOP w0.203: 15.49,72.46 15.72,72.23 15.72,71.72 15.93,71.51 15.93,71.51 16.06,71.38 16.06,71.38 16.14,71.31 U3600.26
  TOP w0.457: C3606.1 15.49,73.42 15.49,72.46
  vias: v1(15.06,76.42)
+5VS_FAN2: length 8.4
  TOP w0.102: 164.64,21.18 166.04,19.78 172.14,19.78 v1(172.39,20.03)
+5VS_HDD:
  vias: v1(31.42,45.36)
+5VS_HDMI: length 25.6
  TOP w0.508: v2(247.19,75.53) 246.74,75.53 246.68,75.47 246.21,75.47 D4800.3
  IN1 w0.508: v2(257.35,82.69) 256.31,81.65 252.2,81.65 250.39,79.84 250.39,76.14 249.78,75.53 v2(247.19,75.53)
  IN4 w0.508: v2(257.35,82.69) 260.79,86.13 260.79,87.58 262.63,89.42 CON4800.18
  vias: v1(257.99,82.77)
+5VS_LED: length 23.7
  TOP w0.254: LR802.2 198.97,161.42 198.81,161.26 196.9,161.26 195.48,159.84 v2(195.48,159.59) LR804.1 196.63,157.92 197.08,157.48 v1(198.09,157.48) ; CON1.8 v2(183.55,156.94)
  IN1 w0.254: v2(195.48,159.59) 195.48,158.95 194.76,158.22 184.83,158.22 v2(183.55,156.94)
+5VS_LGF: length 10.5
  TOP w0.254: v2(52.24,182.28) 52.25,182.27 CON4500.37
  BOTTOM w0.508: R4503.2 50.6,175.58 50.6,176.22 T4509.1 49.94,177.82 49,178.75 49,179.81 49.74,180.55 50.57,180.55 50.9,180.88 C4538.1 51.8,182.22 52.18,182.22 v2(52.24,182.28)
+5VS_ODD_FAN: length 251.7
  TOP w1.778: 28.45,25.29 35,31.84 40.18,31.84 41.35,33.01
  IN2 w1.016: 156.87,26.66 154.29,29.24 146.84,29.24 146.49,28.88 135.52,28.88 134.84,28.2 132.77,28.2 131.11,29.86 123.08,29.86 122.61,29.39 113.97,29.39 110.98,32.37 89.86,32.37 88.61,33.62 81.27,33.62 81.02,33.37 69.78,33.37 67.43,35.72 51.81,35.72 50.37,34.28 43.85,34.28
  IN3 w0.762: 156.23,25.87 153.4,28.71 143.87,28.71 143.69,28.9 134.96,28.9 134.37,28.31 132.99,28.31 132.21,29.1 112.56,29.1 110.43,31.23 94.64,31.23 92.36,33.52 73.39,33.52 73.37,33.49 69.81,33.49 67.58,35.73 51.69,35.73 50.45,34.49 44.56,34.49
  vias: v1(28.5,26.38) v3(42.75,34.49) v3(43.62,34.51) v3(157.28,25.8) v3(158.14,25.8)
+5VS_PWR: length 16.1
  TOP w0.254: v2(176.77,170.82) v1(176.07,170.82) 175.17,170.82 175,170.99 PCON700.1 ; v2(183.29,170.82) 183.29,170.85 182.7,171.44 CON402.26
  IN2 w0.254: v2(176.77,170.82) v2(183.29,170.82)
+5VS_TS: length 14.6
  TOP w0.203: CON4301.16 98.27,182 v2(98.6,182.34) 98.77,182.18 CON4301.17
  TOP w0.381: v2(98.6,182.34) 98.6,183.37 99.68,184.45 102.09,184.45 102.28,184.63 102.92,184.63 v1(103.38,184.18) 103.38,183.28 103.24,183.14 103.24,180.43 102.86,180.05 101.69,180.05 R4314.1
+5VSUS: length 379.9
  TOP w0.432: v2(244.16,57.66) R5207.1
  TOP w0.508: R3713.2 199.98,29.64 C3711.1 199.59,29.61 v2(199.25,29.27) ; R5209.1 v2(233.48,56.74)
  IN1 w0.508: v2(199.25,29.27) 201.28,29.27 201.71,28.85 203.94,28.85 204.81,29.72 205.63,29.72 206.33,30.42 209.09,30.42 v2(209.25,30.57)
  IN2 w0.508: v3(231.64,51.26) 230.11,51.26 229.47,51.9 227.91,51.9 226.48,50.47 225.11,50.47 220.29,45.66 220.29,39.36 219.25,38.32 219.25,37.25 217.64,35.63 215.55,35.63 212.93,33.01 212.93,31.49 212.52,31.08 209.73,31.08 209.35,30.7 209.35,30.68 v2(209.25,30.57)
  IN3 w0.102: 233.86,39.36 234.31,39.36 ; 27.1,42.13 27.23,42.51 ; 250.61,48.27 250.91,48 ; 240.03,42.16 240.44,42.29
  IN3 w1.016: v3(27.1,163.03) 23.39,163.03 20.51,165.91 20.51,166.82 18.45,168.88 7.44,168.88 6.83,168.27 6.83,151.35 8.15,150.03 8.15,144.32 6.83,142.99 6.83,142.61 4.65,140.43 4.65,124.78 5,124.42 5,111.6 5.78,110.83 5.78,109.2 5.53,108.95 5.53,107.42 7.29,105.66
  IN3 w2.54: 5.28,67.68 5.28,73.15
  IN3 w3.048: 237.14,22.47 233.8,19.13 223.36,19.13 218.78,23.72 213.41,23.72 212.78,24.35 208.97,24.35 208.22,23.6 155.67,23.6 152.56,26.71 147.89,26.71 147.53,26.35 ; 65.61,31.49 87.48,31.49 ; 29.01,35.65 29.01,32.33 30.66,30.68 33.99,30.68 35.23,31.92 49.94,31.92 ; 127.43,26.28 110.26,26.28 ; 30.07,47.36 27.69,49.75 27.69,53.36 24.26,56.79 24.26,58.98 21.02,62.22
  IN4 w0.508: v2(39.6,179.7) 39.6,178.55 41.35,176.8 53.01,176.8
  IN4 w1.016: 52.92,174 51.46,174 50.88,173.43 50.88,171.71 49.86,170.69 45.8,170.69 40.54,165.42 35.87,165.42 33.86,163.42 27.48,163.42 v3(27.1,163.03)
  BOTTOM w0.279: CON5602.19 38.75,178.8 39.6,179.65 v2(39.6,179.7)
  BOTTOM w0.508: v2(52.77,172.78) 52.77,176.47 53.01,176.72 U4501.5
  vias: v2(9.75,61.1) v2(10.39,61.1) v2(239.7,77.61) v2(239.7,76.98) v2(239.7,76.34) v2(239.7,75.71) v2(239.7,74.06) v2(239.7,73.42) v2(239.7,72.79) v2(240.34,77.61) v2(240.34,76.98) v2(240.34,76.34) v2(240.34,75.71) v2(240.34,74.06) v2(240.34,73.42) v2(240.34,72.79) v2(240.97,77.61) v2(240.97,76.98) v2(240.97,76.34) v2(240.97,75.71) v2(240.97,74.06) v2(240.97,73.42) v2(240.97,72.79) v2(241.61,77.61) v2(241.61,76.98) v2(241.61,76.34) v2(241.61,75.71) v2(241.61,74.06) v2(241.61,73.42) v2(241.61,72.79) v2(242.24,73.42) v2(242.24,72.79) v3(11.56,106.04) v3(11.56,105.15) v3(11.56,104.26) v3(243.53,61.98) v3(243.51,61.05) v3(252.83,60.07) v3(252.81,59.15)
