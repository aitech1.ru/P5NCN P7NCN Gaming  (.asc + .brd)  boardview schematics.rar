# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Library data of the parts (continued)
JP5601 JP9300-JP9303 = DEV_63: room: CTL
JP8050-JP8061 = DEV_67: room: COR
JP8100 JP8106 JP8107 = DEV_66: room: SYS
JP8101 JP8102 JP8108-JP8111 = DEV_65: room: SYS
JP8103-JP8105 = DEV_67: room: SYS
JP8200 = DEV_67: room: 1.0VSUS
JP8202 = DEV_65: room: 1.0VSUS
JP8300 JP8303 JP8304 = DEV_67: room: DDR
JP8301 = DEV_66: room: DDR
JP8302 = DEV_65: room: DDR
JP8400 = DEV_66: room: 1.5VS
JP8800 JP8803 JP8806 = DEV_65: room: CHG
JP8801 JP8802 JP8804 JP8805 = DEV_67: room: CHG
JP8901 JP8902 = DEV_65: room: +FBVDDQ
JP9000 = DEV_67: room: CTL
JP9400 = DEV_65: room: VCCIO
JP9401 = DEV_67: room: VCCIO
JP9500 = DEV_65: room: 2.5V
JP9501 JP9502 = DEV_67: room: 2.5V
JP9600 = DEV_64: room: 1.05VO_VGA
JP9601 JP9602 = DEV_67: room: 1.05VO_VGA
L1101 = DEV_336
L1106 = DEV_372
L1201 L1202 = DEV_315
L3300 = DEV_389
L3301 L3302 L3600 L3601 L3606 L3607 = DEV_269
L3400-L3403 L4301 L4302 L4500-L4505 L5301 L5500-L5505 = DEV_365
L3701-L3704 = DEV_381
L4800-L4803 = DEV_374
L5300 L5302 L6700 L6701 = DEV_268
L6001 L6002 = DEV_182
L7100 = DEV_267
L7201 L7202 = DEV_181
L7203 = DEV_266
L7204 = DEV_180
L8000-L8004 = DEV_62: room: COR
L8005 = DEV_273: room: COR
L8100 L8101 = DEV_322: room: SYS
L8200 = DEV_294: room: 1.0VSUS
L8300 = DEV_311: room: DDR
L8700-L8702 = DEV_277: room: VGP
L8800 = DEV_293: room: CHG
L8900 = DEV_310: room: +FBVDDQ
L9400 = DEV_294: room: VCCIO
L9500 = DEV_292: room: 2.5V
L9600 = DEV_291: room: 1.05VO_VGA
LLED800-LLED802 = DEV_298
LLED803 = DEV_388
LQ800-LQ802 PQ700 = DEV_231
LQ803 Q3601 U2301 = DEV_60
LR800-LR803 PR701 PR703 = DEV_377
LR804 R0704 R1111-R1115 R1130-R1132 R1134 R1135 R1138 R1145 R1146 R1161 R1224 R1225 R1227-R1230 R1302 R1315 R1316 R1320 R1407 R2100 R2102-R2108 R2110-R2124 R2131-R2136 R2141-R2146 R2152 R2157 R2162 R2201-R2210 R2236-R2242 R2244-R2250 R2255 R2256 R2258-R2260 R2302-R2305 R2309 R2310 R2316-R2319 R2357 R2358 R2360 R2361 R2363-R2365 R2369-R2372 R2381 R2406-R2412 R2414-R2417 R2420-R2423 R2425-R2437 R2442 R2444 R2447 R2459 R2463 R2465-R2467 R2469-R2473 R2475 R2477 R2478 R2481 R2490 R3001 R3005 R3053 R3070-R3073 R3081 R3141-R3148 R3167 R3604 R3608 R3632 R3711 R3712 R4501 R4523 R4524 R4526 R4587 R4592 R4593 R4621 R5011-R5013 R5018 R5115 R5134 R5208 R5302 R5601-R5603 R5806 R6101-R6104 R6113-R6124 R7000 R7001 R7008 R7100-R7107 R7112-R7119 R7208 R7210 R7211 R7305 R7308 R7309 R7311 R7313 R7318 R7400 R7411 R7414 R7419 R7425 R7436 R7438 R7439 R7441 R7443 R7445 R7502 = DEV_51
PCON702 = DEV_297
PLED701 PLED702 = DEV_296
PR700 R0500 R0503 R0700 R0701 R0702 R0703 R0705 R0706 R0709 R0710 R0712 R0713 R0714 R0715 R0718 R0719 R0723 R0724 R0725 R0726 R0729 R0744 R0745 R1610 R1612 R1623 R1624 R1710 R1714 R2000 R2235 R2257 R2261 R2263 R2327 R2328 R2331 R2332 R2413 R2446 R2450 R2474 R2811 R3112 R3116 R3124 R4404-R4406 R4412 R4414 R4416 R4418 R4422 R4425 R5015 R5016 R7212 R7437 R7614 R7619 R7714 R7719 R7814 R7819 R7914 R7919 = DEV_47
PR702 R0301 R0305 R0306 R0307 R0751 R1119 R1120 R1125-R1127 R1133 R1139 R1142 R1154 R1155 R1222 R1226 R1233-R1236 R1314 R1317 R1414-R1416 R2125 R2127 R2148 R2149 R2163 R2164 R2476 R2479 R3061-R3064 R3168 R3600 R3603 R3624 R4518 R4586 R4588 R4607 R4608 R4627 R4629 R4630 R5004 R5014 R5127 R5206 R5207 R5209 R5210 R5704 R6001 R6006 R7010 R7213 R7214 R7423 R7429 R7435 R7444 R7448 = DEV_49
PSR701 SR300 SR400 = DEV_230
PSW1700 = DEV_327
PU701 = DEV_236
Q0702 Q1201 Q1202 Q2301 Q3100 Q3102 Q3602 Q4801-Q4803 Q5102 Q5301 Q5302 Q5700-Q5705 Q6001 Q6701 Q7000 Q7201 Q7400-Q7405 = DEV_58
Q1302 = DEV_61
Q3107-Q3111 Q4501 Q5101 Q9100 Q9105 = DEV_55: room: LOAD_SW
Q4601 Q4804 = DEV_173
Q4805 = DEV_354
Q5001 = DEV_347
Q5300 Q7202 Q7203 = DEV_265
Q7600 Q7700 Q7800 Q7900 = DEV_264
Q8001 = DEV_206: room: COR
Q8002 = DEV_59: room: COR
Q8100 Q8101 = DEV_56: room: SYS
Q8106 = DEV_60: room: SYS
Q8300 = DEV_59: room: DDR
Q8301 = DEV_206: room: DDR
Q8701 Q8705 Q8709 = DEV_206: room: VGP
Q8703 Q8704 Q8707 Q8708 Q8711 Q8712 = DEV_321: room: VGP
Q8800 = DEV_395: room: CHG
Q8801 Q8802 = DEV_114: room: CHG
Q8803 Q8804 = DEV_57: room: CHG
Q8805-Q8807 = DEV_58: room: CHG
Q8900 Q8901 = DEV_309: room: +FBVDDQ
Q9101-Q9104 = DEV_54: room: LOAD_SW
Q9200 = DEV_60: room: CTL
R300 R401 R0501 R0734 R0748 R0749 R0750 R1001 R1005 R1010 R1018 R1121 R1148-R1153 R1162 R1202 R1204 R1211 R1219 R1220 R1223 R1239 R1303 R1408 R1604-R1609 R1613-R1615 R1617-R1621 R1704-R1709 R1712 R1713 R1715-R1717 R1719-R1721 R2001 R2101 R2140 R2150 R2156 R2158-R2161 R2218-R2226 R2229-R2234 R2322 R2325 R2343-R2346 R2375-R2377 R2382 R2438-R2441 R2443 R2457 R2462 R2483 R2485 R2488 R2489 R2491-R2496 R2498-R2503 R2505 R2507-R2511 R2515 R2517-R2522 R2525 R2527 R2528 R2700 R2701 R3013-R3016 R3018 R3020 R3032-R3035 R3037 R3069 R3074-R3077 R3079 R3080 R3082 R3084-R3092 R3094-R3098 R3108 R3110 R3137-R3140 R3149-R3151 R3163 R3164 R3303-R3305 R3308 R3610 R3616 R3620-R3622 R3702 R3707-R3710 R4301 R4308 R4402 R4403 R4407 R4408 R4413 R4415 R4417 R4419-R4421 R4423 R4424 R4426 R4502 R4504 R4527 R4590 R4628 R4816 R5104 R5106 R5108 R5109 R5122-R5126 R5131 R5202-R5204 R5309-R5312 R5706 R5803-R5805 R5807 R5808 R7002 R7206 R7219 R7220 R7446 R7447 R7449 R7450 R7503 = DEV_40
R0300 R0509 R0510 R0511 R0600 R7306 R7317 = DEV_155
R301 R400 R0900 R0901 R1000 R1002 R1003 R1006-R1008 R1011 R1012 R1159 R1160 R1164 R1237 R1238 R2603-R2609 R2615-R2619 R3000 R3047 R3048 R3161 R3162 R3165 R3166 R3170 R3309 R3404 R3605 R3609 R3612 R3625-R3631 R3713 R3714 R4313 R4314 R4400 R4401 R4503 R4594 R4631 R5129 R5130 R6003-R6005 R6201 R6202 R7007 R7215 = DEV_145
R0302 R0731 = DEV_154
R0502 R0505 R0508 = DEV_295
R0504 R7612 R7613 R7712 R7713 R7812 R7813 R7912 R7913 = DEV_178
R0506 R3400-R3403 = DEV_153
R0507 R0707 R1004 R1009 R1013 R1128 R1129 R2516 = DEV_48
R0708 = DEV_152
R0717 = DEV_185
R0727 R1123 R1124 R2329 R2330 = DEV_19
R0728 = DEV_150
R0730 R7108-R7111 R7120-R7123 R7500 = DEV_149
R0733 = DEV_148
R0736 R0737 R0738 R0739 R0740 R0741 R2350 = DEV_147
R0742 R1014-R1016 = DEV_50
R0743 R2228 R2307 R2311 R2326 = DEV_146
R0746 = DEV_353
R0747 = DEV_184
R1017 R1622 R1722 R2613 R4603 = DEV_33
R1101 = DEV_144
R1102 R1108 = DEV_34
R1103-R1106 R1231 R1232 = DEV_143
R1107 = DEV_142
R1109 R1110 R1140 R1141 R1143 R1144 R2128 R2129 R2151 R2153-R2155 R2262 R2451 R4410 R4411 R4806 R4807 R4817 R4818 R7615-R7618 R7715-R7718 R7815-R7818 R7915-R7918 = DEV_35
R1118 R1122 R1147 R1321 R1417 R2448 R2524 R4609 R4610 R4800 = DEV_24
R1218 R3114 R7314 = DEV_130
R1301 R1411 R4312 R4604 R7304 R7315 = DEV_126
R1304-R1309 R1401-R1406 R2333-R2335 R2378 R2402 R2405 R2445 R2449 R2464 R3029 R3030 R3307 R4302-R4307 R4309-R4311 R4525 R4601 R4602 R4623-R4626 R5000 R5003 R5007 R5008 R5132 R5300 R5308 R6737 R6738 R7216-R7218 R7405 R7406 R7409 R7410 = DEV_151
R1600 R1601 R1700 R1701 = DEV_141
R2227 R2264 R2265 R3611 R3613 = DEV_140
R2243 R2251 = DEV_139
R2300 R2301 R2306 R2308 R3156-R3160 R7401-R7403 = DEV_52
R2312-R2315 R2379 R2380 R8110 = DEV_47: room: SYS
R2347-R2349 R2424 R2460 R2484 R2810 R2812 R4803 R5201 R5301 R7312 = DEV_36
R2400 R2401 R2403 R2404 R2418 R2419 R7307 = DEV_138
R2452 = DEV_137
R2454 = DEV_136
R2458 R5005 R5009 = DEV_135
R2497 = DEV_51: room: SB_
R2512 R3104 R3105 R8096 = DEV_134
R2523 = DEV_133
R2526 = DEV_132
R3041 R3043 R3044 R5017 = DEV_131
R3065 R3066 R9100 R9104-R9106 R9109 = DEV_21: room: LOAD_SW
R3169 R4591 R5700-R5703 R5707 = DEV_127
R3301 = DEV_37
R3306 = DEV_129
R3606 R3607 = DEV_282
R3623 = DEV_128
R3700 R3704 = DEV_235
R4409 R5006 R5010 = DEV_53
R4808-R4815 = DEV_348
R5001 R5002 R8710 = DEV_272: room: VGP
R5136 R8300 = DEV_41: room: DDR
R5137 R5139 R80125 R80130 R80135 R80140 R80145 = DEV_49: room: COR
R5200 = DEV_202
R5501 = DEV_326
R7006 = DEV_125
R7009 = DEV_124
R7310 R7319 = DEV_123
R7316 = DEV_122
R7404 = DEV_275
R7407 R7408 = DEV_179
R7501 R7506 = DEV_121
R7600 R7610 R7700 R7710 R7800 R7810 R7900 R7910 = DEV_120
R7601 R7611 R7701 R7711 R7801 R7811 R7901 R7911 = DEV_119
R7602 R7603 R7702 R7704 R7802 R7803 R7902 R7903 = DEV_118
R7608 R7609 R7708 R7709 R7808 R7809 R7908 R7909 = DEV_117
R8000 R8019 R80112 R80147 = DEV_48: room: COR
R8003-R8008 R8013 R8017 R8020 R8027 R8032 R8034 R8040 R8048 R8068 R8069 R8076 R8091 R8097 R80103 R80124 R80151 = DEV_40: room: COR
R8012 = DEV_50: room: COR
R8014 R8033 R8075 R8089 = DEV_23: room: COR
R8015 = DEV_213: room: COR
R8021 = DEV_190: room: COR
R8023 R8047 R8080 = DEV_189: room: COR
R8024 R8094 R80101 = DEV_191: room: COR
R8025 R8044 R8083 = DEV_188: room: COR
R8026 R8082 R8088 = DEV_187: room: COR
R8028 = DEV_212: room: COR
R8029 = DEV_290: room: COR
R8030 = DEV_211: room: COR
R8031 R8081 = DEV_352: room: COR
R8035 = DEV_308: room: COR
R8036 R8043 R8079 R80102 = DEV_47: room: COR
R8037 R8049 = DEV_210: room: COR
R8038 R8092 = DEV_22: room: COR
R8039 R8084 = DEV_351
R8041 = DEV_209: room: COR
R8045 = DEV_246: room: COR
R8046 = DEV_201: room: COR
R8050-R8052 R8065 R8071 = DEV_205: room: COR
R8053-R8055 R8070 R8072 R8073 = DEV_46: room: COR
R8056 R8058 R8060 R8062 R8063 R8067 = DEV_186: room: COR
R8057 R8059 R8061 R8064 R8066 = DEV_45: room: COR
R8085 = DEV_332: room: COR
R8087 = DEV_208: room: COR
R8093 = DEV_143: room: COR
R8098 = DEV_245: room: COR
R8099 = DEV_244: room: COR
R8100 R8101 = DEV_44: room: SYS
R8102 = DEV_243: room: SYS
R8103 = DEV_242: room: SYS
R8104 = DEV_43: room: SYS
R8105 = DEV_235: room: SYS
R8106 R8107 = DEV_51: room: SYS
R8108 R8109 = DEV_42: room: SYS
R8111 = DEV_40: room: SYS
R8200 = DEV_20: room: 1.0VSUS
R8201 = DEV_36: room: 1.0VSUS
R8202 = DEV_46: room: 1.0VSUS
R8203 = DEV_49: room: 1.0VSUS
R8204 R8208 = DEV_40: room: 1.0VSUS
R8205 = DEV_307: room: 1.0VSUS
R8206 = DEV_394: room: 1.0VSUS
R8207 = DEV_19: room: 1.0VSUS
R8301 = DEV_46: room: DDR
R8302 = DEV_241: room: DDR
R8303-R8305 = DEV_40: room: DDR
R8306 = DEV_51: room: DDR
R8307 = DEV_303: room: DDR
R8308 = DEV_175: room: DDR
R8400 = DEV_38: room: 1.5VS
R8401 = DEV_171: room: 1.5VS
R8402 = DEV_37: room: 1.5VS
R8403 = DEV_36: room: 1.5VS
R8700 R8701 = DEV_39: room: VGP
R8702 R8705 = DEV_135: room: VGP
R8704 = DEV_37: room: VGP
R8706 R8707 = DEV_35: room: VGP
R8709 R8716 R8721 R8725 R8726 R8728 R8729 = DEV_40: room: VGP
R8711 R8723 R8727 = DEV_46: room: VGP
R8712 = DEV_41: room: VGP
R8714 R8741 R8905 R8912 = DEV_224: room: VGP
R8715 R8909 = DEV_48: room: VGP
R8717 = DEV_289: room: VGP
R8718-R8720 R8736-R8740 = DEV_51: room: VGP
R8730 R8733 = DEV_240
R8731 R8732 R8734 R8735 = DEV_23: room: VGP
R8800 = DEV_204: room: CHG
R8801 = DEV_32: room: CHG
R8802 R8815 R8819 R8820 = DEV_49: room: CHG
R8803 R8804 = DEV_31: room: CHG
R8805 = DEV_30: room: CHG
R8806 = DEV_51: room: CHG
R8807 = DEV_29: room: CHG
R8808 = DEV_28: room: CHG
R8809 = DEV_33: room: CHG
R8810 = DEV_46: room: CHG
R8811 = DEV_42: room: CHG
R8812 = DEV_27: room: CHG
R8813 = DEV_26: room: CHG
R8814 = DEV_392: room: CHG
R8816 = DEV_25: room: CHG
R8817 = DEV_24: room: CHG
R8818 = DEV_138: room: CHG
R8821 R8822 = DEV_40: room: CHG
R8900 = DEV_36: room: +FBVDDQ
R8901 = DEV_21: room: +FBVDDQ
R8902 R8903 R8911 = DEV_51: room: +FBVDDQ
R8904 = DEV_46: room: +FBVDDQ
R8907 = DEV_306: room: +FBVDDQ
R8910 = DEV_22: room: +FBVDDQ
R9102 R9103 R9110 R9111 = DEV_51: room: LOAD_SW
R9107 R9108 = DEV_42: room: LOAD_SW
R9112 = DEV_305: room: LOAD_SW
R9200 R9202 R9203 = DEV_49: room: CTL
R9204 = DEV_42: room: CTL
R9205-R9213 = DEV_40: room: CTL
R9400 = DEV_20: room: VCCIO
R9401 = DEV_46: room: VCCIO
R9402 R9408 = DEV_40: room: VCCIO
R9403 = DEV_51: room: VCCIO
R9404 = DEV_49: room: VCCIO
R9405 = DEV_304: room: VCCIO
R9406 = DEV_202: room: VCCIO
R9407 = DEV_19: room: VCCIO
R9500 = DEV_20: room: 2.5V
R9501 = DEV_46: room: 2.5V
R9502 = DEV_49: room: 2.5V
R9503 = DEV_303: room: 2.5V
R9504 = DEV_19: room: 2.5V
R9505 = DEV_170: room: 2.5V
R9506 = DEV_172: room: 2.5V
R9507 = DEV_40: room: 2.5V
R9600 = DEV_49: room: 1.05VO_VGA
R9601 = DEV_46: room: 1.05VO_VGA
R9602 = DEV_282: room: 1.05VO_VGA
R9603 = DEV_20: room: 1.05VO_VGA
R9604 = DEV_172: room: 1.05VO_VGA
R9605 = DEV_19: room: 1.05VO_VGA
R9606 = DEV_288: room: 1.05VO_VGA
R80100 = DEV_129: room: COR
R80148 = DEV_220: room: COR
R80149 = DEV_184: room: COR
R80150 = DEV_153: room: COR
RN1201 RN1202 RN3400-RN3403 RN4301 RN4302 RN4500-RN4505 RN4800-RN4803 RN5301 RN5500-RN5505 = DEV_116
SP1202 SP2601 SP4502 SP5101 = DEV_18
SR8000 SR8001 = DEV_335: room: COR
SR8100 SR8101 SR8104 = DEV_17: room: SYS
SR8102 SR8103 = DEV_334: room: SYS
SR8200 = DEV_335: room: 1.0VSUS
SR8300 = DEV_18: room: DDR
SR8301 = DEV_17: room: DDR
SR8302 SR8303 = DEV_16: room: DDR
SR8400 = DEV_15: room: 1.5VS
SR8700-SR8702 SR8707 = DEV_335: room: VGP
SR8703-SR8706 = DEV_15: room: VGP
SR8800-SR8802 = DEV_16: room: CHG
SR8803 = DEV_17: room: CHG
SR8804 SR8805 = DEV_14: room: CHG
SR8806 = DEV_18: room: CHG
SR8807 = DEV_13: room: CHG
SR8900 SR8902 SR8903 SR8908 SR8910 = DEV_335: room: +FBVDDQ
SR8901 SR8906 SR8909 = DEV_15: room: +FBVDDQ
SR9100 SR9101 SR9103 SR9104 = DEV_334: room: LOAD_SW
SR9102 = DEV_12: room: LOAD_SW
SR9204-SR9206 = DEV_334: room: CTL
SR9400 = DEV_335: room: VCCIO
T300 T400 = DEV_228
T0301 T0500 T0700 T0701 T0702 T0703 T0704 T0705 T0706 T0707 T0708 T0709 T0710 T0714 T0717 T0719 T0722 T0724 T0729 T0730 T0732 T0734 T0745 T1000-T1003 T1105-T1112 T1205-T1210 T1301 T1302 T1600-T1603 T1700-T1703 T2201-T2206 T2400-T2411 T2500-T2503 T4401 T5102 T5201 T5301 T5302 T7000-T7002 = DEV_10
T1101-T1104 T3300-T3303 T3602 T5103 T7404 T7405 T7500-T7502 T8050-T8055 = DEV_11: room: COR
T4504-T4509 T8900-T8902 T8904-T8907 = DEV_11: room: +FBVDDQ
T6001 T6002 T8100-T8127 = DEV_10: room: SYS
T7406-T7410 T8300-T8313 = DEV_11: room: DDR
T8200-T8205 = DEV_11: room: 1.0VSUS
T8700 T8702-T8715 = DEV_11: room: VGP
T8800-T8811 = DEV_11: room: CHG
T8812 = DEV_10: room: CHG
T9100 T9102 T9104-T9108 T9110-T9112 = DEV_10: room: LOAD_SW
T9101 T9103 T9109 T9113 T9114 = DEV_11: room: LOAD_SW
T9200-T9211 T9300-T9303 = DEV_11: room: CTL
T9400-T9404 = DEV_11: room: VCCIO
T9500-T9505 = DEV_11: room: 2.5V
T9600-T9603 = DEV_10: room: 1.05VO_VGA
U300 U400 = DEV_384
U0300 = DEV_9
U0701 U0702 U5102 = DEV_219
U0703 U2401-U2403 = DEV_2
U1101 = DEV_387
U1103 = DEV_393
U1201 = DEV_276
U1207 = DEV_263
U1301 U1401 U4601 = DEV_174
U2000 = DEV_357
U2404 = DEV_177: room: SB_
U3001 = DEV_262
U3101 = DEV_261
U3102 = DEV_260
U3103 = DEV_257
U3300 = DEV_386
U3401 = DEV_259
U3600 = DEV_274
U3700 = DEV_258
U4301 = DEV_183
U4302 U5500 U5502 = DEV_115
U4501 = DEV_302
U4502 = DEV_383
U5000 = DEV_346
U5001 U5002 U5103 = DEV_256
U5003 = DEV_301
U5200 = DEV_255
U5501 = DEV_375
U5800 = DEV_217
U6200 = DEV_254
U6901 U6902 = DEV_287
U7000 = DEV_356
U7002 = DEV_177
U7401 = DEV_333
U7600 U7601 U7700 U7701 U7800 U7801 U7900 U7901 = DEV_253
U8000 = DEV_239: room: COR
U8001-U8004 U8006 = DEV_207: room: COR
U8005 = DEV_238: room: COR
U8100 = DEV_8: room: SYS
U8200 = DEV_320: room: 1.0VSUS
U8300 = DEV_7: room: DDR
U8400 = DEV_6: room: 1.5VS
U8700 = DEV_5: room: VGP
U8701 = DEV_368: room: VGP
U8702 = DEV_237: room: VGP
U8800 = DEV_4: room: CHG
U8801 = DEV_376
U8900 = DEV_3: room: +FBVDDQ
U9100 U9102 = DEV_169: room: LOAD_SW
U9101 U9103 = DEV_168: room: LOAD_SW
U9200 U9201 = DEV_2: room: CTL
U9400 = DEV_320: room: VCCIO
U9500 = DEV_1: room: 2.5V
U9600 = DEV_1: room: 1.05VO_VGA
X1101 = DEV_252
X7200 = DEV_251
XDP4400 = DEV_382
Y2500 = DEV_216
Y2501 = DEV_250
Y3300 = DEV_249

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1MM_OPEN_5MIL_M1M2
  custom 0.159x0.159 smd: 1(0,-0.318) 2(0,0.318)
2MM_OPEN_5MIL_M1M2
  custom 0.318x0.318 smd: 1(0,-0.699) 2(0,0.699)
3MM_OPEN_5MIL_M1M2
  custom 0.476x0.476 smd: 1(0,0.317) 2(0,-1.714)
ANT_CLIP_1P_102X107
  custom 0.358x0.358 smd: 1(0,0)
BGA_1440P_1102X1654_N
  oval 0.406x0.508 smd: A3(12.06,-20.314) A36(-11.958,-20.314) A37(-12.739,-20.314) BT2(12.743,20.314) BT3(12.019,20.314) BT36(-11.996,20.314) BT37(-12.722,20.314)
  oval 0.381x0.483 smd: A4(11.343,-20.314) A34(-11.146,-20.314) BT4(11.295,20.314) BT35(-11.184,20.314)
  oval 0.356x0.457 smd: A5(10.543,-20.314) A6(9.768,-20.314) A8(8.996,-20.314) A9(8.209,-20.314) A10(7.421,-20.314) A11(6.634,-20.314) A12(5.847,-20.314) A13(5.059,-20.314) A14(4.272,-20.314) A15(3.484,-20.314) A16(2.697,-20.314) A17(1.91,-20.314) A18(1.122,-20.314) A19(0.335,-20.314) A20(-0.453,-20.314) A21(-1.24,-20.314) A22(-2.027,-20.314) A23(-2.815,-20.314) A24(-3.602,-20.314) A25(-4.39,-20.314) A26(-5.177,-20.314) A27(-5.964,-20.314) A28(-6.752,-20.314) A29(-7.539,-20.314) A30(-8.53,-20.314) A32(-9.558,-20.314) A33(-10.345,-20.314) BT5(10.495,20.314) BT6(9.721,20.314) BT8(8.666,20.314) BT9(7.65,20.314) BT11(6.863,20.314) BT12(6.076,20.314) BT13(5.288,20.314) BT14(4.501,20.314) BT15(3.713,20.314) BT16(2.926,20.314) BT17(2.139,20.314) BT18(1.351,20.314) BT19(0.564,20.314) BT20(-0.224,20.314) BT21(-1.011,20.314) BT22(-1.798,20.314) BT23(-2.586,20.314) BT24(-3.373,20.314) BT25(-4.161,20.314) BT26(-4.948,20.314) BT27(-5.735,20.314) BT28(-6.523,20.314) BT29(-7.31,20.314) BT30(-8.098,20.314) BT31(-8.86,20.314) BT32(-9.609,20.314) BT34(-10.384,20.314)
  oval 0.457x0.356 smd: AA1(13.314,-6.295) AA38(-13.314,-5.899) AB1(13.314,-5.559) AB38(-13.314,-5.111) AC1(13.314,-4.67) AC38(-13.314,-4.324) AD1(13.314,-3.781) AD38(-13.314,-3.537) AE1(13.314,-3.044) AE38(-13.314,-2.749) AF1(13.314,-2.155) AF38(-13.314,-1.962) AG1(13.314,-1.266) AG38(-13.314,-1.174) AH1(13.314,-0.529) AH38(-13.314,-0.387) AJ1(13.314,0.36) AJ38(-13.314,0.4) AK1(13.314,1.249) AK38(-13.314,1.188) AL1(13.314,1.985) AL38(-13.314,1.975) AM1(13.314,2.874) AM38(-13.314,2.763) AN1(13.314,3.763) AN38(-13.314,3.55) AP1(13.314,4.5) AP38(-13.314,4.337) AR1(13.314,5.389) AR38(-13.314,5.125) AT1(13.314,6.278) AT38(-13.314,5.912) AU1(13.314,7.014) AU38(-13.314,6.7) AV38(-13.314,7.487) AW1(13.314,7.903) AW38(-13.314,8.274) AY1(13.314,8.792) AY38(-13.314,9.062) BA1(13.314,9.529) BA38(-13.314,9.849) BB1(13.314,10.418) BB38(-13.314,10.637) BC1(13.314,11.307) BC38(-13.314,11.424) BD1(13.314,12.044) BD38(-13.314,12.211) BE1(13.314,12.933) BE38(-13.314,12.999) BF1(13.314,13.822) BF38(-13.314,13.786) BG1(13.314,14.558) BG38(-13.314,14.574) BH1(13.314,15.701) BH38(-13.314,15.361) BJ38(-13.314,16.098) BK1(13.314,16.722) BL38(-13.314,16.862) BM1(13.314,17.5) BM38(-13.314,17.573) E1(13.314,-17.536) E38(-13.314,-17.418) G1(13.314,-16.733) G38(-13.314,-16.643) H1(13.314,-15.871) J38(-13.314,-15.602) K1(13.314,-14.728) K38(-13.314,-14.56) L1(13.314,-13.839) L38(-13.314,-13.773) M1(13.314,-13.102) M38(-13.314,-12.985) N1(13.314,-12.213) N38(-13.314,-12.198) P1(13.314,-11.324) P38(-13.314,-11.411) R1(13.314,-10.588) R38(-13.314,-10.623) T1(13.314,-9.699) T38(-13.314,-9.836) U1(13.314,-8.81) U38(-13.314,-9.048) V1(13.314,-8.073) V38(-13.314,-8.261) W1(13.314,-7.184) W38(-13.314,-7.474) Y38(-13.314,-6.686)
  round 0.356 smd: AA2(12.664,-6.295) AA3(12.014,-6.295) AA4(11.363,-6.295) AA5(10.713,-6.295) AA6(10.063,-6.346) AA7(9.403,-5.766) AA8(8.753,-5.766) AA9(8.103,-5.766) AA10(7.452,-5.766) AA11(6.802,-5.766) AA12(6.152,-5.766) AA31(-8.762,-5.899) AA32(-9.413,-5.899) AA33(-10.063,-5.899) AA34(-10.713,-5.899) AA35(-11.363,-5.899) AA36(-12.014,-5.899) AA37(-12.664,-5.899) AB2(12.664,-5.559) AB3(12.014,-5.559) AB4(11.363,-5.559) AB5(10.713,-5.559) AB6(10.063,-5.508) AB31(-8.762,-5.111) AB32(-9.413,-5.111) AB33(-10.063,-5.111) AB34(-10.713,-5.111) AB35(-11.363,-5.111) AB36(-12.014,-5.111) AB37(-12.664,-5.111) AC2(12.664,-4.67) AC3(12.014,-4.67) AC4(11.363,-4.67) AC5(10.713,-4.67) AC6(10.063,-4.67) AC7(9.403,-4.852) AC8(8.753,-4.852) AC9(8.103,-4.852) AC10(7.452,-4.852) AC11(6.802,-4.852) AC12(6.152,-4.852) AC31(-8.762,-4.324) AC32(-9.413,-4.324) AC33(-10.063,-4.324) AC34(-10.713,-4.324) AC35(-11.363,-4.324) AC36(-12.014,-4.324) AC37(-12.664,-4.324) AD2(12.664,-3.781) AD3(12.014,-3.781) AD4(11.363,-3.781) AD5(10.713,-3.781) AD6(10.063,-3.831) AD7(9.403,-3.937) AD8(8.753,-3.937) AD9(8.103,-3.937) AD10(7.452,-3.937) AD11(6.802,-3.937) AD12(6.152,-3.937) AD31(-8.762,-3.537) AD32(-9.413,-3.537) AD33(-10.063,-3.537) AD34(-10.713,-3.537) AD35(-11.363,-3.537) AD36(-12.014,-3.537) AD37(-12.664,-3.537) AE2(12.664,-3.044) AE3(12.014,-3.044) AE4(11.363,-3.044) AE5(10.713,-3.044) AE6(10.063,-2.993) AE7(9.403,-3.023) AE8(8.753,-3.023) AE9(8.103,-3.023) AE10(7.452,-3.023) AE11(6.802,-3.023) AE12(6.152,-3.023) AE31(-8.762,-2.749) AE32(-9.413,-2.749) AE33(-10.063,-2.749) AE34(-10.713,-2.749) AE35(-11.363,-2.749) AE36(-12.014,-2.749) AE37(-12.664,-2.749) AF2(12.664,-2.155) AF3(12.014,-2.155) AF4(11.363,-2.155) AF5(10.713,-2.155) AF6(10.063,-2.155) AF7(9.403,-2.108) AF8(8.753,-2.108) AF9(8.103,-2.108) AF10(7.452,-2.108) AF11(6.802,-2.108) AF12(6.152,-2.108) AF31(-8.762,-1.962) AF32(-9.413,-1.962) AF33(-10.063,-1.962) AF34(-10.713,-1.962) AF35(-11.363,-1.962) AF36(-12.014,-1.962) AF37(-12.664,-1.962) AG2(12.664,-1.266) AG3(12.014,-1.266) AG4(11.363,-1.266) AG5(10.713,-1.266) AG6(10.063,-1.317) AG7(9.403,-1.194) AG8(8.753,-1.194) AG9(8.103,-1.194) AG10(7.452,-1.194) AG11(6.802,-1.194) AG12(6.152,-1.194) AG31(-8.762,-1.174) AG32(-9.413,-1.174) AG33(-10.063,-1.174) AG34(-10.713,-1.174) AG35(-11.363,-1.174) AG36(-12.014,-1.174) AG37(-12.664,-1.174) AH2(12.664,-0.529) AH3(12.014,-0.529) AH4(11.363,-0.529) AH5(10.713,-0.529) AH6(10.063,-0.479) AH7(9.403,-0.28) AH8(8.753,-0.28) AH9(8.103,-0.28) AH10(7.452,-0.28) AH11(6.802,-0.28) AH12(6.152,-0.28) AH31(-8.762,-0.387) AH32(-9.413,-0.387) AH33(-10.063,-0.387) AH34(-10.713,-0.387) AH35(-11.363,-0.387) AH36(-12.014,-0.387) AH37(-12.664,-0.387) AJ2(12.664,0.36) AJ3(12.014,0.36) AJ4(11.363,0.36) AJ5(10.713,0.36) AJ6(10.063,0.36) AJ7(9.403,0.635) AJ8(8.753,0.635) AJ9(8.103,0.635) AJ10(7.452,0.635) AJ11(6.802,0.635) AJ12(6.152,0.635) AJ31(-8.762,0.4) AJ32(-9.413,0.4) AJ33(-10.063,0.4) AJ34(-10.713,0.4) AJ35(-11.363,0.4) AJ36(-12.014,0.4) AJ37(-12.664,0.4) AK2(12.664,1.249) AK3(12.014,1.249) AK4(11.363,1.249) AK5(10.713,1.249) AK6(10.063,1.198) AK31(-8.762,1.188) AK32(-9.413,1.188) AK33(-10.063,1.188) AK34(-10.713,1.188) AK35(-11.363,1.188) AK36(-12.014,1.188) AK37(-12.664,1.188) AL2(12.664,1.985) AL3(12.014,1.985) AL4(11.363,1.985) AL5(10.713,1.985) AL6(10.063,2.036) AL7(9.403,1.549) AL8(8.753,1.549) AL9(8.103,1.549) AL10(7.452,1.549) AL11(6.802,1.549) AL12(6.152,1.549) AL31(-8.762,1.975) AL32(-9.413,1.975) AL33(-10.063,1.975) AL34(-10.713,1.975) AL35(-11.363,1.975) AL36(-12.014,1.975) AL37(-12.664,1.975) AM2(12.664,2.874) AM3(12.014,2.874) AM4(11.363,2.874) AM5(10.713,2.874) AM6(10.063,2.874) AM7(9.403,2.464) AM8(8.753,2.464) AM9(8.103,2.464) AM10(7.452,2.464) AM11(6.802,2.464) AM12(6.152,2.464) AM31(-8.762,2.763) AM32(-9.413,2.763) AM33(-10.063,2.763) AM34(-10.713,2.763) AM35(-11.363,2.763) AM36(-12.014,2.763) AM37(-12.664,2.763) AN2(12.664,3.763) AN3(12.014,3.763) AN4(11.363,3.763) AN5(10.713,3.763) AN6(10.063,3.712) AN7(9.403,3.378) AN8(8.753,3.378) AN9(8.103,3.378) AN10(7.452,3.378) AN11(6.802,3.378) AN12(6.152,3.378) AN31(-8.762,3.55) AN32(-9.413,3.55) AN33(-10.063,3.55) AN34(-10.713,3.55) AN35(-11.363,3.55) AN36(-12.014,3.55) AN37(-12.664,3.55) AP2(12.664,4.5) AP3(12.014,4.5) AP4(11.363,4.5) AP5(10.713,4.5) AP6(10.063,4.551) AP7(9.403,4.292) AP8(8.753,4.292) AP9(8.103,4.292) AP10(7.452,4.292) AP11(6.802,4.292) AP12(6.152,4.292) AP31(-8.762,4.337) AP32(-9.413,4.337) AP33(-10.063,4.337) AP34(-10.713,4.337) AP35(-11.363,4.337) AP36(-12.014,4.337) AP37(-12.664,4.337) AR2(12.664,5.389) AR3(12.014,5.389) AR4(11.363,5.389) AR5(10.713,5.389) AR6(10.063,5.389) AR7(9.403,5.207) AR8(8.753,5.207) AR9(8.103,5.207) AR10(7.452,5.207) AR11(6.802,5.207) AR12(6.152,5.207) AR31(-8.762,5.125) AR32(-9.413,5.125) AR33(-10.063,5.125) AR34(-10.713,5.125) AR35(-11.363,5.125) AR36(-12.014,5.125) AR37(-12.664,5.125) AT2(12.664,6.278) AT3(12.014,6.278) AT4(11.363,6.278) AT5(10.713,6.278) AT6(10.063,6.227) AT7(9.403,6.121) AT8(8.753,6.121) AT9(8.103,6.121) AT10(7.452,6.121) AT11(6.802,6.121) AT12(6.152,6.121) AT31(-8.762,5.912) AT32(-9.413,5.912) AT33(-10.063,5.912) AT34(-10.713,5.912) AT35(-11.363,5.912) AT36(-12.014,5.912) AT37(-12.664,5.912) AU2(12.664,7.014) AU3(12.014,7.014) AU4(11.363,7.014) AU5(10.713,7.014) AU6(10.063,7.065) AU7(9.403,7.036) AU8(8.753,7.036) AU9(8.103,7.036) AU10(7.452,7.036) AU11(6.802,7.036) AU12(6.152,7.036) AU31(-8.762,6.7) AU32(-9.413,6.7) AU33(-10.063,6.7) AU34(-10.713,6.7) AU35(-11.363,6.7) AU36(-12.014,6.7) AU37(-12.664,6.7) AV31(-8.762,7.487) AV32(-9.413,7.487) AV33(-10.063,7.487) AV34(-10.713,7.487) AV35(-11.363,7.487) AV36(-12.014,7.487) AV37(-12.664,7.487) AW2(12.664,7.903) AW3(12.014,7.903) AW4(11.363,7.903) AW5(10.713,7.903) AW6(10.063,7.903) AW7(9.403,7.95) AW8(8.753,7.95) AW9(8.103,7.95) AW10(7.452,7.95) AW11(6.802,7.95) AW12(6.152,7.95) AW31(-8.762,8.274) AW32(-9.413,8.274) AW33(-10.063,8.274) AW34(-10.713,8.274) AW35(-11.363,8.274) AW36(-12.014,8.274) AW37(-12.664,8.274) AY2(12.664,8.792) AY3(12.014,8.792) AY4(11.363,8.792) AY5(10.713,8.792) AY6(10.063,8.742) AY7(9.403,8.864) AY8(8.753,8.864) AY9(8.103,8.864) AY10(7.452,8.864) AY11(6.802,8.864) AY12(6.152,8.864) AY31(-8.762,9.062) AY32(-9.413,9.062) AY33(-10.063,9.062) AY34(-10.713,9.062) AY35(-11.363,9.062) AY36(-12.014,9.062) AY37(-12.664,9.062) B4(11.283,-19.344) B5(10.571,-19.664) B6(9.784,-19.664) B8(8.996,-19.664) B9(8.209,-19.664) B10(7.421,-19.664) B11(6.634,-19.664) B12(5.847,-19.664) B13(5.059,-19.664) B14(4.272,-19.664) B15(3.484,-19.664) B16(2.697,-19.664) B17(1.91,-19.664) B18(1.122,-19.664) B19(0.335,-19.664) B20(-0.453,-19.664) B21(-1.24,-19.664) B22(-2.027,-19.664) B23(-2.815,-19.664) B24(-3.602,-19.664) B25(-4.39,-19.664) B26(-5.177,-19.664) B27(-5.964,-19.664) B28(-6.752,-19.664) B29(-7.539,-19.664) B30(-8.327,-19.664) B31(-9.114,-19.664) B33(-9.901,-19.664) B34(-11.129,-19.645) B36(-11.884,-19.613) BA2(12.664,9.529) BA3(12.014,9.529) BA4(11.363,9.529) BA5(10.713,9.529) BA6(10.063,9.58) BA7(9.403,9.779) BA8(8.753,9.779) BA9(8.103,9.779) BA10(7.452,9.779) BA11(6.802,9.779) BA12(6.152,9.779) BA31(-8.762,9.849) BA32(-9.413,9.849) BA33(-10.063,9.849) BA34(-10.713,9.849) BA35(-11.363,9.849) BA36(-12.014,9.849) BA37(-12.664,9.849) BB2(12.664,10.418) BB3(12.014,10.418) BB4(11.363,10.418) BB5(10.713,10.418) BB6(10.063,10.418) BB7(9.403,10.693) BB8(8.753,10.693) BB9(8.103,10.693) BB10(7.452,10.693) BB11(6.802,10.693) BB12(6.152,10.693) BB31(-8.762,10.637) BB32(-9.413,10.637) BB33(-10.063,10.637) BB34(-10.713,10.637) BB35(-11.363,10.637) BB36(-12.014,10.637) BB37(-12.664,10.637) BC2(12.664,11.307) BC3(12.014,11.307) BC4(11.363,11.307) BC5(10.713,11.307) BC6(10.063,11.256) BC7(9.403,11.608) BC8(8.753,11.608) BC9(8.103,11.608) BC10(7.452,11.608) BC11(6.802,11.608) BC12(6.152,11.608) BC31(-8.762,11.424) BC32(-9.413,11.424) BC33(-10.063,11.424) BC34(-10.713,11.424) BC35(-11.363,11.424) BC36(-12.014,11.424) BC37(-12.664,11.424) BD2(12.664,12.044) BD3(12.014,12.044) BD4(11.363,12.044) BD5(10.713,12.044) BD6(10.063,12.094) BD7(9.403,12.522) BD8(8.753,12.522) BD9(8.103,12.522) BD10(7.452,12.522) BD11(6.802,12.522) BD12(6.152,12.522) BD31(-8.762,12.211) BD32(-9.413,12.211) BD33(-10.063,12.211) BD34(-10.713,12.211) BD35(-11.363,12.211) BD36(-12.014,12.211) BD37(-12.664,12.211) BE2(12.664,12.933) BE3(12.014,12.933) BE4(11.363,12.933) BE5(10.713,12.933) BE6(10.063,12.933) BE31(-8.762,12.999) BE32(-9.413,12.999) BE33(-10.063,12.999) BE34(-10.713,12.999) BE35(-11.363,12.999) BE36(-12.014,12.999) BE37(-12.664,12.999) BF2(12.664,13.822) BF3(12.014,13.822) BF4(11.363,13.822) BF5(10.713,13.822) BF6(10.063,13.771) BF7(9.403,13.436) BF8(8.753,13.436) BF9(8.103,13.436) BF10(7.452,13.436) BF11(6.802,13.436) BF12(6.152,13.436) BF31(-8.762,13.786) BF32(-9.413,13.786) BF33(-10.063,13.786) BF34(-10.713,13.786) BF35(-11.363,13.786) BF36(-12.014,13.786) BF37(-12.664,13.786) BG2(12.664,14.558) BG3(12.014,14.558) BG4(11.363,14.558) BG5(10.713,14.558) BG6(10.063,14.609) BG7(9.403,14.351) BG8(8.753,14.351) BG9(8.103,14.351) BG10(7.452,14.351) BG11(6.802,14.351) BG12(6.152,14.351) BG31(-8.762,14.574) BG32(-9.413,14.574) BG33(-10.063,14.574) BG34(-10.713,14.574) BG35(-11.363,14.574) BG36(-12.014,14.574) BG37(-12.664,14.574) BH2(12.664,15.447) BH3(12.014,15.447) BH4(11.363,15.447) BH5(10.713,15.447) BH6(10.063,15.447) BH7(9.403,15.265) BH8(8.753,15.265) BH9(8.103,15.265) BH10(7.452,15.265) BH11(6.802,15.265) BH12(6.152,15.265) BH31(-8.762,15.361) BH32(-9.413,15.361) BH33(-10.063,15.361) BH34(-10.713,15.361) BH35(-11.363,15.361) BH36(-12.014,15.361) BH37(-12.664,15.361) BJ7(9.403,16.18) BJ8(8.753,16.18) BJ9(8.103,16.18) BJ10(7.452,16.18) BJ11(6.802,16.18) BJ12(6.032,16.091) BJ31(-8.762,16.148) BJ32(-9.413,16.148) BJ33(-10.063,16.148) BJ34(-10.713,16.148) BJ35(-11.363,16.148) BJ36(-12.014,16.148) BJ37(-12.664,16.148) BK2(12.664,16.285) BK3(12.014,16.285) BK4(11.363,16.285) BK5(10.713,16.285) BK6(10.063,16.285) BK13(5.415,16.413) BL2(12.664,17.124) BL3(12.014,17.073) BL4(11.363,17.073) BL5(10.713,17.073) BL6(10.063,17.124) BL7(9.327,17.069) BL8(8.438,17.063) BL9(7.65,17.063) BL11(6.863,17.063) BL12(6.076,17.063) BL13(5.288,17.063) BL14(4.501,17.063) BL15(3.713,17.063) BL16(2.926,17.063) BL17(2.139,17.063) BL18(1.351,17.063) BL19(0.564,17.063) BL20(-0.224,17.063) BL21(-1.011,17.063) BL22(-1.798,17.063) BL23(-2.586,17.063) BL24(-3.373,17.063) BL25(-4.161,17.063) BL26(-4.948,17.063) BL27(-5.735,17.063) BL28(-6.523,17.063) BL29(-7.31,17.063) BL30(-8.112,16.936) BL31(-8.762,16.936) BL32(-9.413,16.936) BL33(-10.063,16.936) BL34(-10.713,16.936) BL35(-11.363,16.936) BL36(-12.014,16.936) BL37(-12.664,16.936) BM2(12.352,17.738) BM3(11.701,17.815) BM5(10.789,17.815) BM6(10.145,17.916) BM7(9.225,17.713) BM8(8.438,17.713) BM9(7.65,17.713) BM11(6.863,17.713) BM12(6.076,17.713) BM13(5.288,17.713) BM14(4.501,17.713) BM15(3.713,17.713) BM16(2.926,17.713) BM17(2.139,17.713) BM18(1.351,17.713) BM19(0.564,17.713) BM20(-0.224,17.713) BM21(-1.011,17.713) BM22(-1.798,17.713) BM23(-2.586,17.713) BM24(-3.373,17.713) BM25(-4.161,17.713) BM26(-4.948,17.713) BM27(-5.735,17.713) BM28(-6.523,17.713) BM29(-7.31,17.713) BM30(-8.098,17.713) BM31(-8.885,17.713) BM33(-9.672,17.713) BM34(-10.46,17.713) BM35(-11.247,17.713) BM36(-12.014,17.672) BM37(-12.664,17.672) BN2(12.664,18.328) BN3(12.014,18.387) BN4(11.209,18.315) BN5(10.566,18.479) BN7(9.225,18.363) BN8(8.438,18.363) BN9(7.65,18.363) BN11(6.863,18.363) BN12(6.076,18.363) BN13(5.288,18.363) BN14(4.501,18.363) BN15(3.713,18.363) BN16(2.926,18.363) BN17(2.139,18.363) BN18(1.351,18.363) BN19(0.564,18.363) BN20(-0.224,18.363) BN21(-1.011,18.363) BN22(-1.798,18.363) BN23(-2.586,18.363) BN24(-3.373,18.363) BN25(-4.161,18.363) BN26(-4.948,18.363) BN27(-5.735,18.363) BN28(-6.523,18.363) BN29(-7.31,18.363) BN30(-8.098,18.363) BN31(-8.885,18.363) BN33(-9.672,18.363) BN34(-10.46,18.363) BN35(-11.248,18.363) BN36(-11.999,18.324) BN37(-12.651,18.35) BP2(12.486,18.965) BP3(11.831,19.02) BP5(10.94,19.037) BP6(10.02,18.974) BP7(9.225,19.014) BP8(8.438,19.014) BP9(7.65,19.014) BP11(6.863,19.014) BP12(6.076,19.014) BP13(5.288,19.014) BP14(4.501,19.014) BP15(3.713,19.014) BP16(2.926,19.014) BP17(2.139,19.014) BP18(1.351,19.014) BP19(0.564,19.014) BP20(-0.224,19.014) BP21(-1.011,19.014) BP22(-1.798,19.014) BP23(-2.586,19.014) BP24(-3.373,19.014) BP25(-4.161,19.014) BP26(-4.948,19.014) BP27(-5.735,19.014) BP28(-6.523,19.014) BP29(-7.31,19.014) BP30(-8.098,19.014) BP31(-8.885,19.014) BP33(-9.672,19.014) BP34(-10.46,19.014) BP35(-11.247,19.014) BP37(-12.374,18.943) BR3(11.927,19.664) BR5(11.148,19.67) BR6(10.122,19.647) BR7(9.225,19.664) BR8(8.438,19.664) BR9(7.65,19.664) BR11(6.863,19.664) BR12(6.076,19.664) BR13(5.288,19.664) BR14(4.501,19.664) BR15(3.713,19.664) BR16(2.926,19.664) BR17(2.139,19.664) BR18(1.351,19.664) BR19(0.564,19.664) BR20(-0.224,19.664) BR21(-1.011,19.664) BR22(-1.798,19.664) BR23(-2.586,19.664) BR24(-3.373,19.664) BR25(-4.161,19.664) BR26(-4.948,19.664) BR27(-5.735,19.664) BR28(-6.523,19.664) BR29(-7.31,19.664) BR30(-8.098,19.664) BR31(-8.885,19.664) BR33(-9.672,19.664) BR34(-10.46,19.664) BR35(-11.222,19.664) BR36(-11.879,19.657) C5(10.571,-19.014) C6(9.784,-19.014) C8(8.996,-19.014) C9(8.209,-19.014) C10(7.421,-19.014) C11(6.634,-19.014) C12(5.847,-19.014) C13(5.059,-19.014) C14(4.272,-19.014) C15(3.484,-19.014) C16(2.697,-19.014) C17(1.91,-19.014) C18(1.122,-19.014) C19(0.335,-19.014) C20(-0.453,-19.014) C21(-1.24,-19.014) C22(-2.027,-19.014) C23(-2.815,-19.014) C24(-3.602,-19.014) C25(-4.39,-19.014) C26(-5.177,-19.014) C27(-5.964,-19.014) C28(-6.752,-19.014) C29(-7.539,-19.014) C30(-8.327,-19.014) C31(-9.114,-19.014) C33(-9.901,-19.014) C34(-10.697,-19.025) C36(-11.831,-18.926) C37(-12.594,-18.912) D3(12.081,-18.492) D4(11.42,-18.66) D5(10.571,-18.363) D6(9.784,-18.363) D8(8.996,-18.363) D9(8.209,-18.363) D10(7.421,-18.363) D11(6.634,-18.363) D12(5.847,-18.363) D13(5.059,-18.363) D14(4.272,-18.363) D15(3.484,-18.363) D16(2.697,-18.363) D17(1.91,-18.363) D18(1.122,-18.363) D19(0.335,-18.363) D20(-0.453,-18.363) D21(-1.24,-18.363) D22(-2.027,-18.363) D23(-2.815,-18.363) D24(-3.602,-18.363) D25(-4.39,-18.363) D26(-5.177,-18.363) D27(-5.964,-18.363) D28(-6.752,-18.363) D29(-7.539,-18.363) D30(-8.327,-18.363) D31(-9.114,-18.363) D33(-9.901,-18.363) D34(-10.689,-18.363) D35(-11.341,-18.453) D37(-12.289,-18.329) E2(12.664,-17.84) E3(12.014,-17.84) E4(11.363,-17.739) E5(10.571,-17.713) E6(9.784,-17.713) E8(8.996,-17.713) E9(8.209,-17.713) E10(7.421,-17.713) E11(6.634,-17.713) E12(5.847,-17.713) E13(5.059,-17.713) E14(4.272,-17.713) E15(3.484,-17.713) E16(2.697,-17.713) E17(1.91,-17.713) E18(1.122,-17.713) E19(0.335,-17.713) E20(-0.453,-17.713) E21(-1.24,-17.713) E22(-2.027,-17.713) E23(-2.815,-17.713) E24(-3.602,-17.713) E25(-4.39,-17.713) E26(-5.177,-17.713) E27(-5.964,-17.713) E28(-6.752,-17.713) E29(-7.539,-17.713) E30(-8.327,-17.713) E31(-9.114,-17.713) E33(-9.901,-17.713) E34(-10.689,-17.713) E35(-11.363,-17.71) E36(-12.014,-17.71) E37(-12.664,-17.71) F2(12.664,-17.155) F3(12.014,-17.155) F4(11.363,-17.053) F5(10.571,-17.041) F6(9.784,-17.041) F8(8.996,-17.063) F9(8.209,-17.063) F10(7.421,-17.063) F11(6.634,-17.063) F12(5.847,-17.063) F13(5.059,-17.063) F14(4.272,-17.063) F15(3.484,-17.063) F16(2.697,-17.063) F17(1.91,-17.063) F18(1.122,-17.063) F19(0.335,-17.063) F20(-0.453,-17.063) F21(-1.24,-17.063) F22(-2.027,-17.063) F23(-2.815,-17.063) F24(-3.602,-17.063) F25(-4.39,-17.063) F26(-5.177,-17.063) F27(-5.964,-17.063) F28(-6.752,-17.063) F29(-7.539,-17.063) F30(-8.327,-17.063) F31(-9.114,-17.063) F33(-9.901,-17.063) F34(-10.713,-16.922) F35(-11.363,-16.922) F36(-12.014,-16.922) F37(-12.664,-16.922) G2(12.664,-16.367) G3(12.014,-16.367) G4(11.363,-16.367) G5(10.713,-16.367) G6(10.063,-16.367) G8(8.996,-16.413) G9(8.209,-16.413) G10(7.421,-16.413) G11(6.634,-16.413) G12(5.847,-16.413) G13(5.059,-16.413) G14(4.272,-16.413) G15(3.484,-16.413) G16(2.697,-16.413) G17(1.91,-16.413) G18(1.122,-16.413) G19(0.335,-16.413) G20(-0.453,-16.413) G21(-1.24,-16.413) G22(-2.027,-16.413) G23(-2.815,-16.413) G24(-3.602,-16.413) G25(-4.39,-16.413) G26(-5.177,-16.413) G27(-5.964,-16.413) G28(-6.752,-16.413) G29(-7.539,-16.413) G30(-8.327,-16.413) H11(6.634,-15.762) H12(5.847,-15.762) H30(-8.289,-15.762) H32(-9.413,-16.135) H33(-10.063,-16.135) H34(-10.713,-16.135) H35(-11.363,-16.135) H36(-12.014,-16.135) H37(-12.664,-16.135) J2(12.664,-15.566) J3(12.014,-15.566) J4(11.363,-15.566) J5(10.713,-15.566) J6(10.063,-15.566) J7(9.421,-15.695) J8(8.773,-15.598) J9(8.103,-15.621) J10(7.421,-15.686) J31(-8.762,-15.31) J32(-9.413,-15.348) J33(-10.063,-15.348) J34(-10.713,-15.348) J35(-11.363,-15.348) J36(-12.014,-15.348) J37(-12.664,-15.348) K2(12.664,-14.728) K3(12.014,-14.728) K4(11.363,-14.728) K5(10.713,-14.728) K6(10.063,-14.728) K7(9.403,-14.758) K8(8.753,-14.834) K9(8.103,-14.834) K10(7.452,-14.834) K11(6.802,-14.834) K12(6.152,-14.834) K31(-8.762,-14.56) K32(-9.413,-14.56) K33(-10.063,-14.56) K34(-10.713,-14.56) K35(-11.363,-14.56) K36(-12.014,-14.56) K37(-12.664,-14.56) L2(12.664,-13.839) L3(12.014,-13.839) L4(11.363,-13.839) L5(10.713,-13.839) L6(10.063,-13.89) L7(9.403,-13.919) L8(8.753,-13.97) L9(8.103,-13.996) L10(7.452,-13.996) L11(6.802,-13.996) L12(6.152,-13.996) L31(-8.762,-13.773) L32(-9.413,-13.773) L33(-10.063,-13.773) L34(-10.713,-13.773) L35(-11.363,-13.773) L36(-12.014,-13.773) L37(-12.664,-13.773) M2(12.664,-13.102) M3(12.014,-13.102) M4(11.363,-13.102) M5(10.713,-13.102) M6(10.063,-13.052) M7(9.403,-13.081) M8(8.753,-13.081) M9(8.103,-13.081) M10(7.452,-13.081) M11(6.802,-13.081) M12(6.152,-13.081) M31(-8.762,-12.985) M32(-9.413,-12.985) M33(-10.063,-12.985) M34(-10.713,-12.985) M35(-11.363,-12.985) M36(-12.014,-12.985) M37(-12.664,-12.985) N2(12.664,-12.213) N3(12.014,-12.213) N4(11.363,-12.213) N5(10.713,-12.213) N6(10.063,-12.213) N7(9.403,-12.167) N8(8.753,-12.167) N9(8.103,-12.167) N10(7.452,-12.167) N11(6.802,-12.167) N12(6.152,-12.167) N31(-8.762,-12.198) N32(-9.413,-12.198) N33(-10.063,-12.198) N34(-10.713,-12.198) N35(-11.363,-12.198) N36(-12.014,-12.198) N37(-12.664,-12.198) P2(12.664,-11.324) P3(12.014,-11.324) P4(11.363,-11.324) P5(10.713,-11.324) P6(10.063,-11.375) P7(9.403,-11.252) P8(8.753,-11.252) P9(8.103,-11.252) P10(7.452,-11.252) P11(6.802,-11.252) P12(6.152,-11.252) P31(-8.762,-11.411) P32(-9.413,-11.411) P33(-10.063,-11.411) P34(-10.713,-11.411) P35(-11.363,-11.411) P36(-12.014,-11.411) P37(-12.664,-11.411) R2(12.664,-10.588) R3(12.014,-10.588) R4(11.363,-10.588) R5(10.713,-10.588) R6(10.063,-10.537) R7(9.403,-10.338) R8(8.753,-10.338) R9(8.103,-10.338) R10(7.452,-10.338) R11(6.802,-10.338) R12(6.152,-10.338) R31(-8.762,-10.623) R32(-9.413,-10.623) R33(-10.063,-10.623) R34(-10.713,-10.623) R35(-11.363,-10.623) R36(-12.014,-10.623) R37(-12.664,-10.623) T2(12.664,-9.699) T3(12.014,-9.699) T4(11.363,-9.699) T5(10.713,-9.699) T6(10.063,-9.699) T7(9.403,-9.424) T8(8.753,-9.424) T9(8.103,-9.424) T10(7.452,-9.424) T11(6.802,-9.424) T12(6.152,-9.424) T31(-8.762,-9.836) T32(-9.413,-9.836) T33(-10.063,-9.836) T34(-10.713,-9.836) T35(-11.363,-9.836) T36(-12.014,-9.836) T37(-12.664,-9.836) U2(12.664,-8.81) U3(12.014,-8.81) U4(11.363,-8.81) U5(10.713,-8.81) U6(10.063,-8.861) U31(-8.762,-9.048) U32(-9.413,-9.048) U33(-10.063,-9.048) U34(-10.713,-9.048) U35(-11.363,-9.048) U36(-12.014,-9.048) U37(-12.664,-9.048) V2(12.664,-8.073) V3(12.014,-8.073) V4(11.363,-8.073) V5(10.713,-8.073) V6(10.063,-8.022) V7(9.403,-8.509) V8(8.753,-8.509) V9(8.103,-8.509) V10(7.452,-8.509) V11(6.802,-8.509) V12(6.152,-8.509) V31(-8.762,-8.261) V32(-9.413,-8.261) V33(-10.063,-8.261) V34(-10.713,-8.261) V35(-11.363,-8.261) V36(-12.014,-8.261) V37(-12.664,-8.261) W2(12.664,-7.184) W3(12.014,-7.184) W4(11.363,-7.184) W5(10.713,-7.184) W6(10.063,-7.184) W7(9.403,-7.595) W8(8.753,-7.595) W9(8.103,-7.595) W10(7.452,-7.595) W11(6.802,-7.595) W12(6.152,-7.595) W31(-8.762,-7.474) W32(-9.413,-7.474) W33(-10.063,-7.474) W34(-10.713,-7.474) W35(-11.363,-7.474) W36(-12.014,-7.474) W37(-12.664,-7.474) Y7(9.403,-6.68) Y8(8.753,-6.68) Y9(8.103,-6.68) Y10(7.452,-6.68) Y11(6.802,-6.68) Y12(6.152,-6.68) Y31(-8.762,-6.686) Y32(-9.413,-6.686) Y33(-10.063,-6.686) Y34(-10.713,-6.686) Y35(-11.363,-6.686) Y36(-12.014,-6.686) Y37(-12.664,-6.686)
  round 0.381 smd: AA13(5.502,-5.766) AA14(4.851,-5.766) AA29(-7.411,-5.899) AA30(-8.061,-5.899) AB29(-7.411,-5.111) AB30(-8.061,-5.111) AC13(5.502,-4.852) AC14(4.851,-4.852) AC29(-7.411,-4.324) AC30(-8.061,-4.324) AD13(5.502,-3.937) AD14(4.851,-3.937) AD29(-7.411,-3.537) AD30(-8.061,-3.537) AE13(5.502,-3.023) AE14(4.851,-3.023) AE29(-7.411,-2.749) AE30(-8.061,-2.749) AF13(5.502,-2.108) AF14(4.851,-2.108) AF29(-7.411,-1.962) AF30(-8.061,-1.962) AG13(5.502,-1.194) AG14(4.851,-1.194) AG29(-7.411,-1.174) AG30(-8.061,-1.174) AH13(5.502,-0.28) AH14(4.851,-0.28) AH29(-7.411,-0.387) AH30(-8.061,-0.387) AJ13(5.502,0.635) AJ14(4.851,0.635) AJ29(-7.411,0.4) AJ30(-8.061,0.4) AK29(-7.411,1.188) AK30(-8.061,1.188) AL13(5.502,1.549) AL14(4.851,1.549) AL29(-7.411,1.975) AL30(-8.061,1.975) AM13(5.502,2.464) AM14(4.851,2.464) AM29(-7.411,2.763) AM30(-8.061,2.763) AN13(5.502,3.378) AN14(4.851,3.378) AN29(-7.411,3.55) AN30(-8.061,3.55) AP13(5.502,4.292) AP14(4.851,4.292) AP29(-7.411,4.337) AP30(-8.061,4.337) AR13(5.502,5.207) AR14(4.851,5.207) AR29(-7.411,5.125) AR30(-8.061,5.125) AT13(5.502,6.121) AT14(4.851,6.121) AT29(-7.411,5.912) AT30(-8.061,5.912) AU13(5.502,7.036) AU14(4.851,7.036) AU29(-7.411,6.7) AU30(-8.061,6.7) AV29(-7.411,7.487) AV30(-8.061,7.487) AW13(5.502,7.95) AW14(4.851,7.95) AW29(-7.411,8.274) AW30(-8.061,8.274) AY13(5.502,8.864) AY14(4.851,8.864) AY29(-7.411,9.062) AY30(-8.061,9.062) B3(11.933,-19.616) BA13(5.502,9.779) BA14(4.851,9.779) BA29(-7.411,9.849) BA30(-8.061,9.849) BB13(5.502,10.693) BB14(4.851,10.693) BB29(-7.411,10.637) BB30(-8.061,10.637) BC13(5.502,11.608) BC14(4.851,11.608) BC29(-7.411,11.424) BC30(-8.061,11.424) BD13(5.502,12.522) BD14(4.851,12.522) BD29(-7.411,12.211) BD30(-8.061,12.211) BE29(-7.411,12.999) BE30(-8.061,12.999) BF13(5.502,13.436) BF14(4.851,13.436) BF29(-7.411,13.786) BF30(-8.061,13.786) BG13(5.502,14.351) BG14(4.851,14.351) BG29(-7.411,14.574) BG30(-8.061,14.574) BH13(5.502,15.265) BH14(4.851,15.227) BH29(-7.411,15.234) BH30(-8.061,15.361) BJ13(5.144,15.812) BJ14(4.463,15.762) BJ15(3.713,15.762) BJ16(2.926,15.762) BJ17(2.139,15.762) BJ18(1.351,15.762) BJ19(0.564,15.762) BJ20(-0.224,15.762) BJ21(-1.011,15.762) BJ22(-1.798,15.762) BJ23(-2.586,15.762) BJ24(-3.373,15.762) BJ25(-4.161,15.762) BJ26(-4.948,15.762) BJ27(-5.735,15.762) BJ28(-6.523,15.762) BJ29(-7.183,15.844) BJ30(-8.039,16.015) BK14(4.501,16.413) BK15(3.713,16.413) BK16(2.926,16.413) BK17(2.139,16.413) BK18(1.351,16.413) BK19(0.564,16.413) BK20(-0.224,16.413) BK21(-1.011,16.413) BK22(-1.798,16.413) BK23(-2.586,16.413) BK24(-3.373,16.413) BK25(-4.161,16.413) BK26(-4.948,16.413) BK27(-5.735,16.413) BK28(-6.523,16.413) BK29(-7.518,16.421) BR2(12.596,19.619) C2(12.616,-18.953) H13(5.059,-15.712) H14(4.272,-15.712) H15(3.484,-15.712) H16(2.697,-15.712) H17(1.91,-15.712) H18(1.122,-15.712) H19(0.335,-15.712) H20(-0.453,-15.712) H21(-1.24,-15.712) H22(-2.027,-15.712) H23(-2.815,-15.712) H24(-3.602,-15.712) H25(-4.39,-15.712) H26(-5.177,-15.712) H27(-5.964,-15.712) H28(-6.752,-15.712) H29(-7.539,-15.762) J14(4.272,-15.061) J15(3.484,-15.061) J16(2.697,-15.061) J17(1.91,-15.061) J18(1.122,-15.061) J19(0.335,-15.061) J20(-0.453,-15.061) J21(-1.24,-15.061) J22(-2.027,-15.061) J23(-2.815,-15.061) J24(-3.602,-15.061) J25(-4.39,-15.061) J26(-5.177,-15.061) J27(-5.964,-15.061) J28(-6.752,-15.061) J30(-7.747,-15.146) K13(5.436,-15.138) K14(4.851,-14.656) K29(-7.411,-14.56) K30(-8.061,-14.56) L13(5.502,-13.996) L14(4.851,-13.996) L29(-7.411,-13.773) L30(-8.061,-13.773) M13(5.502,-13.081) M14(4.851,-13.081) M29(-7.411,-12.985) M30(-8.061,-12.985) N13(5.502,-12.167) N14(4.851,-12.167) N29(-7.411,-12.198) N30(-8.061,-12.198) P13(5.502,-11.252) P14(4.851,-11.252) P29(-7.411,-11.411) P30(-8.061,-11.411) R13(5.502,-10.338) R14(4.851,-10.338) R29(-7.411,-10.623) R30(-8.061,-10.623) T13(5.502,-9.424) T14(4.851,-9.424) T29(-7.411,-9.836) T30(-8.061,-9.836) U29(-7.411,-9.048) U30(-8.061,-9.048) V13(5.502,-8.509) V14(4.851,-8.509) V29(-7.411,-8.261) V30(-8.061,-8.261) W13(5.502,-7.595) W14(4.851,-7.595) W29(-7.411,-7.474) W30(-8.061,-7.474) Y13(5.502,-6.68) Y14(4.851,-6.68) Y29(-7.411,-6.686) Y30(-8.061,-6.686)
  round 0.406 smd: B2(12.654,-19.654) B37(-12.595,-19.612) BR37(-12.59,19.613)
  oval 0.508x0.406 smd: B38(-13.314,-19.761) BP1(13.314,19.024) BP38(-13.314,18.996) BR1(13.314,19.748) BR38(-13.314,19.722) C1(13.314,-19.047) C38(-13.314,-18.98)
  oval 0.483x0.381 smd: BN1(13.314,18.3) BN38(-13.314,18.285) D1(13.314,-18.323) D38(-13.314,-18.218)
BTOB_60P_20_F_SAM
  round 1.016 hole 1.016 unplated: (-10.06,0) (10.066,0)
  rect 0.279x2.286 smd: 1(-7.25,-5.53) 2(-7.25,0.198) 3(-6.75,-5.53) 4(-6.75,0.198) 5(-6.25,-5.53) 6(-6.25,0.198) 7(-5.75,-5.53) 8(-5.75,0.198) 9(-5.25,-5.53) 10(-5.25,0.198) 11(-4.75,-5.53) 12(-4.75,0.198) 13(-4.25,-5.53) 14(-4.25,0.198) 15(-3.75,-5.53) 16(-3.75,0.198) 17(-3.25,-5.53) 18(-3.25,0.198) 19(-2.75,-5.53) 20(-2.75,0.198) 21(-2.25,-5.53) 22(-2.25,0.198) 23(-1.75,-5.53) 24(-1.75,0.198) 25(-1.25,-5.53) 26(-1.25,0.198) 27(-0.75,-5.53) 28(-0.75,0.198) 29(-0.25,-5.53) 30(-0.25,0.198) 31(0.25,-5.53) 32(0.25,0.198) 33(0.75,-5.53) 34(0.75,0.198) 35(1.25,-5.53) 36(1.25,0.198) 37(1.75,-5.53) 38(1.75,0.198) 39(2.25,-5.53) 40(2.25,0.198) 41(2.75,-5.53) 42(2.75,0.198) 43(3.25,-5.53) 44(3.25,0.198) 45(3.75,-5.53) 46(3.75,0.198) 47(4.25,-5.53) 48(4.25,0.198) 49(4.75,-5.53) 50(4.75,0.198) 51(5.25,-5.53) 52(5.25,0.198) 53(5.75,-5.53) 54(5.75,0.198) 55(6.25,-5.53) 56(6.25,0.198) 57(6.75,-5.53) 58(6.75,0.198) 59(7.25,-5.53) 60(7.25,0.198)
HOLE_C63D63N
  round 1.6 hole 1.6 unplated: (0,0)
HOLE_C102D102N
  round 2.591 hole 2.591 unplated: (0,0)
HOLE_O63X102DO63X102N
  oval 1.6x2.591 hole 1.6 unplated: (0,0)
HOLE_O122X102DO122X102N
  oval 3.099x2.591 hole 2.591 unplated: (0,0)
HOLE_O134X102DO134X102N
  oval 3.404x2.591 hole 2.591 unplated: (0,0)
NB_H_RT335X315B315D118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_H_RT335X350CBD118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_H_RT419X335B335D118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_NUT_CT256SB315D146_LF2
  rect 8.001x8.001 hole 3.708: 1(0,0)
NB_NUT_CT256SBD146_H91_LF2
  rect 8.001x8.001 hole 3.708: 1(0,0)
NB_NUT_CT256SBD146_H134_LF2
  rect 8.001x8.001 hole 3.708: 1(0,0)
NB_NUT_CT256SBD146_H205
  rect 8.001x8.001 hole 3.708: 1(0,0)
NB_OPEN2_5MIL_PT
  custom 0.181x0.181 smd: 1(0,-0.508) 2(0,0.508)
NB_PWR_FB_SHORT_PT
  rect 0.229x0.635 smd: 1(-0.203,0) 2(0.203,0)
NB_R0402_SHORT
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
NB_R0402_SHORT_5MIL_SMALL
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
NB_R0402_SHORT_20MIL_SMALL
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
NB_R0603_SHORT_10MIL_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_R0603_SHORT_32MIL
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
NB_R0603_SHORT_32MIL_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_TPC26T_50
  round 0.66 smd: 1(0,0)
NB_TPC26T_68
  round 0.66 smd: 1(0,0)
NB_TPC28T_68
  round 0.711 smd: 1(0,0)
T_HH_BGA_96P_20_240X240_TI
  round 0.254 smd: A1(-2.5,-2.5) A2(-2.5,-2) A3(-2.5,-1.5) A4(-2.5,-1) A5(-2.5,-0.5) A6(-2.5,0) A7(-2.5,0.5) A8(-2.5,1) A9(-2.5,1.5) A10(-2.5,2) A11(-2.5,2.5) B1(-2,-2.5) B11(-2,2.5) C1(-1.5,-2.5) C11(-1.5,2.5) D1(-1,-2.5) D11(-1,2.5) E1(-0.5,-2.5) E11(-0.5,2.5) F1(0,-2.5) F11(0,2.5) G1(0.5,-2.5) G11(0.5,2.5) H1(1,-2.5) H11(1,2.5) J1(1.5,-2.5) J11(1.5,2.5) K1(2,-2.5) K11(2,2.5) L1(2.5,-2.5) L2(2.5,-2) L3(2.5,-1.5) L4(2.5,-1) L5(2.5,-0.5) L6(2.5,0) L7(2.5,0.5) L8(2.5,1) L9(2.5,1.5) L10(2.5,2) L11(2.5,2.5)
  round 0.305 smd: B2(-2,-2) B3(-2,-1.5) B4(-2,-1) B5(-2,-0.5) B6(-2,0) B7(-2,0.5) B8(-2,1) B9(-2,1.5) B10(-2,2) C2(-1.5,-2) C10(-1.5,2) D2(-1,-2) D5(-1,-0.5) D6(-1,0) D7(-1,0.5) D8(-1,1) D10(-1,2) E2(-0.5,-2) E4(-0.5,-1) E5(-0.5,-0.5) E6(-0.5,0) E7(-0.5,0.5) E8(-0.5,1) E10(-0.5,2) F2(0,-2) F4(0,-1) F5(0,-0.5) F6(0,0) F7(0,0.5) F8(0,1) F10(0,2) G2(0.5,-2) G4(0.5,-1) G5(0.5,-0.5) G6(0.5,0) G7(0.5,0.5) G8(0.5,1) G10(0.5,2) H2(1,-2) H4(1,-1) H5(1,-0.5) H6(1,0) H7(1,0.5) H8(1,1) H10(1,2) J2(1.5,-2) J10(1.5,2) K2(2,-2) K3(2,-1.5) K4(2,-1) K5(2,-0.5) K6(2,0) K7(2,0.5) K8(2,1) K9(2,1.5) K10(2,2)
T_NB_USB_24P_10HD_ACON
  round 0.762 hole 0.762 unplated: (-3.6,0) (3.6,0)
  oval 1.219x0.864 hole 0.457: 3(3.845,1.55) 4(-3.845,1.55)
  rect 0.508x0.406 smd: 5(1.25,1.55) 6(-1.25,1.55)
  oval 0.864x1.448 hole 0.457: 7(4.22,-1.25) 8(-4.22,-1.25)
  oval 0.864x1.854 hole 0.457: 9(4.5,-3.765) 10(-4.5,-3.765)
  rect 0.305x0.889 smd: A1(-2.75,0.57) A2(-2.25,0.57) A3(-1.75,0.57) A4(-1.25,0.57) A5(-0.75,0.57) A6(-0.25,0.57) A7(0.25,0.57) A8(0.75,0.57) A9(1.25,0.57) A10(1.75,0.57) A11(2.25,0.57) A12(2.75,0.57)
  round 0.66 hole 0.406: B1(2.8,-0.65) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.2,-0.65) B5(0.8,-1.35) B6(0.4,-0.65) B7(-0.4,-0.65) B8(-0.8,-1.35) B9(-1.2,-0.65) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.65)
T_SOD962
  rect 0.203x0.254 smd: 1(-0.2,0) 2(0.2,0)
T_SW_4P_185X185_DAWNING
  rect 1.194x0.94 smd: 1(-1.2,2.226) 2(1.2,2.226) 3(-1.2,-2.226) 4(1.2,-2.226)
unnamed
  round 4.064 hole 4.064 unplated: (0,0)
unnamed#3
  round 1.016 smd: 1(0,0)
VX_2R4P0603_H28
  rect 0.508x0.838 smd: 1(-0.4,-0.825) 2(-0.4,0.825) 3(0.4,-0.825) 4(0.4,0.825)
VX_BATHOLDER_2P_2HOLD
  round 1.016 hole 1.016 unplated: (0,-8)
  round 1.245 hole 1.245 unplated: (0,8)
  rect 2.007x3.988 smd: 1(14.5,0) 2(-15.8,0)
VX_BGA_170P_31_551X472
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
