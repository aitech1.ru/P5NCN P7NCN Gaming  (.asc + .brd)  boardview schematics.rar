# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R7439  -  [VX_R0402_SMALL]  102.29 117.62 90 bottom
R7441  -  [VX_R0402_SMALL]  98.73 117.62 90 bottom
R7443  -  [VX_R0402_SMALL]  98.81 114.95 90 bottom
R7444  -  [VX_R0402_SMALL]  103.68 115.33 270 bottom
R7445  -  [VX_R0402_SMALL]  101.4 117.62 90 bottom
R7446  -  [VX_R0402_0OHM_SMALL]  106.21 112.84 180 bottom
R7447  -  [VX_R0402_0OHM_SMALL]  100.51 117.62 270 bottom
R7448  -  [VX_R0402_SMALL]  106.3 114.75 180 bottom
R7449  -  [VX_R0402_0OHM_SMALL]  102.74 112.71 180 bottom
R7450  -  [VX_R0402_0OHM_SMALL]  100.13 112.11 270 top
R7500  -  [VX_R0402_SMALL]  124.89 165.24 0 bottom
R7501  -  [VX_R0402_SMALL]  119.18 149.25 0 top
R7502  -  [VX_R0402_SMALL]  94.92 165.7 270 bottom
R7503  -  [VX_R0402_0OHM_SMALL]  126.67 164.86 90 bottom
R7506  -  [VX_R0402_SMALL]  124.89 164.23 0 bottom
R7600  -  [VX_R0402_SMALL]  124.03 183 0 top
R7601  -  [VX_R0402_SMALL]  124.03 182.11 180 top
R7602  -  [VX_R0402_SMALL]  121.95 176.7 90 top
R7603  -  [VX_R0402_SMALL]  112.6 176.67 270 top
R7608  -  [VX_R0402_SMALL]  135.43 173.7 0 top
R7609  -  [VX_R0402_SMALL]  134.04 172.61 180 top
R7610  -  [VX_R0402_SMALL]  117.29 179.14 180 top
R7611  -  [VX_R0402_SMALL]  117.29 178.25 0 top
R7612  -  [VX_R0402_SMALL]  118.92 178.45 270 top
R7613  -  [VX_R0402_SMALL]  114.63 175.91 90 top
R7614  -  [VX_R0402_SMALL]  111.78 175.6 270 top
R7615  -  [VX_R0402_SMALL]  130.61 174.97 90 top
R7616  -  [VX_R0402_SMALL]  130.61 176.75 90 top
R7617  -  [VX_R0402_SMALL]  102.24 177.28 90 top
R7618  -  [VX_R0402_SMALL]  103.07 177.69 90 top
R7619  -  [VX_R0402_SMALL]  121.72 178.3 90 top
R7700  -  [VX_R0402_SMALL]  155.75 161.81 0 bottom
R7701  -  [VX_R0402_SMALL]  155.75 162.7 180 bottom
R7702  -  [VX_R0402_SMALL]  148.79 173.27 0 top
R7704  -  [VX_R0402_SMALL]  147.22 166.16 180 top
R7708  -  [VX_R0402_SMALL]  157.4 163.08 270 bottom
R7709  -  [VX_R0402_SMALL]  158.29 163.08 270 bottom
R7710  -  [VX_R0402_SMALL]  148.88 169.04 0 top
R7711  -  [VX_R0402_SMALL]  148.88 168.15 180 top
R7712  -  [VX_R0402_SMALL]  146.7 167.69 0 top
R7713  -  [VX_R0402_SMALL]  150.35 170.61 180 top
R7714  -  [VX_R0402_SMALL]  148.77 174.64 0 top
R7715  -  [VX_R0402_SMALL]  146.13 154.8 0 top
R7716  -  [VX_R0402_SMALL]  146.13 155.69 180 top
R7717  -  [VX_R0402_SMALL]  148.51 182.77 270 bottom
R7718  -  [VX_R0402_SMALL]  147.63 182.77 90 bottom
R7719  -  [VX_R0402_SMALL]  148.06 162.57 0 top
R7800  -  [VX_R0402_SMALL]  155.61 122.8 0 bottom
R7801  -  [VX_R0402_SMALL]  155.61 123.66 180 bottom
R7802  -  [VX_R0402_SMALL]  147.24 146.17 180 top
R7803  -  [VX_R0402_SMALL]  148.66 126.31 270 top
R7808  -  [VX_R0402_SMALL]  157.55 124.14 270 bottom
R7809  -  [VX_R0402_SMALL]  158.44 124.14 90 bottom
R7810  -  [VX_R0402_SMALL]  149.66 129.94 270 bottom
R7811  -  [VX_R0402_SMALL]  148.77 129.94 90 bottom
R7812  -  [VX_R0402_SMALL]  146.61 129.94 270 bottom
R7813  -  [VX_R0402_SMALL]  145.06 140.9 90 bottom
R7814  -  [VX_R0402_SMALL]  147.24 147.46 180 top
R7815  -  [VX_R0402_SMALL]  145.97 116.04 0 top
R7816  -  [VX_R0402_SMALL]  147.63 116.04 0 top
R7817  -  [VX_R0402_SMALL]  148.06 155.69 180 top
R7818  -  [VX_R0402_SMALL]  148.06 154.8 0 top
R7819  -  [VX_R0402_SMALL]  147.94 123.33 0 top
R7900  -  [VX_R0402_SMALL]  116.8 99.17 90 top
R7901  -  [VX_R0402_SMALL]  117.65 99.17 270 top
R7902  -  [VX_R0402_SMALL]  129.29 105.16 0 top
R7903  -  [VX_R0402_SMALL]  122.99 106.57 270 top
R7908  -  [VX_R0402_SMALL]  136.37 118.97 0 top
R7909  -  [VX_R0402_SMALL]  136.37 118.03 0 top
R7910  -  [VX_R0402_SMALL]  125.15 103.93 180 top
R7911  -  [VX_R0402_SMALL]  125.15 105.04 0 top
R7912  -  [VX_R0402_SMALL]  123.88 106.57 270 top
R7913  -  [VX_R0402_SMALL]  125.15 103.04 0 top
R7914  -  [VX_R0402_SMALL]  131.45 107.51 90 top
R7915  -  [VX_R0402_SMALL]  111.81 105.55 180 bottom
R7916  -  [VX_R0402_SMALL]  111.81 106.44 0 bottom
R7917  -  [VX_R0402_SMALL]  137.34 107.25 270 top
R7918  -  [VX_R0402_SMALL]  138.23 107.25 90 top
R7919  -  [VX_R0402_SMALL]  121.13 105.6 270 top
R8000  -  [VX_R0402_SMALL]  7.29 177.31 180 top
R8003  -  [VX_R0402_0OHM_SMALL]  12.78 182.55 90 bottom
R8004  -  [VX_R0402_0OHM_SMALL]  9.14 176.04 270 top
R8005  -  [VX_R0402_0OHM_SMALL]  7.65 176.01 270 top
R8006  -  [VX_R0402_0OHM_SMALL]  8.81 169.43 90 bottom
R8007  -  [VX_R0402_0OHM_SMALL]  7.93 169.43 90 bottom
R8008  -  [VX_R0402_0OHM_SMALL]  11.61 171.39 90 bottom
R8012  -  [VX_R0402_SMALL]  11.95 182.55 90 bottom
R8013  -  [VX_R0402_0OHM_SMALL]  10.96 182.17 90 bottom
R8014  -  [VX_R0402_SMALL]  10.11 182.17 90 bottom
R8015  -  [VX_R0402_SMALL]  16.42 178.37 180 bottom
R8017  -  [VX_R0402_0OHM_SMALL]  13.61 182.17 90 bottom
R8019  -  [VX_R0402_SMALL]  21.77 176.93 270 bottom
R8020  -  [VX_R0402_0OHM_SMALL]  19.99 176.93 90 bottom
R8021  -  [VX_R0402_SMALL]  13.64 184.8 270 bottom
R8023  -  [VX_R0402_SMALL]  15.38 179.64 270 bottom
R8024  -  [VX_R0402_SMALL]  6.53 181.5 180 top
R8025  -  [VX_R0402_SMALL]  2.59 181.24 270 bottom
R8026  -  [VX_R0402_H24_SMALL]  74 172.96 180 bottom
R8027  -  [VX_R0402_0OHM_SMALL]  16.42 177.52 180 bottom
R8028  -  [VX_R0402_SMALL]  7.42 184.8 90 bottom
R8029  -  [VX_R0402_SMALL]  14.53 184.8 270 bottom
R8030  -  [VX_R0402_SMALL]  15.81 181.91 180 bottom
R8031  -  [VX_R0402_SMALL]  15.82 182.8 0 bottom
R8032  -  [VX_R0402_0OHM_SMALL]  5.77 180.35 270 bottom
R8033  -  [VX_R0402_SMALL]  5 176.67 0 top
R8034  -  [VX_R0402_0OHM_SMALL]  7.06 168.8 90 bottom
R8035  -  [VX_R0402_SMALL]  4.75 180.18 90 bottom
R8036  -  [VX_R0402_SMALL]  3.83 180.18 90 bottom
R8037  -  [VX_R0402_SMALL]  16.58 179.21 180 bottom
R8038  -  [VX_R0402_SMALL]  5.55 175.13 270 bottom
R8039  -  [VX_R0402_H22_SMALL]  23.93 173.12 0 top
R8040  -  [VX_R0402_0OHM_SMALL]  23.39 173.37 180 bottom
R8041  -  [VX_R0402_SMALL]  6.53 184.8 90 bottom
R8043  -  [VX_R0402_SMALL]  26.09 174.26 90 bottom
R8044  -  [VX_R0402_SMALL]  22.02 175.15 270 bottom
R8045  -  [VX_R0402_SMALL]  25.2 174.26 90 bottom
R8046  -  [VX_R0402_SMALL]  5.13 184.8 90 bottom
R8047  -  [VX_R0402_SMALL]  4.88 178.45 90 top
R8048  -  [VX_R0402_0OHM_SMALL]  2.85 176.67 0 top
R8049  -  [VX_R0402_SMALL]  12.7 176.42 0 top
R8050  -  [VX_R0402_SMALL]  41.58 173.88 90 bottom
R8051  -  [VX_R0402_SMALL]  30.66 174.13 90 bottom
R8052  -  [VX_R0402_SMALL]  64.82 169.81 90 bottom
R8053  -  [VX_R0805_H24_SMALL]  45.17 169.3 270 bottom
R8054  -  [VX_R0805_H24_SMALL]  32.94 170.19 0 bottom
R8055  -  [VX_R0805_H24_SMALL]  64.19 163.82 0 top
R8056  -  [VX_R0402_SMALL]  12.5 171.39 270 bottom
R8057  -  [VX_R0402_SMALL]  10.21 169.28 0 bottom
R8058  -  [VX_R0402_SMALL]  4.5 168.8 270 bottom
R8059  -  [VX_R0402_SMALL]  2.46 168.92 0 bottom
R8060  -  [VX_R0402_SMALL]  5.33 168.8 270 bottom
R8061  -  [VX_R0402_SMALL]  2.46 169.81 0 bottom
R8062  -  [VX_R0402_SMALL]  18.09 172.1 0 bottom
R8063  -  [VX_R0402_SMALL]  23.88 176.47 0 bottom
R8064  -  [VX_R0402_SMALL]  19.3 173.37 270 bottom
R8065  -  [VX_R0402_SMALL]  19.99 170.83 90 bottom
R8066  -  [VX_R0402_SMALL]  25.58 172.99 180 bottom
R8067  -  [VX_R0402_SMALL]  3.61 184.16 0 top
R8068  -  [VX_R0402_0OHM_SMALL]  68.07 171.82 270 bottom
R8069  -  [VX_R0402_0OHM_SMALL]  6.15 182.39 0 top
R8070  -  [VX_R0805_H24_SMALL]  87.3 169.05 270 bottom
R8071  -  [VX_R0402_SMALL]  7.42 165.75 90 bottom
R8072  -  [VX_R0805_H24_SMALL]  21.13 164.48 0 bottom
R8073  -  [VX_R0805_H24_SMALL]  2.85 156.22 270 top
R8075  -  [VX_R0402_SMALL]  2.85 174.89 180 top
R8076  -  [VX_R0402_0OHM_SMALL]  25.96 176.93 90 bottom
R8079  -  [VX_R0402_SMALL]  3.99 178.45 90 top
R8080  -  [VX_R0402_SMALL]  13.16 177.31 0 top
R8081  -  [VX_R0402_SMALL]  16.94 173.37 270 bottom
R8082  -  [VX_R0402_H24_SMALL]  48.44 170.76 0 top
R8083  -  [VX_R0402_SMALL]  4.62 171.08 90 bottom
R8084  -  [VX_R0402_H22_SMALL]  34.6 176.54 0 top
R8085  -  [VX_R0402_SMALL]  2.59 185.05 180 bottom
R8087  -  [VX_R0402_SMALL]  4.24 184.8 90 bottom
R8088  -  [VX_R0402_H24_SMALL]  2.72 153.94 90 top
R8089  -  [VX_R0402_SMALL]  17.09 176.57 180 top
R8091  -  [VX_R0402_0OHM_SMALL]  25.1 176.93 270 bottom
R8092  -  [VX_R0402_SMALL]  16.05 173.37 270 bottom
R8093  -  [VX_R0402_SMALL]  3.86 175.99 270 bottom
R8094  -  [VX_R0402_SMALL]  22.66 176.93 90 bottom
R8096  -  [VX_R0402_SMALL]  15.55 170.7 90 bottom
R8097  -  [VX_R0402_0OHM_SMALL]  2.85 171.08 90 bottom
R8098  -  [VX_R0402_SMALL]  9.83 171.39 270 bottom
R8099  -  [VX_R0402_SMALL]  2.59 177.56 180 top
R8100  -  [VX_R0603_H28_SMALL]  223.57 70.37 0 bottom
R8101  -  [VX_R0603_H28_SMALL]  203.38 64.91 0 bottom
R8102  -  [VX_R0402_SMALL]  222.43 78.12 90 top
R8103  -  [VX_R0402_SMALL]  214.94 78.37 90 top
R8104  -  [VX_R0402_SMALL]  220.4 79.14 180 top
R8105  -  [VX_R0402_SMALL]  216.33 79.01 0 top
R8106  -  [VX_R0402_SMALL]  219.76 80.66 270 top
R8107  -  [VX_R0402_SMALL]  216.84 80.53 270 top
R8108  -  [VX_R0402_SMALL]  223.44 78.12 90 top
R8109  -  [VX_R0402_SMALL]  213.16 78.25 0 top
R8110  -  [VX_R0402_SMALL]  217.6 89.3 180 top
R8111  -  [VX_R0402_0OHM_SMALL]  223.01 76.42 90 top
R8200  -  [VX_R0603_H28_SMALL]  141.32 70.47 90 bottom
R8201  -  [VX_R0402_SMALL]  136.65 66.11 90 bottom
R8202  -  [VX_R0805_H24_SMALL]  142.16 75.4 270 bottom
R8203  -  [VX_R0402_SMALL]  142.16 68.8 0 bottom
R8204  -  [VX_R0402_0OHM_SMALL]  137.72 67.91 270 bottom
R8205  -  [VX_R0402_SMALL]  138.61 67.91 90 bottom
R8206  -  [VX_R0402_SMALL]  139.2 69.12 0 bottom
R8207  -  [VX_R0402_SMALL]  145.5 68.55 270 bottom
R8208  -  [VX_R0402_0OHM_SMALL]  143.82 68.8 0 bottom
R8300  -  [VX_R0402_SMALL]  138.74 64.78 270 top
R8301  -  [VX_R0805_H24_SMALL]  120.43 70.42 0 bottom
R8302  -  [VX_R0402_SMALL]  134.04 65.43 180 top
R8303  -  [VX_R0402_0OHM_SMALL]  136.7 66.28 90 top
R8304  -  [VX_R0402_0OHM_SMALL]  140.64 62.88 270 top
R8305  -  [VX_R0402_0OHM_SMALL]  140.64 61.28 270 top
R8306  -  [VX_R0402_SMALL]  138.1 59.83 180 top
R8307  -  [VX_R0402_SMALL]  140.41 67.37 270 top
R8308  -  [VX_R0402_SMALL]  138.1 60.72 0 top
R8400  -  [VX_R0402_SMALL]  175.64 24.7 180 top
R8401  -  [VX_R0402_SMALL]  167.31 26 270 top
R8402  -  [VX_R0402_SMALL]  164.26 29.05 0 top
R8403  -  [VX_R0402_SMALL]  170.1 25.87 270 top
R8700  -  [VX_R0402_SMALL]  153.95 86.1 0 bottom
R8701  -  [VX_R0402_SMALL]  157 86.45 90 bottom
R8702  -  [VX_R0402_SMALL]  154.36 84.6 270 bottom
R8704  -  [VX_R0402_SMALL]  155.25 84.6 270 bottom
R8705  -  [VX_R0402_SMALL]  155.7 85.87 180 bottom
R8706  -  [VX_R0402_SMALL]  149.66 88.15 270 bottom
R8707  -  [VX_R0402_SMALL]  150.55 88.15 270 bottom
R8709  -  [VX_R0402_0OHM_SMALL]  147.91 84.79 180 bottom
R8710  -  [VX_R0402_SMALL]  145.59 87.85 0 bottom
R8711  -  [VX_R0805_H24_SMALL]  123.44 80.09 180 bottom
R8712  -  [VX_R0402_SMALL]  157.33 82.52 0 bottom
R8714  -  [VX_R0402_SMALL]  151.56 82.31 90 top
R8715  -  [VX_R0402_SMALL]  160.38 84.42 90 bottom
R8716  -  [VX_R0402_0OHM_SMALL]  149.78 82.31 90 top
R8717  -  [VX_R0402_SMALL]  147.24 82.06 0 bottom
R8718  -  [VX_R0402_SMALL]  151.82 76.98 90 bottom
R8719  -  [VX_R0402_SMALL]  152.71 77.31 90 bottom
R8720  -  [VX_R0402_SMALL]  155.5 79.01 180 bottom
R8721  -  [VX_R0402_0OHM_SMALL]  146.86 78.12 180 bottom
R8723  -  [VX_R0805_H24_SMALL]  138.01 78.97 270 bottom
R8725  -  [VX_R0402_0OHM_SMALL]  147.24 91.91 180 top
R8726  -  [VX_R0402_0OHM_SMALL]  144.32 91.96 180 top
R8727  -  [VX_R0805_H24_SMALL]  153.72 108.3 0 bottom
R8728  -  [VX_R0402_0OHM_SMALL]  143.94 97.88 180 top
R8729  -  [VX_R0402_0OHM_SMALL]  144.96 98.9 180 top
R8730  -  [VX_R0612_4P_H31]  128.7 71.01 0 top
R8731  -  [VX_R0402_SMALL]  126.42 70.75 180 top
R8732  -  [VX_R0402_SMALL]  126.42 71.64 180 top
R8733  -  [VX_R0612_4P_H31]  128.45 74.44 0 top
R8734  -  [VX_R0402_SMALL]  125.11 73.85 180 top
R8735  -  [VX_R0402_SMALL]  125.11 74.74 180 top
R8736  -  [VX_R0402_SMALL]  124.51 70.25 0 top
R8737  -  [VX_R0402_SMALL]  120.62 68.09 270 top
R8738  -  [VX_R0402_SMALL]  117.53 70.88 180 top
R8739  -  [VX_R0402_SMALL]  121.46 68.09 270 top
R8740  -  [VX_R0402_SMALL]  118.03 73.55 270 top
R8741  -  [VX_R0402_SMALL]  158.67 85.18 90 bottom
R8800  -  [VX_R1206_H35]  2.94 115.14 270 top
R8801  -  [VX_R1206_H26]  15.42 107.41 0 top
R8802  -  [VX_R0402_SMALL]  246.05 13.63 180 top
R8803  -  [VX_R0603_H24_SMALL]  220.9 33.11 90 top
R8804  -  [VX_R0603_H24_SMALL]  222.17 33.11 90 top
R8805  -  [VX_R0402_SMALL]  216.21 29.94 90 top
R8806  -  [VX_R0402_SMALL]  217.73 31.72 180 top
R8807  -  [VX_R0402_SMALL]  217.48 29.94 270 top
R8808  -  [VX_R0402_SMALL]  219.38 31.72 180 top
R8809  -  [VX_R1206_H31]  245.84 11.87 0 top
R8810  -  [VX_R0805_H24_SMALL]  233.6 17.24 180 top
R8811  -  [VX_R0402_SMALL]  214.68 24.86 90 top
R8812  -  [VX_R0805_H24_SMALL]  26.47 108.59 270 top
R8813  -  [VX_R0402_SMALL]  215.52 24.86 270 top
R8814  -  [VX_R0402_SMALL]  243.97 13.63 180 top
R8815  -  [VX_R0402_SMALL]  217.73 35.65 90 top
R8816  -  [VX_R0402_SMALL]  219.38 32.73 0 top
R8817  -  [VX_R0402_SMALL]  219.38 33.75 180 top
R8818  -  [VX_R0402_SMALL]  220.7 32.99 90 bottom
R8819  -  [VX_R0402_SMALL]  220.14 39.08 90 bottom
R8820  -  [VX_R0402_SMALL]  219.63 32.99 270 bottom
R8821  -  [VX_R0402_0OHM_SMALL]  222.05 39.08 90 bottom
R8822  -  [VX_R0402_0OHM_SMALL]  219.25 52.54 180 bottom
R8900  -  [VX_R0402_SMALL]  182.03 84.37 270 top
R8901  -  [VX_R0402_SMALL]  185.03 84.24 180 top
R8902  -  [VX_R0402_SMALL]  181.26 81.27 90 top
R8903  -  [VX_R0402_SMALL]  180.24 81.27 270 top
R8904  -  [VX_R0805_H24_SMALL]  170.61 84.42 0 top
R8905  -  [VX_R0402_SMALL]  175.18 89.35 270 top
R8907  -  [VX_R0402_SMALL]  184.96 86.25 0 top
R8909  -  [VX_R0402_SMALL]  177.09 89.69 180 top
R8910  -  [VX_R0402_SMALL]  184.96 87.26 0 top
R8911  -  [VX_R0402_SMALL]  175.17 84.98 0 top
R8912  -  [VX_R0402_SMALL]  181.47 88.14 90 top
R9100  -  [VX_R0402_SMALL]  138.99 65.04 0 bottom
R9102  -  [VX_R0402_SMALL]  154.22 45.85 0 top
R9103  -  [VX_R0402_SMALL]  155.63 45.05 270 top
R9104  -  [VX_R0402_SMALL]  195.03 70.75 270 bottom
R9105  -  [VX_R0402_SMALL]  220.65 87.01 180 bottom
R9106  -  [VX_R0402_SMALL]  220.65 83.96 180 bottom
R9107  -  [VX_R0402_SMALL]  150.04 37.94 0 top
R9108  -  [VX_R0402_SMALL]  145.87 33.57 0 top
R9109  -  [VX_R0402_SMALL]  233.17 62.14 0 bottom
R9110  -  [VX_R0402_SMALL]  212.4 82.18 270 bottom
R9111  -  [VX_R0402_SMALL]  199.06 82.14 90 top
R9112  -  [VX_R0402_SMALL]  141.02 66.51 0 bottom
R9200  -  [VX_R0402_SMALL]  128.96 49.93 270 top
R9202  -  [VX_R0402_SMALL]  134.8 52.08 90 top
R9203  -  [VX_R0402_SMALL]  142.28 50.69 0 top
R9204  -  [VX_R0402_SMALL]  136.45 48.48 0 top
R9205  -  [VX_R0402_0OHM_SMALL]  136.45 50.81 180 top
R9206  -  [VX_R0402_0OHM_SMALL]  132.86 53.38 180 top
R9207  -  [VX_R0402_0OHM_SMALL]  130.89 48.27 90 top
R9208  -  [VX_R0402_0OHM_SMALL]  130.05 48.27 90 top
R9209  -  [VX_R0402_0OHM_SMALL]  128.32 48.27 90 top
R9210  -  [VX_R0402_0OHM_SMALL]  129.21 48.27 90 top
R9211  -  [VX_R0402_0OHM_SMALL]  127.23 49.93 270 top
R9212  -  [VX_R0402_0OHM_SMALL]  128.07 49.93 270 top
R9213  -  [VX_R0402_0OHM_SMALL]  129.85 49.93 270 top
R9400  -  [VX_R0603_H28_SMALL]  74.98 160.75 270 bottom
R9401  -  [VX_R0805_H24_SMALL]  75.22 153.74 90 bottom
R9402  -  [VX_R0402_0OHM_SMALL]  80.19 161.13 0 bottom
R9403  -  [VX_R0402_SMALL]  78.66 160.16 270 top
R9404  -  [VX_R0402_SMALL]  76.12 160.65 90 bottom
R9405  -  [VX_R0402_SMALL]  77.65 162.15 0 bottom
R9406  -  [VX_R0402_SMALL]  78.54 161.13 0 bottom
R9407  -  [VX_R0402_SMALL]  72.62 153.91 0 bottom
R9408  -  [VX_R0402_0OHM_SMALL]  73.58 153 180 bottom
R9500  -  [VX_R0603_H28_SMALL]  120.57 62.45 180 top
R9501  -  [VX_R0805_H24_SMALL]  120.7 59.66 180 top
R9502  -  [VX_R0402_SMALL]  116.66 62.93 270 top
R9503  -  [VX_R0402_SMALL]  122.99 62.58 0 top
R9504  -  [VX_R0402_SMALL]  117.87 65 180 top
R9505  -  [VX_R0402_SMALL]  118.87 66.26 270 top
R9506  -  [VX_R0402_SMALL]  120.61 64.27 0 top
R9507  -  [VX_R0402_0OHM_SMALL]  125.53 62.58 180 top
R9600  -  [VX_R0402_SMALL]  89.03 175.35 180 top
R9601  -  [VX_R0805_H24_SMALL]  85.9 171.04 90 top
R9602  -  [VX_R0402_SMALL]  76.63 178.02 90 bottom
R9603  -  [VX_R0603_H28_SMALL]  84.63 175.23 180 top
R9604  -  [VX_R0402_SMALL]  90.35 178.78 180 top
R9605  -  [VX_R0402_SMALL]  89.97 176.62 270 top
R9606  -  [VX_R0402_SMALL]  90.35 177.89 180 top
R80100  -  [VX_R0402_SMALL]  11.3 175.53 0 top
R80101  -  [VX_R0402_SMALL]  5.51 172.1 270 bottom
R80102  -  [VX_R0402_SMALL]  10.21 170.12 180 bottom
R80103  -  [VX_R0402_0OHM_SMALL]  21.6 172.99 180 bottom
R80112  -  [VX_R0402_SMALL]  11.23 179.85 180 top
R80124  -  [VX_R0402_0OHM_SMALL]  4.88 182.77 90 top
R80125  -  [VX_R0402_SMALL]  10.21 168.44 0 bottom
R80130  -  [VX_R0402_SMALL]  6.66 170.07 180 bottom
R80135  -  [VX_R0402_SMALL]  6.22 168.8 270 bottom
R80140  -  [VX_R0402_SMALL]  18.47 173.37 270 bottom
R80145  -  [VX_R0402_SMALL]  23.88 177.31 0 bottom
R80147  -  [VX_R0402_SMALL]  17.2 147.97 0 top
R80148  -  [VX_R0402_SMALL]  19.23 148.91 180 top
R80149  -  [VX_R0402_SMALL]  17.65 150.26 90 top
R80150  -  [VX_R0402_SMALL]  17.2 150.48 180 bottom
R80151  -  [VX_R0402_0OHM_SMALL]  11.21 181.86 0 top
RN1201  -  [VX_2R4P0603_H28]  255.02 35.27 180 bottom
RN1202  -  [VX_2R4P0603_H28]  252.61 31.08 180 bottom
RN3400  -  [VX_2R4P0603_H28]  252.65 137.3 90 bottom
RN3401  -  [VX_2R4P0603_H28]  252.65 140.1 90 bottom
RN3402  -  [VX_2R4P0603_H28]  252.65 142.89 90 bottom
RN3403  -  [VX_2R4P0603_H28]  252.65 146.06 90 bottom
RN4301  -  [VX_2R4P0603_H28]  92.13 180.23 0 bottom
RN4302  -  [VX_2R4P0603_H28]  89.71 180.23 0 bottom
RN4500  -  [VX_2R4P0603_H28]  54.28 175.02 180 bottom
RN4501  -  [VX_2R4P0603_H28]  72.57 178.58 180 bottom
RN4502  -  [VX_2R4P0603_H28]  69.01 177.94 180 bottom
RN4503  -  [VX_2R4P0603_H28]  66.47 177.94 180 bottom
RN4504  -  [VX_2R4P0603_H28]  63.93 177.94 180 bottom
RN4505  -  [VX_2R4P0603_H28]  61.39 177.94 180 bottom
RN4800  -  [VX_2R4P0603_H28]  255.19 87.64 90 top
RN4801  -  [VX_2R4P0603_H28]  255.19 98.06 90 top
RN4802  -  [VX_2R4P0603_H28]  255.19 100.47 90 top
RN4803  -  [VX_2R4P0603_H28]  255.19 84.72 90 top
RN5301  -  [VX_2R4P0603_H28]  238.18 80.79 0 bottom
RN5500  -  [VX_2R4P0603_H28]  254.15 47.48 270 top
RN5501  -  [VX_2R4P0603_H28]  255.87 44.76 0 bottom
RN5502  -  [VX_2R4P0603_H28]  254.36 45.15 270 top
RN5503  -  [VX_2R4P0603_H28]  251.93 72.02 270 top
RN5504  -  [VX_2R4P0603_H28]  253.5 72.72 90 bottom
RN5505  -  [VX_2R4P0603_H28]  251.93 69.35 270 top
SP1202  -  [NB_R0603_SHORT_32MIL]  231.45 53.05 90 top
SP2601  -  [NB_R0603_SHORT_32MIL]  194.11 44.04 0 top
SP4502  -  [NB_R0603_SHORT_32MIL]  53.61 184.18 180 bottom
SP5101  -  [NB_R0603_SHORT_32MIL]  38.54 45.69 180 bottom
SR300  -  [VX_R0402_SMALL_SHORT]  172.89 151.4 0 top
SR400  -  [VX_R0402_SMALL_SHORT]  204.32 151.71 0 top
SR8000  -  [NB_R0402_SHORT_5MIL_SMALL]  8.77 182.79 180 bottom
SR8001  -  [NB_R0402_SHORT_5MIL_SMALL]  9.58 183.91 90 top
SR8100  -  [NB_R0603_SHORT_32MIL_SMALL]  222.81 73.17 0 top
SR8101  -  [NB_R0603_SHORT_32MIL_SMALL]  213.54 73.29 0 top
SR8102  -  [NB_R0402_SHORT_5MIL_SMALL]  224.46 76.41 90 top
SR8103  -  [NB_R0402_SHORT_5MIL_SMALL]  213.16 76.47 0 top
SR8104  -  [NB_R0603_SHORT_32MIL_SMALL]  240.46 65.8 90 top
SR8200  -  [NB_R0402_SHORT_5MIL_SMALL]  138.74 75.28 180 bottom
SR8300  -  [NB_R0603_SHORT_32MIL]  128.58 61.74 0 top
SR8301  -  [NB_R0603_SHORT_32MIL_SMALL]  129.97 63.64 270 top
SR8302  -  [NB_R0402_SHORT_20MIL_SMALL]  134.93 67.45 0 top
SR8303  -  [NB_R0402_SHORT_20MIL_SMALL]  136.07 65.04 0 top
SR8400  -  [NB_R0402_SHORT_20MIL_SMALL]  175.06 27.83 0 top
SR8700  -  [NB_R0402_SHORT_5MIL_SMALL]  151.42 88.17 270 bottom
SR8701  -  [NB_R0402_SHORT_5MIL_SMALL]  152.71 87.9 180 bottom
SR8702  -  [NB_R0402_SHORT_5MIL_SMALL]  146.1 77.06 0 bottom
SR8703  -  [NB_R0402_SHORT_20MIL_SMALL]  156.52 83.79 180 top
SR8704  -  [NB_R0402_SHORT_20MIL_SMALL]  117.65 83.91 270 top
SR8705  -  [NB_R0402_SHORT_20MIL_SMALL]  123.53 88.55 270 top
SR8706  -  [NB_R0402_SHORT_20MIL_SMALL]  143.56 93.49 270 top
SR8707  -  [NB_R0402_SHORT_5MIL_SMALL]  156.52 81.12 180 top
SR8800  -  [NB_R0402_SHORT_20MIL_SMALL]  216.84 28.54 0 top
SR8801  -  [NB_R0402_SHORT_20MIL_SMALL]  214.55 27.65 0 top
SR8802  -  [NB_R0402_SHORT_20MIL_SMALL]  214.55 26.76 0 top
SR8803  -  [NB_R0603_SHORT_32MIL_SMALL]  226.11 27.48 180 top
SR8804  -  [NB_R0603_SHORT_32MIL_SMALL]  228.4 25.73 180 top
SR8805  -  [NB_R0603_SHORT_32MIL_SMALL]  228.4 24.52 180 top
SR8806  -  [NB_R0603_SHORT_32MIL]  226.37 32.22 90 bottom
SR8807  -  [NB_R0402_SHORT]  214.55 30.45 180 top
SR8900  -  [NB_R0402_SHORT_5MIL_SMALL]  174.93 79.77 270 top
SR8901  -  [NB_R0402_SHORT_20MIL_SMALL]  176 82.41 180 top
SR8902  -  [NB_R0402_SHORT_5MIL_SMALL]  175.31 81.55 0 top
SR8903  -  [NB_R0402_SHORT_5MIL_SMALL]  177.09 81.55 0 top
SR8906  -  [NB_R0402_SHORT_20MIL_SMALL]  183.67 87.26 270 top
SR8908  -  [NB_R0402_SHORT_5MIL_SMALL]  177.11 88.81 0 top
SR8909  -  [NB_R0402_SHORT_20MIL_SMALL]  173.79 89.81 180 bottom
SR8910  -  [NB_R0402_SHORT_5MIL_SMALL]  176.71 90.64 0 top
SR9100  -  [NB_R0402_SHORT_5MIL_SMALL]  148.13 46.96 0 top
SR9101  -  [NB_R0402_SHORT_5MIL_SMALL]  136.07 40.99 270 top
SR9102  -  [NB_R0603_SHORT_10MIL_SMALL]  143.56 87.6 0 bottom
SR9103  -  [NB_R0402_SHORT_5MIL_SMALL]  140.77 33.16 180 top
SR9104  -  [NB_R0402_SHORT_5MIL_SMALL]  213.28 82.18 90 bottom
SR9204  -  [NB_R0402_SHORT_5MIL_SMALL]  134.44 47.84 180 top
SR9205  -  [NB_R0402_SHORT_5MIL_SMALL]  142.29 48.91 0 top
SR9206  -  [NB_R0402_SHORT_5MIL_SMALL]  142.29 49.8 0 top
SR9400  -  [NB_R0402_SHORT_5MIL_SMALL]  79.51 153.51 0 bottom
T300  -  [NB_TPC26T_50]  169.44 149.91 0 top
T0301  -  [NB_TPC26T_68]  67.78 147.56 0 top
T400  -  [NB_TPC26T_50]  206.79 148.79 270 top
T0500  -  [NB_TPC26T_68]  17.07 126.15 0 top
T0700  -  [NB_TPC26T_68]  22.81 147.46 0 top
T0701  -  [NB_TPC26T_68]  21.17 146.69 0 top
T0702  -  [NB_TPC26T_68]  67.56 125.03 180 bottom
T0703  -  [NB_TPC26T_68]  23.01 149.47 0 top
T0704  -  [NB_TPC26T_68]  65.86 123.61 180 bottom
T0705  -  [NB_TPC26T_68]  65.81 125.34 180 bottom
T0706  -  [NB_TPC26T_68]  69.66 118.85 180 bottom
T0707  -  [NB_TPC26T_68]  28.12 133.75 0 top
T0708  -  [NB_TPC26T_68]  25.12 134.1 0 top
T0709  -  [NB_TPC26T_68]  18.36 121.61 0 top
T0710  -  [NB_TPC26T_68]  20.37 121.61 0 top
T0714  -  [NB_TPC26T_68]  24.64 148.68 0 top
T0717  -  [NB_TPC26T_68]  25.77 137.95 0 top
T0719  -  [NB_TPC26T_68]  26.04 135.65 0 top
T0722  -  [NB_TPC26T_68]  27.97 140.66 0 top
T0724  -  [NB_TPC26T_68]  26.31 141.19 0 top
T0729  -  [NB_TPC26T_68]  20.12 136.77 0 top
T0730  -  [NB_TPC26T_68]  20.24 134.97 0 top
T0732  -  [NB_TPC26T_68]  25.83 150.64 0 top
T0734  -  [NB_TPC26T_68]  23.62 151.54 0 top
T0745  -  [NB_TPC26T_68]  24.54 146.88 0 top
T1000  -  [NB_TPC26T_68]  36.7 133.72 0 top
T1001  -  [NB_TPC26T_68]  34.77 133.8 0 top
T1002  -  [NB_TPC26T_68]  56.03 133.37 0 top
T1003  -  [NB_TPC26T_68]  57.51 134.31 0 top
T1101  -  [NB_TPC28T_68]  236.65 39.82 0 bottom
T1102  -  [NB_TPC28T_68]  227.95 42.04 0 bottom
T1103  -  [NB_TPC28T_68]  228.09 44.06 0 bottom
T1104  -  [NB_TPC28T_68]  229.54 41.36 0 bottom
T1105  -  [NB_TPC26T_68]  238.49 28.83 180 bottom
T1106  -  [NB_TPC26T_68]  234.39 27.49 180 bottom
T1107  -  [NB_TPC26T_68]  234.21 25.75 90 top
T1108  -  [NB_TPC26T_68]  235.44 24.53 90 top
T1109  -  [NB_TPC26T_68]  250.94 26.76 90 top
T1110  -  [NB_TPC26T_68]  249.19 27.13 90 top
T1111  -  [NB_TPC26T_68]  246.23 28.83 180 bottom
T1112  -  [NB_TPC26T_68]  239.24 27.24 180 bottom
T1205  -  [NB_TPC26T_68]  228.68 52.32 180 bottom
T1206  -  [NB_TPC26T_68]  230.71 52.75 180 bottom
T1207  -  [NB_TPC26T_68]  228.27 54.45 180 bottom
T1208  -  [NB_TPC26T_68]  230 54.63 180 bottom
T1209  -  [NB_TPC26T_68]  233.31 51.96 180 bottom
T1210  -  [NB_TPC26T_68]  230.43 50.87 180 bottom
T1301  -  [NB_TPC26T_68]  212.65 58.64 0 top
T1302  -  [NB_TPC26T_68]  210.72 60.74 0 top
T1600  -  [NB_TPC26T_68]  74.6 82.9 180 bottom
T1601  -  [NB_TPC26T_68]  80.32 84.75 180 bottom
T1602  -  [NB_TPC26T_68]  80.32 86.56 180 bottom
T1603  -  [NB_TPC26T_68]  74.6 80.99 180 bottom
T1700  -  [NB_TPC26T_68]  84.71 52.49 180 bottom
T1701  -  [NB_TPC26T_68]  82.7 52.49 180 bottom
T1702  -  [NB_TPC26T_68]  72.44 52.49 180 bottom
T1703  -  [NB_TPC26T_68]  74.24 52.49 180 bottom
T2201  -  [NB_TPC26T_68]  175.01 48.61 0 top
T2202  -  [NB_TPC26T_68]  175.11 46.65 0 top
T2203  -  [NB_TPC26T_68]  181.28 55.21 0 top
T2204  -  [NB_TPC26T_68]  175.03 64.23 0 top
T2205  -  [NB_TPC26T_68]  190.68 54.62 0 top
T2206  -  [NB_TPC26T_68]  188.16 55.52 0 top
T2400  -  [NB_TPC26T_68]  175.57 50.74 0 top
T2401  -  [NB_TPC26T_68]  185.04 59.01 180 bottom
T2402  -  [NB_TPC26T_68]  173.91 55.77 0 top
T2403  -  [NB_TPC26T_68]  184 64.32 270 top
T2404  -  [NB_TPC26T_68]  194.36 59.2 270 top
T2405  -  [NB_TPC26T_68]  186.56 61.46 270 top
T2406  -  [NB_TPC26T_68]  194.78 58.7 180 bottom
T2407  -  [NB_TPC26T_68]  176.33 63.04 0 top
T2408  -  [NB_TPC26T_68]  182.8 50.43 0 top
T2409  -  [NB_TPC26T_68]  175.08 61.82 0 top
T2410  -  [NB_TPC26T_68]  194.18 60.62 180 bottom
T2411  -  [NB_TPC26T_68]  175.11 70.02 0 top
T2500  -  [NB_TPC26T_68]  181.2 70.28 180 bottom
T2501  -  [NB_TPC26T_68]  181.03 66.13 180 bottom
T2502  -  [NB_TPC26T_68]  156.48 75.56 180 bottom
T2503  -  [NB_TPC26T_68]  158.35 75.51 180 bottom
T3300  -  [NB_TPC28T_68]  218.69 92.09 0 top
T3301  -  [NB_TPC28T_68]  229.59 89.78 0 top
T3302  -  [NB_TPC28T_68]  229.65 88.04 0 top
T3303  -  [NB_TPC28T_68]  217.88 90.52 0 top
T3602  -  [NB_TPC28T_68]  20.67 73.99 180 bottom
T4401  -  [NB_TPC26T_68]  156.9 57.29 0 top
T4504  -  [NB_TPC28T_68]  61 181.91 180 bottom
T4505  -  [NB_TPC28T_68]  60.21 183.57 180 bottom
T4506  -  [NB_TPC28T_68]  51.54 183.32 180 bottom
T4507  -  [NB_TPC28T_68]  44.81 178.33 0 top
T4508  -  [NB_TPC28T_68]  57.46 185.13 180 bottom
T4509  -  [NB_TPC28T_68]  49.94 176.88 180 bottom
T5102  -  [NB_TPC26T_68]  37.24 27.2 0 top
T5103  -  [NB_TPC28T_68]  49.33 30.78 0 top
T5201  -  [NB_TPC26T_68]  241.45 58.5 0 top
T5301  -  [NB_TPC26T_68]  233.02 81.71 180 bottom
T5302  -  [NB_TPC26T_68]  251.26 81.04 180 bottom
T6001  -  [NB_TPC26T_68]  259.74 14.17 0 top
T6002  -  [NB_TPC26T_68]  257.58 17.37 180 bottom
T7000  -  [NB_TPC26T_68]  88.29 136.47 0 top
T7001  -  [NB_TPC26T_68]  159.17 80.08 180 bottom
T7002  -  [NB_TPC26T_68]  155.52 82.72 0 top
T7404  -  [NB_TPC28T_68]  101.8 119.7 180 bottom
T7405  -  [NB_TPC28T_68]  99.31 128.64 0 top
T7406  -  [NB_TPC28T_68]  90.02 136.29 0 top
T7407  -  [NB_TPC28T_68]  93.65 135.9 0 top
T7408  -  [NB_TPC28T_68]  86.56 132.61 0 top
T7409  -  [NB_TPC28T_68]  91.87 135.9 0 top
T7410  -  [NB_TPC28T_68]  86.89 134.41 0 top
T7500  -  [NB_TPC28T_68]  108.28 130.04 0 top
T7501  -  [NB_TPC28T_68]  116.66 150.75 0 top
T7502  -  [NB_TPC28T_68]  108.08 133.44 0 top
T8050  -  [NB_TPC28T_68]  47.35 168.62 180 bottom
T8051  -  [NB_TPC28T_68]  35.07 169.8 180 bottom
T8052  -  [NB_TPC28T_68]  67.69 163.89 0 top
T8053  -  [NB_TPC28T_68]  85.01 167.48 0 top
T8054  -  [NB_TPC28T_68]  4.37 160.92 0 top
T8055  -  [NB_TPC28T_68]  21.9 166.64 180 bottom
T8100  -  [NB_TPC26T_68]  220.65 70.25 0 top
T8101  -  [NB_TPC26T_68]  205.74 64.91 0 top
T8102  -  [NB_TPC26T_68]  221.15 72.2 0 top
T8103  -  [NB_TPC26T_68]  215.06 71.9 180 bottom
T8104  -  [NB_TPC26T_68]  222.88 75.09 180 bottom
T8105  -  [NB_TPC26T_68]  216.26 74.97 180 bottom
T8106  -  [NB_TPC26T_68]  219.76 71.64 180 bottom
T8107  -  [NB_TPC26T_68]  218.11 80.54 0 top
T8108  -  [NB_TPC26T_68]  230.3 70.75 0 top
T8109  -  [NB_TPC26T_68]  231.11 74.18 0 top
T8110  -  [NB_TPC26T_68]  202.16 61.67 180 bottom
T8111  -  [NB_TPC26T_68]  219.89 67.84 0 top
T8112  -  [NB_TPC26T_68]  206.45 75.63 0 top
T8113  -  [NB_TPC26T_68]  206.58 70.95 0 top
T8114  -  [NB_TPC26T_68]  224.33 69.99 0 top
T8115  -  [NB_TPC26T_68]  189.56 71.27 180 bottom
T8116  -  [NB_TPC26T_68]  191.73 71.08 180 bottom
T8117  -  [NB_TPC26T_68]  241.16 74.95 0 top
T8118  -  [NB_TPC26T_68]  238.02 75.01 0 top
T8119  -  [NB_TPC26T_68]  246.3 67.2 0 top
T8120  -  [NB_TPC26T_68]  246.33 63.72 0 top
T8121  -  [NB_TPC26T_68]  216.59 83.45 0 top
T8122  -  [NB_TPC26T_68]  219.63 68.72 180 bottom
T8123  -  [NB_TPC26T_68]  222.22 68.65 180 bottom
T8124  -  [NB_TPC26T_68]  199.3 70.84 0 top
T8125  -  [NB_TPC26T_68]  199.27 73.6 0 top
T8126  -  [NB_TPC26T_68]  251.02 63.79 0 top
T8127  -  [NB_TPC26T_68]  253.16 66.94 0 top
T8200  -  [NB_TPC28T_68]  142.6 73.26 180 bottom
T8201  -  [NB_TPC28T_68]  152.89 70.62 180 bottom
T8202  -  [NB_TPC28T_68]  160.58 50.72 0 top
T8203  -  [NB_TPC28T_68]  115.29 83.43 0 top
T8204  -  [NB_TPC28T_68]  151.94 56.71 0 top
T8205  -  [NB_TPC28T_68]  134.39 78.02 90 bottom
T8300  -  [NB_TPC28T_68]  138.46 61.79 180 bottom
T8301  -  [NB_TPC28T_68]  117.58 67.08 180 bottom
T8302  -  [NB_TPC28T_68]  109.08 68.7 0 top
T8303  -  [NB_TPC28T_68]  111.3 72.01 0 top
T8304  -  [NB_TPC28T_68]  111.23 68.75 0 top
T8305  -  [NB_TPC28T_68]  81.05 162.3 0 top
T8306  -  [NB_TPC28T_68]  115.55 77.7 0 top
T8307  -  [NB_TPC28T_68]  147.57 104.66 0 top
T8308  -  [NB_TPC28T_68]  130.23 54.83 0 top
T8309  -  [NB_TPC28T_68]  130.32 56.65 0 top
T8310  -  [NB_TPC28T_68]  130.43 58.55 0 top
T8311  -  [NB_TPC28T_68]  150.57 137.85 0 top
T8312  -  [NB_TPC28T_68]  124.86 65.52 0 top
T8313  -  [NB_TPC28T_68]  124.56 59.63 0 top
T8700  -  [NB_TPC28T_68]  154.84 83.13 180 bottom
T8702  -  [NB_TPC28T_68]  146.96 87.04 180 bottom
T8703  -  [NB_TPC28T_68]  119.27 88.85 0 top
T8704  -  [NB_TPC28T_68]  129.08 88.99 0 top
T8705  -  [NB_TPC28T_68]  111.3 97.17 180 bottom
T8706  -  [NB_TPC28T_68]  140.5 98.1 180 bottom
T8707  -  [NB_TPC28T_68]  109.11 98.7 180 bottom
T8708  -  [NB_TPC28T_68]  128.42 94.24 0 top
T8709  -  [NB_TPC28T_68]  103.82 99.83 0 top
T8710  -  [NB_TPC28T_68]  118.46 94.46 0 top
T8711  -  [NB_TPC28T_68]  158.9 111.83 270 bottom
T8712  -  [NB_TPC28T_68]  91.75 168.75 180 bottom
T8713  -  [NB_TPC28T_68]  115.04 84.85 180 bottom
T8714  -  [NB_TPC28T_68]  150.86 111.13 270 top
T8715  -  [NB_TPC28T_68]  119.58 68.83 180 top
T8800  -  [NB_TPC28T_68]  223.83 28.41 180 bottom
T8801  -  [NB_TPC28T_68]  224.21 24.22 180 bottom
T8802  -  [NB_TPC28T_68]  258.95 18.79 180 bottom
T8803  -  [NB_TPC28T_68]  261.63 18.31 0 top
T8804  -  [NB_TPC28T_68]  253.51 16.73 0 top
T8805  -  [NB_TPC28T_68]  253.08 14.85 0 top
T8806  -  [NB_TPC28T_68]  223.06 21.43 0 top
T8807  -  [NB_TPC28T_68]  226.24 21.3 0 top
T8808  -  [NB_TPC28T_68]  18.59 106.9 0 top
T8809  -  [NB_TPC28T_68]  20.67 110.05 0 top
T8810  -  [NB_TPC28T_68]  223.32 11.78 270 top
T8811  -  [NB_TPC28T_68]  223.06 13.81 270 top
T8812  -  [NB_TPC26T_68]  219.74 53.57 270 bottom
T8900  -  [NB_TPC28T_68]  175.95 82.9 180 bottom
T8901  -  [NB_TPC28T_68]  157.28 90.26 0 top
T8902  -  [NB_TPC28T_68]  160.19 94.15 0 top
T8904  -  [NB_TPC28T_68]  170.68 77.92 180 bottom
T8905  -  [NB_TPC28T_68]  136.58 89.12 0 top
T8906  -  [NB_TPC28T_68]  172.4 91.64 0 top
T8907  -  [NB_TPC28T_68]  178.94 88.74 180 bottom
T9100  -  [NB_TPC26T_68]  140.28 61.85 180 bottom
T9101  -  [NB_TPC28T_68]  187.3 83.28 0 top
T9102  -  [NB_TPC26T_68]  146.23 59.45 180 bottom
T9103  -  [NB_TPC28T_68]  154.61 44.54 0 top
T9104  -  [NB_TPC26T_68]  193.91 62.51 0 top
T9105  -  [NB_TPC26T_68]  214.84 88.2 90 bottom
T9106  -  [NB_TPC26T_68]  216.15 81.48 180 bottom
T9107  -  [NB_TPC26T_68]  149.5 36.57 0 top
T9108  -  [NB_TPC26T_68]  142.77 58.79 0 top
T9109  -  [NB_TPC28T_68]  144.36 90.83 180 bottom
T9110  -  [NB_TPC26T_68]  145.57 32.35 0 top
T9111  -  [NB_TPC26T_68]  142.7 73.97 0 top
T9112  -  [NB_TPC26T_68]  241.2 61.64 0 top
T9113  -  [NB_TPC28T_68]  209.89 86.48 180 bottom
T9114  -  [NB_TPC28T_68]  195.12 82.01 0 top
T9200  -  [NB_TPC28T_68]  126.92 46.75 0 top
T9201  -  [NB_TPC28T_68]  130.84 46.63 0 top
T9202  -  [NB_TPC28T_68]  126.19 54.04 0 top
T9203  -  [NB_TPC28T_68]  139.67 55.57 0 top
T9204  -  [NB_TPC28T_68]  142.42 56.76 0 top
T9205  -  [NB_TPC28T_68]  135.71 53.38 0 top
T9206  -  [NB_TPC28T_68]  140.26 53.81 0 top
T9207  -  [NB_TPC28T_68]  142.55 53.86 0 top
T9208  -  [NB_TPC28T_68]  132.92 47.31 0 top
T9209  -  [NB_TPC28T_68]  128.02 54.04 0 top
T9210  -  [NB_TPC28T_68]  139.98 68.87 0 top
T9211  -  [NB_TPC28T_68]  135.59 45.79 0 top
T9300  -  [NB_TPC28T_68]  13.97 184.49 0 top
T9301  -  [NB_TPC28T_68]  219.04 91.76 180 bottom
T9302  -  [NB_TPC28T_68]  219.28 89.27 180 bottom
T9303  -  [NB_TPC28T_68]  221.79 84.8 0 top
T9400  -  [NB_TPC28T_68]  75 157.35 180 bottom
T9401  -  [NB_TPC28T_68]  71.61 147.73 180 bottom
T9402  -  [NB_TPC28T_68]  72.69 150.17 180 bottom
T9403  -  [NB_TPC28T_68]  81.91 155.42 180 bottom
T9404  -  [NB_TPC28T_68]  83.36 154.14 180 bottom
T9500  -  [NB_TPC28T_68]  118.51 60.5 0 top
T9501  -  [NB_TPC28T_68]  105.74 64.69 0 top
T9502  -  [NB_TPC28T_68]  105.54 66.61 0 top
T9503  -  [NB_TPC28T_68]  113.79 62.88 0 top
T9504  -  [NB_TPC28T_68]  116.64 77.31 180 bottom
T9505  -  [NB_TPC28T_68]  114.86 78.07 180 bottom
T9600  -  [NB_TPC26T_68]  57.76 162.3 0 top
T9601  -  [NB_TPC26T_68]  15.33 166.03 0 top
T9602  -  [NB_TPC26T_68]  92.25 171.04 0 top
T9603  -  [NB_TPC26T_68]  88.95 176.37 0 top
U300  -  [VX_MICROPHONE_6P_148X186_GO]  184 148.7 0 top
U0300  -  [BGA_1440P_1102X1654_N]  41.9 138.4 270 bottom
U400  -  [VX_MICROPHONE_6P_148X186_GO]  194.5 148.7 0 top
U0701  -  [VX_SOT353_PHILIPS]  14.91 127.01 0 bottom
U0702  -  [VX_SOT353_PHILIPS]  111.05 52.04 180 top
U0703  -  [VX_SC70_S5_TI]  114.35 53.05 0 top
U1101  -  [VX_BGA_337P_421X421]  242.45 33.75 90 top
U1103  -  [VX_SOIC_8P_50_211X311_H85]  226.24 49.37 0 top
U1201  -  [T_HH_BGA_96P_20_240X240_TI]  241.99 51.2 0 top
U1207  -  [VX_DFN3810P9E_9P_150X39]  256.97 28.03 270 bottom
U1301  -  [VX_QFN_48P_20_S276_PAD_PARA]  213.16 53.86 0 top
U1401  -  [VX_QFN_48P_20_S276_PAD_PARA]  212.27 39.89 0 top
U2000  -  [VX_BGA_837P_906X906_INT]  170.61 51.96 180 bottom
U2301  -  [VX_SC70_S6]  176.23 39.94 180 top
U2401  -  [VX_SC70_S5_TI]  176.53 22.6 0 top
U2402  -  [VX_SC70_S5_TI]  194.26 67.24 270 bottom
U2403  -  [VX_SC70_S5_TI]  191.19 67.32 270 bottom
U2404  -  [VX_SOT23_S5_SC70_RD4]  201.6 47.39 180 bottom
U3001  -  [VX_QFP_128P_16_630X630]  118.92 37.35 180 top
U3101  -  [VX_SOIC_8P_50_213X311]  197.28 36.97 180 top
U3102  -  [VX_SOIC_28P_26_386X252]  140.01 25.49 180 top
U3103  -  [VX_SOT23_S5_H57]  223.7 48.35 270 bottom
U3300  -  [VX_QFN_40P_16_S197_P_QUA_9V]  227.89 93.36 90 top
U3401  -  [VX_TRANS_24P_39_595X394_BO]  247.78 142.04 270 top
U3600  -  [VX_QFN_48P_16_S236_P_REA_4V]  19.3 69.51 90 top
U3700  -  [VX_DFN_12P_18_S118_PAD_H35]  200.46 31.84 90 bottom
U4301  -  [VX_QFN_24P_20_S157_P_9VH31]  97.7 179.28 270 bottom
U4302  -  [VX_DFN_9P_34_39X98_AMA]  91.75 183.35 90 bottom
U4501  -  [VX_SOT23_S6_FITI_H57]  53.01 179.34 0 bottom
U4502  -  [VX_SOT23_S6_FITI_H57]  57.33 175.73 180 bottom
U4601  -  [VX_QFN_48P_20_S276_PAD_PARA]  245.67 106.52 0 top
U5000  -  [VX_SOIC_8P_26_122X193_H48]  173.41 75.91 270 top
U5001  -  [VX_SOIC_8P_50_197X236_COLAY]  28.93 115.97 270 top
U5002  -  [VX_SOIC_8P_50_197X236_COLAY]  189.03 77.48 270 top
U5003  -  [VX_SOT23_S5]  230.2 101.69 270 bottom
U5102  -  [VX_SOT353_PHILIPS]  25.96 32.91 0 top
U5103  -  [VX_SOIC_8P_50_197X236_COLAY]  166.8 22.19 270 top
U5200  -  [VX_QFN_16P_20_S118_PAD_RIC]  250.75 56.78 180 top
U5500  -  [VX_DFN_9P_34_39X98_AMA]  257.23 46.32 0 top
U5501  -  [VX_SOT23_S5_H57]  247.83 61.36 0 top
U5502  -  [VX_DFN_9P_34_39X98_AMA]  255.19 70.75 0 top
U5800  -  [VX_LGA_12P_20_79X79_BOSCH]  250.5 126.9 0 top
U6200  -  [VX_SOIC_28P_26_386X252]  183.79 24.96 180 top
U6901  -  [ANT_CLIP_1P_102X107]  250 131.69 270 bottom
U6902  -  [ANT_CLIP_1P_102X107]  243.99 131.69 270 bottom
U7000  -  [VX_BGA_1745P_1575X1575_N]  109.5 141.1 90 bottom
U7002  -  [VX_SOT23_S5_SC70_RD4]  96.32 113.04 0 top
U7401  -  [VX_SOIC_8P_50_197X236]  81.46 124.47 90 top
U7600  -  [VX_BGA_170P_31_551X472]  124.13 176.67 270 bottom
U7601  -  [VX_BGA_170P_31_551X472]  110.41 176.67 90 bottom
U7700  -  [VX_BGA_170P_31_551X472]  147.24 161.94 180 bottom
U7701  -  [VX_BGA_170P_31_551X472]  148.77 175.4 0 bottom
U7800  -  [VX_BGA_170P_31_551X472]  147.24 122.57 180 bottom
U7801  -  [VX_BGA_170P_31_551X472]  147.24 148.35 0 bottom
U7900  -  [VX_BGA_170P_31_551X472]  119.18 106.52 90 bottom
U7901  -  [VX_BGA_170P_31_551X472]  132.89 106.57 270 bottom
U8000  -  [VX_QFN_48P_16_S236_P_INT_5V]  10.47 177.18 270 bottom
U8001  -  [VX_MLP_28P_20_S197_SP_H31]  42.98 172.23 180 top
U8002  -  [VX_MLP_28P_20_S197_SP_H31]  32.06 172.35 180 top
U8003  -  [VX_MLP_28P_20_S197_SP_H31]  65.96 168.01 180 top
U8004  -  [VX_MLP_28P_20_S197_SP_H31]  21.13 169.05 180 top
U8005  -  [VX_DFN_8P_20_S79_P_I_H39_1V]  70.16 169.94 0 bottom
U8006  -  [VX_MLP_28P_20_S197_SP_H31]  8.69 163.97 180 top
U8100  -  [VX_QFN_20P_16_S118_P_H31_2V]  218.62 74.56 180 top
U8200  -  [VX_QFN_16P_20_118X118_MPS]  138.48 72.4 90 bottom
U8300  -  [VX_QFN_20P_16_S118_P_H31_4V]  134.54 61.99 0 top
U8400  -  [VX_DFN_8P_20_79X79_PAD_GMT]  172.26 25.92 270 top
U8700  -  [VX_QFN_24P_20_S157_P_RIC_4V]  151.69 81.29 0 bottom
U8701  -  [VX_DFN_8P_20_79X79_PAD_GMT]  145.97 95.47 270 top
U8702  -  [VX_QFN_16P_26_S157_PAD_SIGE]  120.96 71.9 180 top
U8800  -  [VX_QFN_20P_20_S138_PAD_4V]  221.67 27.6 180 top
U8801  -  [VX_SC70_S5]  220.65 36.42 270 bottom
U8900  -  [VX_QFN_20P_16_S118_P_H31_2V]  178.99 85.36 0 top
U9100  -  [VX_DFN_10P_16_118X79_PAD]  143.69 62.18 0 bottom
U9101  -  [VX_SON_14P_16_118X79_PAD]  195.76 67.58 180 top
U9102  -  [VX_DFN_10P_16_118X79_PAD]  217.22 85.23 270 bottom
U9103  -  [VX_SON_14P_16_118X79_PAD]  236.4 61.48 270 top
U9200  -  [VX_SC70_S5_TI]  133.53 49.67 180 top
U9201  -  [VX_SC70_S5_TI]  145.21 49.8 180 top
U9400  -  [VX_QFN_16P_20_118X118_MPS]  77.9 157.62 270 bottom
U9500  -  [VX_QFN_16P_118X188_MPS]  120.57 61.1 270 bottom
U9600  -  [VX_QFN_16P_118X188_MPS]  82.86 172.31 270 top
X1101  -  [VX_XTAL_4P_126X98_HOSON_H28]  249.99 23.33 180 top
X7200  -  [VX_XTAL_4P_126X98_HELE]  96.44 115.46 90 bottom
XDP4400  -  [BTOB_60P_20_F_SAM]  3.48 134.1 270 bottom
Y2500  -  [VX_XTAL_4P_272X55]  191.82 62.88 0 bottom
Y2501  -  [VX_XTAL_4P_126X98_RAK]  152.61 67.29 180 bottom
Y3300  -  [VX_XTAL_4P_126X98_TXC_H35]  237.8 96.23 90 top

## Library data of the parts
C300 C1612 C1614 C1713 C80135 = DEV_100
C301 C401 C0503 C0504 C0505 C0701 C0702 C0703 C1129 C1212 C1219 C1302 C1305-C1310 C1313-C1316 C1401-C1410 C1413 C1602 C1603 C1605 C1608 C1610 C1613 C1615 C1702 C1703 C1705 C1707 C1710 C2000-C2007 C2009 C2011-C2021 C2200 C2400-C2405 C2602-C2604 C2610 C2616 C2623 C2624 C2629 C2630 C3001-C3004 C3009 C3015 C3020 C3021 C3100 C3105 C3300 C3303 C3306 C3308 C3313-C3315 C3317 C3319-C3322 C3606 C3608 C3617 C3624 C3630 C4303-C4305 C4309-C4312 C4400-C4404 C4519-C4522 C4526 C4529-C4531 C4533-C4536 C4538 C4539 C4543 C4544 C4612 C4618-C4635 C4638 C4800-C4808 C5000 C5001 C5003 C5007 C5106 C5117 C5118 C5125-C5128 C5133-C5136 C5171-C5174 C5200 C5201 C5301 C5307 C5501 C5503 C5600 C5801 C5802 C6001 C6200 C6202-C6205 C6700 C6707 C7026 C7045 C7100 C7101 C7103-C7107 C7208 C7210 C7212-C7214 C7221 C7222 C7225-C7229 C7302-C7304 C7306-C7308 C7400 C7401 C7500-C7507 C7590 C7591 C7594 C7606-C7615 C7622-C7631 C7706-C7715 C7722-C7731 C7806-C7815 C7822-C7831 C7906-C7915 C7922-C7931 LC800-LC803 PC700 PC701 = DEV_165
C302 C402 C1600 C1601 C1606 C1609 C1616-C1620 C1700 C1701 C1706 C1709 C1717-C1719 C1846-C1848 C2202-C2204 C2300-C2303 C2310 C3022-C3025 C3402-C3404 C3627 C3628 C3642 C3711 C5119 C5167 C5168 C5202 C5303 = DEV_113
C0500 C0501 C0502 = DEV_80
C0600 C0601 C0602 C0603 C0604 C0605 C0606 C0607 C0608 C0609 C0610 C0611 C0612 C0613 C0614 C0615 C0616 C0617 C0618 C0619 C0620 C0621 C0622 C0623 C0624 C0625 C0626 C0627 C0628 C0629 C0630 C0631 C1229 C5120 C5131 C5132 C5137-C5139 C5150 C5151 C5154 C5155 C5158 C5159 C7004 C7005 C7009 C7010 C7014 C7015 C7020-C7025 C7029-C7044 C7049-C7052 = DEV_164
C0900 C0901 C0902 C0903 C0904 C0905 C0906 C0907 C0908 C0909 C0910 C0911 C0912 C0913 C0914 C0915 C0916 C0917 C0918 C0919 C0920 C0921 C0922 C0923 C0924 C0925 C0926 C0927 C0928 C0929 C0930 C0931 C0932 C0933 C0934 C0935 C0936 C0937 C0938 C0939 C0940 C0941 C0942 C0943 C0944 C0945 C0946 C0947 C0948 C0949 C0950 C0951 C0952 C0953 C0954 C0955 C0956 C0957 C0958 C0959 C0960 C0961 C0962 C0963 C0964 C0965 C0966 C0967 C0968 C0969 C0970 C0971 C0972 C0973 C0974 C0975 C0976 C0977 C0978 C0979 C0980 C0981 C0982 C0983 C0984 C0985 C0986 C0987 C0988 C0989 C0990 C0991 C0992 C0993 C0994 C0995 C0996 C0997 C0998 C0999 C1165-C1188 C7220 C7224 C09100 C09101 C09102 C09103 C09104 C09105 C09106 C09107 C09108 C09109 C09110 C09111 C09112 C09113 C09114 C09115 C09116 C09117 C09118 C09119 C09120 C09121 C09122 C09123 C09124 C09125 C09126 C09127 C09128 C09129 C09130 = DEV_166
C1000 C1209-C1211 C2600 C2601 C2605 C2606 C2608 C2611-C2613 C2618 C2619 C5160-C5162 C5505 C5506 C7003 C7008 C7013 C7019 C7102 = DEV_101
C1001 C1002 C1004 C1005 C1148-C1154 C1204 C1205 C1218 C1712 C1822-C1829 C1832-C1842 C2607 C2609 C2615 C2617 C2620-C2622 C2625 C2826-C2828 C3101 C3301 C3304 C3307 C3316 C3318 C3323 C3603 C3604 C3610 C3614 C3700 C3704 C3710 C5002 C5005 C5006 C5302 C5507 C7000 C7011 C7016 C7017 C7046 C7048 C7301 C7524-C7537 C7592 C7595 C7603 C7616-C7619 C7632-C7635 C7703 C7716-C7719 C7732-C7735 C7803 C7816-C7819 C7832-C7835 C7903 C7916-C7919 C7932-C7935 C75003-C75005 C75007 C75008 C75010-C75013 C75016-C75019 C75021-C75027 = DEV_88
C1003 C1006 C8068-C8070 C80025 C80066 C80082 = DEV_199: room: COR
C1007-C1016 C1155-C1158 C1163 C1164 C1203 C1206 C3104 C3302 C3309-C3312 C3601 C3602 C3605 C3607 C3609 C3611-C3613 C3615 C3633 C3701 C4532 C4540-C4542 C5107 C5116 C5175 C5300 C5502 C6201 C7519-C7522 C7568-C7573 C7620 C7621 C7636 C7637 C7720 C7721 C7736 C7737 C7820 C7821 C7836 C7837 C7920 C7921 C7936 C7937 = DEV_108
C1101-C1108 C1132-C1135 = DEV_331
C1119-C1126 C1136-C1147 C1189 C1190 = DEV_330
C1130 C1131 = DEV_324
C1159-C1161 C1191 C1192 C7508-C7518 C7523 = DEV_325
C1193-C1196 = DEV_345
C1207 C1208 C1221 C1303 C1304 C1411 C1412 C3600 C3709 C4613 C4637 = DEV_93
C1217 C3305 C3639 C3640 C4516 C7001 C7006 C7027 C7028 C7047 C7200 C7206 C7207 C7219 C7223 C7538-C7567 C7580-C7589 C7593 C7596-C7599 C75001 C75002 C75006 C75009 C75014 C75015 C75020 = DEV_86
C1220 = DEV_350
C1222 = DEV_203
C1223 C1224 C8216 = DEV_105: room: 1.0VSUS
C1225-C1228 = DEV_349
C1301 C1414 C3400 C4636 C5144 C5306 = DEV_162
C1604 C1607 C1704 C1708 C1800-C1821 C1843-C1845 = DEV_223
C1714 = DEV_316
C2201 = DEV_109
C2304-C2309 C3011 C3618-C3622 C3705-C3708 C6704 C6705 = DEV_83
C2500 C2501 C7215 C7216 = DEV_163
C2502 C2503 = DEV_378
C2614 C7209 C7211 C7574-C7579 = DEV_91
C3000 C3019 C3616 C3623 C3631 C5145 C5169 C6206 C7002 C7007 C7012 C7018 = DEV_160
C3102 C3103 = DEV_94
C3324 C3325 = DEV_323
C3401 = DEV_161
C3626 C3629 = DEV_110
C3645-C3647 C5147 = DEV_102
C3702 C3703 C8817 = DEV_81: room: CHG
C4308 = DEV_89
C4515 = DEV_107
C4517 C4518 C80108 = DEV_195: room: COR
C4809 C4810 = DEV_85
C5004 = DEV_159
C5100-C5103 C5121-C5124 C5140-C5143 C9100 C9104 C9134 = DEV_79: room: LOAD_SW
C5803 = DEV_108: room: ACC
C6002 C6003 C8305 C8310 = DEV_97: room: DDR
C7600 C7604 C7605 C7700 C7704 C7705 C7800 C7804 C7805 C7900 C7904 C7905 = DEV_157
C8000 C8002-C8004 C8006 C8013 C8014 C8022 C8035 = DEV_87: room: COR
C8001 C8023 C8025 C8054 C8055 C8060 C8086 C80042 C80052 = DEV_106: room: COR
C8005 C80122 C80124 C80126 = DEV_113: room: COR
C8007 = DEV_198: room: COR
C8008 C8033 = DEV_197: room: COR
C8009 = DEV_78: room: COR
C8010 = DEV_196: room: COR
C8011 C8017 C8019 C8029 C8030 = DEV_194: room: COR
C8012 = DEV_215: room: COR
C8015 = DEV_163: room: COR
C8016 C8031 = DEV_193: room: COR
C8018 C8034 C80106 = DEV_159: room: COR
C8020 C8028 C80104 C80105 C80109-C80111 C80133 C80134 = DEV_97: room: COR
C8021 C8053 C8059 C8064 C8090 C80027 C80074 = DEV_102: room: COR
C8024 = DEV_214: room: COR
C8026 = DEV_225: room: COR
C8027 = DEV_248: room: COR
C8032 = DEV_192: room: COR
C8036 = DEV_247: room: COR
C8050-C8052 C8056-C8058 C8061-C8063 C8087-C8089 C80005 C80006 C80070 C80076 C80079 C80091 = DEV_103: room: COR
C8065-C8067 C80019 C80064 = DEV_200: room: COR
C8071-C8073 C80041 C80046 C80056 = DEV_104: room: COR
C8074-C8085 C8091-C8099 C80002 C80004 C80008-C80010 C80012 C80013 C80017 C80020 C80022-C80024 C80026 C80029 C80031 C80032 C80036 C80038-C80040 C80044 C80049 C80050 C80055 C80057 C80059 C80062 C80068 C80069 C80073 C80075 C80077 C80078 C80083 C80087 C80092 C80095 C80098 C80102 C80112-C80119 C80121 C80128-C80132 = DEV_101: room: COR
C8100 C8109 C8110 C8115-C8117 = DEV_99: room: SYS
C8101 = DEV_98: room: SYS
C8102 C8104 C8105 = DEV_103: room: SYS
C8103 C8106 C8118 = DEV_97: room: SYS
C8107 C8108 C8119-C8123 = DEV_96: room: SYS
C8111 C8112 = DEV_95: room: SYS
C8113 C8114 = DEV_94: room: SYS
C8124 C8126 C8128 C8130 = DEV_113: room: SYS
C8125 C8127 C8129 C8131 = DEV_176: room: SYS
C8202 C8208 = DEV_95: room: 1.0VSUS
C8203 = DEV_103: room: 1.0VSUS
C8205 = DEV_96: room: 1.0VSUS
C8206 = DEV_200: room: 1.0VSUS
C8207 = DEV_75: room: 1.0VSUS
C8209-C8213 = DEV_101: room: 1.0VSUS
C8214 = DEV_113: room: 1.0VSUS
C8215 = DEV_176: room: 1.0VSUS
C8300 C8301 C8308 = DEV_108: room: DDR
C8302 C8318 = DEV_99: room: DDR
C8303 = DEV_90: room: DDR
C8304 C8314 = DEV_95: room: DDR
C8306 C8307 = DEV_103: room: DDR
C8309 = DEV_96: room: DDR
C8311-C8313 C8315-C8317 = DEV_101: room: DDR
C8319 = DEV_79: room: DDR
C8320 C8321 = DEV_89: room: DDR
C8322 = DEV_95
C8323 C8325 C8327 = DEV_113: room: DDR
C8324 C8326 C8328 = DEV_176: room: DDR
C8400 = DEV_102: room: 1.5VS
C8401 C8404 = DEV_108: room: 1.5VS
C8402 = DEV_99: room: 1.5VS
C8403 = DEV_88: room: 1.5VS
C8405 C8406 = DEV_176: room: 1.5VS
C8700 C8701 C8708 C8709 C8728 C8735 C8737 C8742 = DEV_95: room: VGP
C8702 C8704 C8730 C8731 C8739 C8740 = DEV_103: room: VGP
C8703 C8707 C8729 C8738 = DEV_96: room: VGP
C8706 C8733 = DEV_225: room: VGP
C8710-C8722 = DEV_101: room: VGP
C8723 C8736 C8915 = DEV_106: room: VGP
C8724 = DEV_109: room: VGP
C8725 = DEV_99: room: VGP
C8726 = DEV_87: room: VGP
C8727 C8910 = DEV_93: room: VGP
C8741 = DEV_100: room: VGP
C8743 = DEV_113: room: VGP
C8744 = DEV_176: room: VGP
C8745 C8746 C8748 = DEV_108: room: VGP
C8747 = DEV_165: room: VGP
C8800 = DEV_85: room: CHG
C8801 C8824 = DEV_89: room: CHG
C8802 C8804 C8810 = DEV_95: room: CHG
C8803 C8811 C8812 C8818-C8820 = DEV_103: room: CHG
C8806 = DEV_84: room: CHG
C8807-C8809 C8813 C8822 C8823 C8825 C8826 C8829 C8830 C8832 = DEV_97: room: CHG
C8814 = DEV_99: room: CHG
C8815 C8831 = DEV_83: room: CHG
C8816 = DEV_82: room: CHG
C8821 = DEV_98: room: CHG
C8827 = DEV_80: room: CHG
C8828 = DEV_160: room: CHG
C8900 = DEV_97: room: +FBVDDQ
C8901 C8902 = DEV_103: room: +FBVDDQ
C8903 = DEV_106: room: +FBVDDQ
C8904 = DEV_79: room: +FBVDDQ
C8905 C8908 = DEV_99: room: +FBVDDQ
C8906 = DEV_95: room: +FBVDDQ
C8907 = DEV_83: room: +FBVDDQ
C8909 = DEV_92: room: +FBVDDQ
C8912 = DEV_78: room: +FBVDDQ
C8916 = DEV_113: room: +FBVDDQ
C8917 = DEV_176: room: +FVDDQ
C9101 C9107 = DEV_199: room: LOAD_SW
C9102 C9105 C9110 C9112-C9114 C9119 C9125 C9126 C9130 C9131 C9133 = DEV_99: room: LOAD_SW
C9103 = DEV_81: room: LOAD_SW
C9108 C9109 C9116 C9117 C9123 C9124 C9127 C9129 = DEV_102: room: LOAD_SW
C9111 C9128 = DEV_77: room: LOAD_SW
C9115 C9121 C9122 C9132 = DEV_76: room: LOAD_SW
C9118 C9120 = DEV_90: room: LOAD_SW
C9200 = DEV_107: room: CTL
C9400 C9412 = DEV_95: room: VCCIO
C9401 C9402 = DEV_103: room: VCCIO
C9403 = DEV_200: room: VCCIO
C9405 = DEV_75: room: VCCIO
C9406-C9410 = DEV_101: room: VCCIO
C9411 = DEV_79: room: VCCIO
C9414 = DEV_88: room: VCCIO
C9415 = DEV_176: room: VCCIO
C9416 = DEV_105: room: VCCIO
C9500 C9512 = DEV_95: room: 2.5V
C9501 C9502 = DEV_103: room: 2.5V
C9503 C9504 C9511 = DEV_99: room: 2.5V
C9505 = DEV_75: room: 2.5V
C9506-C9510 = DEV_101: room: 2.5V
C9513 = DEV_105: room: 2.5V
C9514 = DEV_113: room: 2.5V
C9515 = DEV_176: room: 2.5V
C9600 C9602 C9613 C9614 = DEV_101: room: 1.05VO_VGA
C9601 = DEV_105: room: 1.05VO_VGA
C9603 C9608 C9612 = DEV_99: room: 1.05VO_VGA
C9604 C9605 = DEV_103: room: 1.05VO_VGA
C9606 = DEV_113: room: 1.05VO_VGA
C9607 = DEV_176: room: 1.05VO_VGA
C9609 = DEV_75: room: 1.05VO_VGA
C9610 = DEV_97: room: 1.05VO_VGA
C9611 = DEV_95: room: 1.05VO_VGA
C80103 = DEV_79: room: COR
C80107 = DEV_75: room: COR
C80123 C80125 C80127 = DEV_176: room: COR
CE1225 CE5502 CE5503 CE6703 = DEV_158
CE1800 = DEV_156
CE7502 CE8900 CE8901 = DEV_74: room: +FBVDDQ
CE8000 CE8001 CE8004 CE8007 = DEV_74: room: COR
CE8100-CE8103 = DEV_73: room: SYS
CE8300 = DEV_355: room: DDR
CE8700-CE8705 = DEV_74: room: VGP
CN1-CN7 = DEV_167
CON1 PCON700 = DEV_329
CON300 CON400 = DEV_300
CON302 = DEV_328
CON402 CON5602 = DEV_284
CON1201 = DEV_218
CON1600 = DEV_364
CON1601 = DEV_363
CON1700 = DEV_362
CON1701 = DEV_361
CON2800 = DEV_286
CON3100 = DEV_367
CON3104 = DEV_319
CON3110 = DEV_318
CON3400 = DEV_299
CON3600 = DEV_371
CON3700 = DEV_373
CON4301 CON5100 = DEV_344
CON4400 CON4402 = DEV_366
CON4500 = DEV_385
CON4601 = DEV_360
CON4800 = DEV_343
CON5000 CON5001 = DEV_370
CON5101 = DEV_342
CON5102 = DEV_341
CON5103 = DEV_359
CON5300 = DEV_285
CON5500 CON5501 = DEV_358
CON6000 = DEV_340
CON6001 = DEV_339
CON6002 = DEV_229
CON6003 = DEV_380
CON6700 = DEV_338
CON6701 = DEV_283
D300-D302 D400-D402 PD700-PD702 = DEV_234
D1201-D1208 = DEV_379
D1209 D3400 D3600 = DEV_278
D2301 D3601 D4503 D4504 = DEV_68
D2801 D3104 D5000 D5002 D7402 = DEV_69
D3101 D3102 D6002 D6003 = DEV_111
D4502 D5601 = DEV_112
D4800 D5001 D5003 = DEV_337
D5004 D7001 = DEV_271
D5101 = DEV_390
D5501-D5506 = DEV_270
D6005 D6006 = DEV_72: room: CRT
D8102 D8103 = DEV_70: room: SYS
D8200 = DEV_71: room: 1.0VSUS
D8300 D8301 = DEV_71: room: DDR
D8700 = DEV_71: room: VGP
D8800 D8801 = DEV_69: room: CHG
D8802 = DEV_71: room: CHG
D8900 = DEV_71: room: +FBVDDQ
D9200 D9202 = DEV_68: room: CTL
D9201 = DEV_71: room: CTL
D9400 = DEV_71: room: VCCIO
D9500 = DEV_71: room: 2.5V
D9600 = DEV_71: room: 1.05VO_VGA
F4601 F4800 = DEV_314
H11 = DEV_313
H21 = DEV_312
H31 H33 H34 H36 H701 H702 H804 H805 = DEV_222
H32 H35 = DEV_317
H51-H56 = DEV_221
H60 H61 H63-H66 = DEV_281
H62 = DEV_280
H68 = DEV_391
H69 = DEV_279
H301 H402 = DEV_233
H302 H401 = DEV_369
H703 H800 H6902 = DEV_226
H704 H803 = DEV_232
H6901 H6903 = DEV_227
