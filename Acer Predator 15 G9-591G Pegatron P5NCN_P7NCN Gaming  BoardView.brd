# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
VX_DDR4_260P_20_4H_REV_ARGO
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  custom 0.502x0.502 smd: 263(-37.75,12)
  rect 2.007x3.505 smd: 264(37.75,8)
VX_DDR4_260P_20_4HD_ARG
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
VX_DDR4_260P_20_4HD_REV_ARG
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
VX_DFN3810P9E_9P_150X39
  rect 0.203x0.66 smd: 1(-1.7,-0.475) 2(-0.8,-0.475) 3(0,-0.475) 4(0.8,-0.475) 5(1.7,-0.475) 6(1.3,0.475) 7(0.4,0.475) 8(-0.4,0.475) 9(-1.3,0.475)
VX_DFN_8P_20_79X79_PAD_GMT
  rect 0.279x0.559 smd: 1(-0.75,-0.875) 2(-0.25,-0.875) 3(0.25,-0.875) 4(0.75,-0.875) 5(0.75,0.875) 6(0.25,0.875) 7(-0.25,0.875) 8(-0.75,0.875)
  rect 1.245x0.66 smd: 9(0,0)
VX_DFN_8P_20_S79_P_I_H39_1V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.6x0.864 smd: 9(0,0)
  round 0.61 hole 0.305: 10(0,0)
VX_DFN_9P_34_39X98_AMA
  rect 0.673x0.203 smd: 1(-0.438,1) 5(-0.438,-1) 6(0.438,-1) 10(0.438,1)
  rect 0.673x0.191 smd: 2(-0.438,0.5) 4(-0.438,-0.5) 7(0.438,-0.5) 9(0.438,0.5)
  rect 1.549x0.394 smd: 3(0,0)
VX_DFN_10P_16_118X79_PAD
  custom 0.15x0.15 smd: 1(-1.2,-1) 7(0.8,-1) 8(0.8,1) 14(-1.2,1)
  rect 0.203x0.711 smd: 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 10(0.4,1) 11(0,1) 12(-0.4,1)
  rect 2.54x0.838 smd: 15(0,0)
VX_DFN_12P_18_S118_PAD_H35
  rect 0.246x0.61 smd: 1(-1.125,-1.35) 2(-0.675,-1.35) 3(-0.225,-1.35) 4(0.225,-1.35) 5(0.675,-1.35) 6(1.125,-1.35) 7(1.125,1.35) 8(0.675,1.35) 9(0.225,1.35) 10(-0.225,1.35) 11(-0.675,1.35) 12(-1.125,1.35)
  rect 2.743x1.651 smd: 13(0,0)
VX_DISPLAY_20P_39_4H_ACON
  rect 0.787x0.787 hole 0.533: 1(5.5,8.48)
  round 0.787 hole 0.533: 2(5,6.98) 3(4.5,8.48) 4(4,6.98) 5(3.5,8.48) 6(3,6.98) 7(2.5,8.48) 8(2,6.98) 9(1.5,8.48) 10(1,6.98) 11(0.5,8.48) 12(0,6.98) 13(-0.5,8.48) 14(-1,6.98) 15(-1.5,8.48) 16(-2,6.98) 17(-2.5,8.48) 18(-3,6.98) 19(-3.5,8.48) 20(-4,6.98)
  oval 1.016x2.007 hole 0.61: 21(8.2,7.58) 22(-8.2,7.58) 23(10.35,0) 24(-10.35,0)
VX_ESD_2P_33_39X24_H24
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
VX_ESD_2P_34_39X24_INPAQ
  rect 0.66x0.508 smd: 1(-0.433,0) 2(0.433,0)
VX_FPC_8P_20_2H_RA_ACE_B
  rect 0.305x0.889 smd: 1(-1.75,3.05) 2(-1.25,3.05) 3(-0.75,3.05) 4(-0.25,3.05) 5(0.25,3.05) 6(0.75,3.05) 7(1.25,3.05) 8(1.75,3.05)
  rect 0.991x2.007 smd: 9(-3.85,0) 10(3.85,0)
VX_FPC_12P_20_2HD_B
  rect 0.292x0.889 smd: 1(-2.75,3.05) 2(-2.25,3.05) 3(-1.75,3.05) 4(-1.25,3.05) 5(-0.75,3.05) 6(-0.25,3.05) 7(0.25,3.05) 8(0.75,3.05) 9(1.25,3.05) 10(1.75,3.05) 11(2.25,3.05) 12(2.75,3.05)
  rect 0.991x2.007 smd: 13(-4.85,0) 14(4.85,0)
VX_FPC_14P_20_2H_ACE_B
  rect 0.305x0.889 smd: 1(-3.25,3.05) 2(-2.75,3.05) 3(-2.25,3.05) 4(-1.75,3.05) 5(-1.25,3.05) 6(-0.75,3.05) 7(-0.25,3.05) 8(0.25,3.05) 9(0.75,3.05) 10(1.25,3.05) 11(1.75,3.05) 12(2.25,3.05) 13(2.75,3.05) 14(3.25,3.05)
  rect 0.991x2.007 smd: 15(-5.35,0) 16(5.35,0)
VX_FPC_14P_20_2HD_RA_ENTERY
  rect 0.305x0.787 smd: 1(-3.25,2.5) 2(-2.75,2.5) 3(-2.25,2.5) 4(-1.75,2.5) 5(-1.25,2.5) 6(-0.75,2.5) 7(-0.25,2.5) 8(0.25,2.5) 9(0.75,2.5) 10(1.25,2.5) 11(1.75,2.5) 12(2.25,2.5) 13(2.75,2.5) 14(3.25,2.5)
  rect 0.406x0.787 smd: 15(-4.25,0) 16(4.25,0)
VX_FPC_18P_20_2HLD_ACES
  rect 0.292x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
VX_FPC_26P_39_2HOLD_RA
  rect 0.61x2.007 smd: 1(-12.5,2.3) 2(-11.5,2.3) 3(-10.5,2.3) 4(-9.5,2.3) 5(-8.5,2.3) 6(-7.5,2.3) 7(-6.5,2.3) 8(-5.5,2.3) 9(-4.5,2.3) 10(-3.5,2.3) 11(-2.5,2.3) 12(-1.5,2.3) 13(-0.5,2.3) 14(0.5,2.3) 15(1.5,2.3) 16(2.5,2.3) 17(3.5,2.3) 18(4.5,2.3) 19(5.5,2.3) 20(6.5,2.3) 21(7.5,2.3) 22(8.5,2.3) 23(9.5,2.3) 24(10.5,2.3) 25(11.5,2.3) 26(12.5,2.3)
  rect 1.803x2.591 smd: 27(-15.1,0) 28(15.1,0)
VX_FPC_45P_20_2H_RA_ENTE_B
  rect 0.305x1.295 smd: 1(-11,2.65) 2(-10.5,2.65) 3(-10,2.65) 4(-9.5,2.65) 5(-9,2.65) 6(-8.5,2.65) 7(-8,2.65) 8(-7.5,2.65) 9(-7,2.65) 10(-6.5,2.65) 11(-6,2.65) 12(-5.5,2.65) 13(-5,2.65) 14(-4.5,2.65) 15(-4,2.65) 16(-3.5,2.65) 17(-3,2.65) 18(-2.5,2.65) 19(-2,2.65) 20(-1.5,2.65) 21(-1,2.65) 22(-0.5,2.65) 23(0,2.65) 24(0.5,2.65) 25(1,2.65) 26(1.5,2.65) 27(2,2.65) 28(2.5,2.65) 29(3,2.65) 30(3.5,2.65) 31(4,2.65) 32(4.5,2.65) 33(5,2.65) 34(5.5,2.65) 35(6,2.65) 36(6.5,2.65) 37(7,2.65) 38(7.5,2.65) 39(8,2.65) 40(8.5,2.65) 41(9,2.65) 42(9.5,2.65) 43(10,2.65) 44(10.5,2.65) 45(11,2.65)
  rect 1.803x1.397 smd: 46(-12.65,0) 47(12.65,0)
VX_FPC_CON_28P_20_2H_AC_B
  rect 0.292x1.295 smd: 1(-6.75,2.8) 2(-6.25,2.8) 3(-5.75,2.8) 4(-5.25,2.8) 5(-4.75,2.8) 6(-4.25,2.8) 7(-3.75,2.8) 8(-3.25,2.8) 9(-2.75,2.8) 10(-2.25,2.8) 11(-1.75,2.8) 12(-1.25,2.8) 13(-0.75,2.8) 14(-0.25,2.8) 15(0.25,2.8) 16(0.75,2.8) 17(1.25,2.8) 18(1.75,2.8) 19(2.25,2.8) 20(2.75,2.8) 21(3.25,2.8) 22(3.75,2.8) 23(4.25,2.8) 24(4.75,2.8) 25(5.25,2.8) 26(5.75,2.8) 27(6.25,2.8) 28(6.75,2.8)
  rect 1.803x1.397 smd: 29(-8.4,0) 30(8.4,0)
VX_H_CT276CB315D118_P2
  round 3.505 hole 2.997: 1(0,0)
VX_H_ST335CB315D118_P2
  round 3.505 hole 2.997: 1(0,0)
VX_HDMI_19P_4H_SING
  rect 0.787x0.787 hole 0.483: 1(4.5,7.57)
  round 0.787 hole 0.483: 2(4,6.37) 3(3.5,7.57) 4(3,6.37) 5(2.5,7.57) 6(2,6.37) 7(1.5,7.57) 8(1,6.37) 9(0.5,7.57) 10(0,6.37) 11(-0.5,7.57) 12(-1,6.37) 13(-1.5,7.57) 14(-2,6.37) 15(-2.5,7.57) 16(-3,6.37) 17(-3.5,7.57) 18(-4,6.37) 19(-4.5,7.57)
  oval 1.168x2.235 hole 0.762: 20(9,5.2) 21(-9,5.2) 22(9,0) 23(-9,0)
VX_INDUCTOR_2P_118X118_MAG
  rect 0.991x2.997 smd: 1(-1.1,0) 2(1.1,0)
VX_INDUCTOR_2P_150X150_CYN
  rect 0.991x3.81 smd: 1(-1.4,0) 2(1.4,0)
VX_INDUCTOR_2P_157X157_COIL
  rect 0.965x3.404 smd: 1(-1.185,0) 2(1.185,0)
VX_INDUCTOR_2P_205X185
  rect 1.905x2.489 smd: 1(-1.95,0) 2(1.95,0)
VX_INDUCTOR_2P_274X260
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
VX_INDUCTOR_2P_274X260_H157
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
VX_INDUCTOR_2P_278X260_H118
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
VX_INDUCTOR_2P_291X264
  rect 2.032x3.2 smd: 1(-3.22,0) 2(3.22,0)
VX_INDUCTOR_2P_299X260_CYN
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
VX_L0603_H37_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_L0603_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_L1812_H67
  rect 1.499x2.997 smd: 1(-2.25,0) 2(2.25,0)
VX_LAN_JACK_8P_2HD_SAN_LF2
  round 1.27 hole 0.686: 1(-3.57,6.42) 2(-2.55,7.52) 3(-1.53,6.42) 4(-0.51,7.52) 5(0.51,6.42) 6(1.53,7.52) 7(2.55,6.42) 8(3.57,7.52)
  oval 1.905x3.581 hole 0.711: 9(9.525,0) 10(-9.525,0)
VX_LED_2P_39X20_EVERLIG
  rect 0.406x0.61 smd: 1(0.5,0) 2(-0.5,0)
VX_LED_2P_150X39_RA
  rect 1.092x0.635 smd: 1(1.75,0) 2(-1.75,0)
VX_LGA_12P_20_79X79_BOSCH
  rect 0.279x0.406 smd: 1(-0.75,-0.815) 2(-0.25,-0.815) 3(0.25,-0.815) 4(0.75,-0.815) 7(0.75,0.815) 8(0.25,0.815) 9(-0.25,0.815) 10(-0.75,0.815)
  rect 0.406x0.279 smd: 5(0.815,-0.25) 6(0.815,0.25) 11(-0.815,0.25) 12(-0.815,-0.25)
VX_MICROPHONE_6P_148X186_GO
  round 0.991 smd: 1(-1.17,1.65) 2(-1.17,0) 3(-1.17,-1.65) 4(1.17,-1.65) 5(1.17,0)
  custom 0.303x0.303 smd: 6(1.17,1.65)
VX_MINI_PCI_67P_20_4H_ARGOY
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 59(5.25,4.725) 60(5.5,-1.725) 61(5.75,4.725) 62(6,-1.725) 63(6.25,4.725) 64(6.5,-1.725) 65(6.75,4.725) 66(7,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.505) 77(10.35,4.505)
VX_MINI_PCI_67P_20_4H_H128
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
VX_MLP_28P_20_S197_SP_H31
  rect 0.305x0.762 smd: 1(-1.75,-2.425) 2(-1.25,-2.425) 3(-0.75,-2.425) 4(-0.25,-2.425) 5(0.25,-2.425) 6(0.75,-2.425) 7(1.25,-2.425) 8(1.75,-2.425) 16(1.75,2.425) 17(1.25,2.425) 18(0.75,2.425) 19(0.25,2.425) 20(-0.25,2.425) 21(-0.75,2.425) 22(-1.25,2.425) 23(-1.75,2.425)
  rect 0.762x0.305 smd: 24(-2.481,1.75) 25(-2.481,1.25) 26(-2.481,0.75) 27(-2.481,0.25) 28(-2.481,-0.25) 29(-2.481,-0.75) 30(-2.481,-1.25) 31(-2.481,-1.75)
  custom 0.339x0.339 smd: 32(1.06,-1.185)
  custom 0.551x0.551 smd: 33(0.15,0.74)
  rect 0.559x0.406 smd: 34(-1.526,0.1)
  rect 1.422x1.118 smd: 35(-1.09,-1.185)
VX_NGFF_67P_20_4HOLD_H165
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
VX_POLYSWITCH_2P_1206_H24
  rect 1.499x2.057 smd: 1(-1.4,0) 2(1.4,0)
VX_QFN_16P_20_118X118_MPS
  rect 0.254x2.108 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.711x0.254 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.254x0.889 smd: 10(-0.5,1.35)
VX_QFN_16P_20_S118_PAD_RIC
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
VX_QFN_16P_26_S157_PAD_SIGE
  rect 0.381x0.762 smd: 1(-0.975,-1.775) 2(-0.325,-1.775) 3(0.325,-1.775) 4(0.975,-1.775) 9(0.975,1.775) 10(0.325,1.775) 11(-0.325,1.775) 12(-0.975,1.775)
  rect 0.762x0.381 smd: 5(1.775,-0.975) 6(1.775,-0.325) 7(1.775,0.325) 8(1.775,0.975) 13(-1.775,0.975) 14(-1.775,0.325) 15(-1.775,-0.325) 16(-1.775,-0.975)
  rect 2.311x2.311 smd: 17(0,0)
VX_QFN_16P_118X188_MPS
  rect 0.203x1.092 smd: 1(-0.525,-1.25) 2(0.175,-1.25) 8(0.525,1.25) 9(-0.175,1.25)
  rect 0.711x0.222 smd: 3(1.45,-0.8) 4(1.45,-0.4) 5(1.45,0) 6(1.45,0.4) 7(1.45,0.8) 10(-1.45,0.8) 11(-1.45,0.4) 12(-1.45,0) 13(-1.45,-0.4) 14(-1.45,-0.8)
  rect 0.203x0.66 smd: 15(-0.165,0) 16(0.435,0)
VX_QFN_20P_16_S118_P_H31_2V
  rect 0.222x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.222 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(0.521,0.521) 23(-0.521,-0.521)
VX_QFN_20P_16_S118_P_H31_4V
  rect 0.197x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.197 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,0.5) 23(0.5,0.5) 24(-0.5,-0.5) 25(0.5,-0.5)
VX_QFN_20P_20_S138_PAD_4V
  rect 0.279x0.61 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 11(1,1.6) 12(0.5,1.6) 13(0,1.6) 14(-0.5,1.6) 15(-1,1.6)
  rect 0.61x0.279 smd: 6(1.6,-1) 7(1.6,-0.5) 8(1.6,0) 9(1.6,0.5) 10(1.6,1) 16(-1.6,1) 17(-1.6,0.5) 18(-1.6,0) 19(-1.6,-0.5) 20(-1.6,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.775,0.775) 23(0.775,0.775) 24(-0.775,-0.775) 25(0.775,-0.775)
VX_QFN_24P_20_S157_P_9VH31
  rect 0.279x0.61 smd: 1(-1.25,-1.85) 2(-0.75,-1.85) 3(-0.25,-1.85) 4(0.25,-1.85) 5(0.75,-1.85) 6(1.25,-1.85) 13(1.25,1.85) 14(0.75,1.85) 15(0.25,1.85) 16(-0.25,1.85) 17(-0.75,1.85) 18(-1.25,1.85)
  rect 0.61x0.279 smd: 7(1.85,-1.25) 8(1.85,-0.75) 9(1.85,-0.25) 10(1.85,0.25) 11(1.85,0.75) 12(1.85,1.25) 19(-1.85,1.25) 20(-1.85,0.75) 21(-1.85,0.25) 22(-1.85,-0.25) 23(-1.85,-0.75) 24(-1.85,-1.25)
  rect 2.667x2.667 smd: 25(0,0)
  round 0.61 hole 0.305: 26(-1.029,1.029) 27(0,1.029) 28(1.029,1.029) 29(-1.029,0) 30(0,0) 31(1.029,0) 32(-1.029,-1.029) 33(0,-1.029) 34(1.029,-1.029)
VX_QFN_24P_20_S157_P_RIC_4V
  rect 0.279x0.61 smd: 1(-1.25,-1.85) 2(-0.75,-1.85) 3(-0.25,-1.85) 4(0.25,-1.85) 5(0.75,-1.85) 6(1.25,-1.85) 13(1.25,1.85) 14(0.75,1.85) 15(0.25,1.85) 16(-0.25,1.85) 17(-0.75,1.85) 18(-1.25,1.85)
  rect 0.61x0.279 smd: 7(1.85,-1.25) 8(1.85,-0.75) 9(1.85,-0.25) 10(1.85,0.25) 11(1.85,0.75) 12(1.85,1.25) 19(-1.85,1.25) 20(-1.85,0.75) 21(-1.85,0.25) 22(-1.85,-0.25) 23(-1.85,-0.75) 24(-1.85,-1.25)
  rect 2.667x2.667 smd: 25(0,0)
  round 0.61 hole 0.305: 26(-1.029,1.029) 27(1.029,1.029) 28(-1.029,-1.029) 29(1.029,-1.029)
VX_QFN_40P_16_S197_P_QUA_9V
  rect 0.229x0.559 smd: 1(-1.8,-2.37) 2(-1.4,-2.37) 3(-1,-2.37) 4(-0.6,-2.37) 5(-0.2,-2.37) 6(0.2,-2.37) 7(0.6,-2.37) 8(1,-2.37) 9(1.4,-2.37) 10(1.8,-2.37) 21(1.8,2.37) 22(1.4,2.37) 23(1,2.37) 24(0.6,2.37) 25(0.2,2.37) 26(-0.2,2.37) 27(-0.6,2.37) 28(-1,2.37) 29(-1.4,2.37) 30(-1.8,2.37)
  rect 0.559x0.229 smd: 11(2.37,-1.8) 12(2.37,-1.4) 13(2.37,-1) 14(2.37,-0.6) 15(2.37,-0.2) 16(2.37,0.2) 17(2.37,0.6) 18(2.37,1) 19(2.37,1.4) 20(2.37,1.8) 31(-2.37,1.8) 32(-2.37,1.4) 33(-2.37,1) 34(-2.37,0.6) 35(-2.37,0.2) 36(-2.37,-0.2) 37(-2.37,-0.6) 38(-2.37,-1) 39(-2.37,-1.4) 40(-2.37,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.49,1.49) 43(0,1.49) 44(1.49,1.49) 45(-1.49,0) 46(0,0) 47(1.49,0) 48(-1.49,-1.49) 49(0,-1.49) 50(1.49,-1.49)
VX_QFN_48P_16_S236_P_INT_5V
  rect 0.222x0.66 smd: 1(-2.2,-2.875) 2(-1.8,-2.875) 3(-1.4,-2.875) 4(-1,-2.875) 5(-0.6,-2.875) 6(-0.2,-2.875) 7(0.2,-2.875) 8(0.6,-2.875) 9(1,-2.875) 10(1.4,-2.875) 11(1.8,-2.875) 12(2.2,-2.875) 25(2.2,2.875) 26(1.8,2.875) 27(1.4,2.875) 28(1,2.875) 29(0.6,2.875) 30(0.2,2.875) 31(-0.2,2.875) 32(-0.6,2.875) 33(-1,2.875) 34(-1.4,2.875) 35(-1.8,2.875) 36(-2.2,2.875)
  rect 0.66x0.222 smd: 13(2.875,-2.2) 14(2.875,-1.8) 15(2.875,-1.4) 16(2.875,-1) 17(2.875,-0.6) 18(2.875,-0.2) 19(2.875,0.2) 20(2.875,0.6) 21(2.875,1) 22(2.875,1.4) 23(2.875,1.8) 24(2.875,2.2) 37(-2.875,2.2) 38(-2.875,1.8) 39(-2.875,1.4) 40(-2.875,1) 41(-2.875,0.6) 42(-2.875,0.2) 43(-2.875,-0.2) 44(-2.875,-0.6) 45(-2.875,-1) 46(-2.875,-1.4) 47(-2.875,-1.8) 48(-2.875,-2.2)
  rect 4.547x4.547 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1.968,1.968) 51(1.968,1.968) 52(0,0) 53(-1.968,-1.968) 54(1.968,-1.968)
VX_QFN_48P_16_S236_P_REA_4V
  rect 0.222x0.61 smd: 1(-2.2,-2.85) 2(-1.8,-2.85) 3(-1.4,-2.85) 4(-1,-2.85) 5(-0.6,-2.85) 6(-0.2,-2.85) 7(0.2,-2.85) 8(0.6,-2.85) 9(1,-2.85) 10(1.4,-2.85) 11(1.8,-2.85) 12(2.2,-2.85) 25(2.2,2.85) 26(1.8,2.85) 27(1.4,2.85) 28(1,2.85) 29(0.6,2.85) 30(0.2,2.85) 31(-0.2,2.85) 32(-0.6,2.85) 33(-1,2.85) 34(-1.4,2.85) 35(-1.8,2.85) 36(-2.2,2.85)
  rect 0.61x0.222 smd: 13(2.85,-2.2) 14(2.85,-1.8) 15(2.85,-1.4) 16(2.85,-1) 17(2.85,-0.6) 18(2.85,-0.2) 19(2.85,0.2) 20(2.85,0.6) 21(2.85,1) 22(2.85,1.4) 23(2.85,1.8) 24(2.85,2.2) 37(-2.85,2.2) 38(-2.85,1.8) 39(-2.85,1.4) 40(-2.85,1) 41(-2.85,0.6) 42(-2.85,0.2) 43(-2.85,-0.2) 44(-2.85,-0.6) 45(-2.85,-1) 46(-2.85,-1.4) 47(-2.85,-1.8) 48(-2.85,-2.2)
  rect 4.648x4.648 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-2.019,2.019) 51(2.019,2.019) 52(-2.019,-2.019) 53(2.019,-2.019)
VX_QFN_48P_20_S276_PAD_PARA
  rect 0.279x0.61 smd: 1(-2.75,-3.35) 2(-2.25,-3.35) 3(-1.75,-3.35) 4(-1.25,-3.35) 5(-0.75,-3.35) 6(-0.25,-3.35) 7(0.25,-3.35) 8(0.75,-3.35) 9(1.25,-3.35) 10(1.75,-3.35) 11(2.25,-3.35) 12(2.75,-3.35) 25(2.75,3.35) 26(2.25,3.35) 27(1.75,3.35) 28(1.25,3.35) 29(0.75,3.35) 30(0.25,3.35) 31(-0.25,3.35) 32(-0.75,3.35) 33(-1.25,3.35) 34(-1.75,3.35) 35(-2.25,3.35) 36(-2.75,3.35)
  rect 0.61x0.279 smd: 13(3.35,-2.75) 14(3.35,-2.25) 15(3.35,-1.75) 16(3.35,-1.25) 17(3.35,-0.75) 18(3.35,-0.25) 19(3.35,0.25) 20(3.35,0.75) 21(3.35,1.25) 22(3.35,1.75) 23(3.35,2.25) 24(3.35,2.75) 37(-3.35,2.75) 38(-3.35,2.25) 39(-3.35,1.75) 40(-3.35,1.25) 41(-3.35,0.75) 42(-3.35,0.25) 43(-3.35,-0.25) 44(-3.35,-0.75) 45(-3.35,-1.25) 46(-3.35,-1.75) 47(-3.35,-2.25) 48(-3.35,-2.75)
  rect 3.912x3.912 smd: 49(0,0)
VX_QFP_128P_16_630X630
  rect 0.191x1.499 smd: 1(-6.2,-7.86) 2(-5.8,-7.86) 3(-5.4,-7.86) 4(-5,-7.86) 5(-4.6,-7.86) 6(-4.2,-7.86) 7(-3.8,-7.86) 8(-3.4,-7.86) 9(-3,-7.86) 10(-2.6,-7.86) 11(-2.2,-7.86) 12(-1.8,-7.86) 13(-1.4,-7.86) 14(-1,-7.86) 15(-0.6,-7.86) 16(-0.2,-7.86) 17(0.2,-7.86) 18(0.6,-7.86) 19(1,-7.86) 20(1.4,-7.86) 21(1.8,-7.86) 22(2.2,-7.86) 23(2.6,-7.86) 24(3,-7.86) 25(3.4,-7.86) 26(3.8,-7.86) 27(4.2,-7.86) 28(4.6,-7.86) 29(5,-7.86) 30(5.4,-7.86) 31(5.8,-7.86) 32(6.2,-7.86) 65(6.2,7.86) 66(5.8,7.86) 67(5.4,7.86) 68(5,7.86) 69(4.6,7.86) 70(4.2,7.86) 71(3.8,7.86) 72(3.4,7.86) 73(3,7.86) 74(2.6,7.86) 75(2.2,7.86) 76(1.8,7.86) 77(1.4,7.86) 78(1,7.86) 79(0.6,7.86) 80(0.2,7.86) 81(-0.2,7.86) 82(-0.6,7.86) 83(-1,7.86) 84(-1.4,7.86) 85(-1.8,7.86) 86(-2.2,7.86) 87(-2.6,7.86) 88(-3,7.86) 89(-3.4,7.86) 90(-3.8,7.86) 91(-4.2,7.86) 92(-4.6,7.86) 93(-5,7.86) 94(-5.4,7.86) 95(-5.8,7.86) 96(-6.2,7.86)
  rect 1.499x0.191 smd: 33(7.86,-6.2) 34(7.86,-5.8) 35(7.86,-5.4) 36(7.86,-5) 37(7.86,-4.6) 38(7.86,-4.2) 39(7.86,-3.8) 40(7.86,-3.4) 41(7.86,-3) 42(7.86,-2.6) 43(7.86,-2.2) 44(7.86,-1.8) 45(7.86,-1.4) 46(7.86,-1) 47(7.86,-0.6) 48(7.86,-0.2) 49(7.86,0.2) 50(7.86,0.6) 51(7.86,1) 52(7.86,1.4) 53(7.86,1.8) 54(7.86,2.2) 55(7.86,2.6) 56(7.86,3) 57(7.86,3.4) 58(7.86,3.8) 59(7.86,4.2) 60(7.86,4.6) 61(7.86,5) 62(7.86,5.4) 63(7.86,5.8) 64(7.86,6.2) 97(-7.86,6.2) 98(-7.86,5.8) 99(-7.86,5.4) 100(-7.86,5) 101(-7.86,4.6) 102(-7.86,4.2) 103(-7.86,3.8) 104(-7.86,3.4) 105(-7.86,3) 106(-7.86,2.6) 107(-7.86,2.2) 108(-7.86,1.8) 109(-7.86,1.4) 110(-7.86,1) 111(-7.86,0.6) 112(-7.86,0.2) 113(-7.86,-0.2) 114(-7.86,-0.6) 115(-7.86,-1) 116(-7.86,-1.4) 117(-7.86,-1.8) 118(-7.86,-2.2) 119(-7.86,-2.6) 120(-7.86,-3) 121(-7.86,-3.4) 122(-7.86,-3.8) 123(-7.86,-4.2) 124(-7.86,-4.6) 125(-7.86,-5) 126(-7.86,-5.4) 127(-7.86,-5.8) 128(-7.86,-6.2)
VX_R0201_H10
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_R0402_0OHM_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_H22_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_H24_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_SMALL_SHORT
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
VX_R0603_0OHM_H28_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_H24_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_H28_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0612_4P_H31
  rect 2.311x0.991 smd: 1(1.22,-0.875) 4(1.22,0.875)
  rect 0.787x0.991 smd: 2(-0.72,-0.875) 3(-0.72,0.875)
VX_R0805_H24_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_R1206_H26
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_R1206_H31
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_R1206_H35
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_SATA_13P_4HLD_ALLTP
  round 2.311 hole 2.311 unplated: (-14,0.7) (14,0.7)
  round 1.346 hole 1.346 unplated: (-11.5,0) (11.5,0)
  round 1.067 hole 0.66: P1(-4.45,1) P2(-5.45,0) P3(-6.45,1) P4(-7.45,0) P5(-8.45,1) P6(-9.45,0)
  round 1.067 hole 0.711: S1(9.38,0) S2(8.11,0) S3(6.84,0) S4(5.57,0) S5(4.3,0) S6(3.03,0) S7(1.76,0)
VX_SC59_DII1
  rect 1.118x0.61 smd: 1(1.451,-0.95) 2(1.451,0.95) 3(-1.451,0)
VX_SC70_S5
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
VX_SC70_S5_TI
  rect 0.94x0.356 smd: 1(1.189,-0.65) 2(1.189,0) 3(1.189,0.65) 4(-1.189,0.65) 5(-1.189,-0.65)
VX_SC70_S6
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
VX_SI7850DP
  rect 0.61x1.27 smd: 1(-1.905,-1.68) 2(-0.635,-1.68) 3(0.635,-1.68) 4(1.905,-1.68)
  custom 1.105x1.105 smd: 5(0,1.68)
VX_SOD123
  rect 1.321x1.372 smd: 1(1.74,0) 2(-1.74,0)
VX_SOD323_H35
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
VX_SOD323_H37
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
VX_SOIC_8P_26_122X193_H48
  rect 0.356x1.448 smd: 1(-0.975,-2.335) 2(-0.325,-2.335) 3(0.325,-2.335) 4(0.975,-2.335) 5(0.975,2.335) 6(0.325,2.335) 7(-0.325,2.335) 8(-0.975,2.335)
VX_SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.858) 6(0.635,2.858) 7(-0.635,2.858) 8(-1.905,2.858)
VX_SOIC_8P_50_197X236_COLAY
  rect 0.66x1.562 smd: 1(-1.905,-2.839) 2(-0.635,-2.839) 3(0.635,-2.839) 4(1.905,-2.839) 5(1.905,2.839) 6(0.635,2.839) 7(-0.635,2.839) 8(-1.905,2.839)
VX_SOIC_8P_50_197X236_IDT
  rect 0.635x1.549 smd: 1(-1.905,-2.835) 2(-0.635,-2.835) 3(0.635,-2.835) 4(1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
VX_SOIC_8P_50_211X311_H85
  rect 0.61x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
VX_SOIC_8P_50_213X311
  rect 0.635x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
VX_SOIC_8P_50_217X236
  rect 0.61x1.295 smd: 1(-1.905,-2.962) 2(-0.635,-2.962) 3(0.635,-2.962) 4(1.905,-2.962) 5(1.905,2.962) 6(0.635,2.962) 7(-0.635,2.962) 8(-1.905,2.962)
VX_SOIC_28P_26_386X252
  rect 0.356x1.499 smd: 1(-4.225,-3.06) 2(-3.575,-3.06) 3(-2.925,-3.06) 4(-2.275,-3.06) 5(-1.625,-3.06) 6(-0.975,-3.06) 7(-0.325,-3.06) 8(0.325,-3.06) 9(0.975,-3.06) 10(1.625,-3.06) 11(2.275,-3.06) 12(2.925,-3.06) 13(3.575,-3.06) 14(4.225,-3.06) 15(4.225,3.06) 16(3.575,3.06) 17(2.925,3.06) 18(2.275,3.06) 19(1.625,3.06) 20(0.975,3.06) 21(0.325,3.06) 22(-0.325,3.06) 23(-0.975,3.06) 24(-1.625,3.06) 25(-2.275,3.06) 26(-2.925,3.06) 27(-3.575,3.06) 28(-4.225,3.06)
VX_SON_14P_16_118X79_PAD
  rect 0.203x0.762 smd: 1(-1.2,-1.025) 2(-0.8,-1.025) 3(-0.4,-1.025) 4(0,-1.025) 5(0.4,-1.025) 6(0.8,-1.025) 7(1.2,-1.025) 8(1.2,1.025) 9(0.8,1.025) 10(0.4,1.025) 11(0,1.025) 12(-0.4,1.025) 13(-0.8,1.025) 14(-1.2,1.025)
  rect 2.591x0.864 smd: 15(0,0)
VX_SOP_8P_SPE_FAIRCHILD
  rect 0.66x0.635 smd: 1(-1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
  custom 0.485x0.485 smd: 2(0,-2.18)
  rect 3.988x2.159 smd: 9(0,0.525)
VX_SOT23_2D4_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_2D4_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_H43
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_H44
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_H49
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_S5
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
VX_SOT23_S5_H57
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
VX_SOT23_S5_SC70_RD4
  rect 0.762x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
VX_SOT23_S6_FITI_H57
  rect 0.61x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
VX_SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
VX_SOT353
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 6(-0.65,0.95)
VX_SOT353_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(-0.65,1.19)
VX_SOT363_NB
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
VX_SW_4P_2HOLD_130X130
  rect 0.94x0.61 smd: 1(-1.775,1.1) 2(1.775,1.1) 3(-1.775,-1.1) 4(1.775,-1.1)
  rect 0.787x0.457 smd: 5(0,1.675) 6(0,-1.675)
VX_SW_4P_146_S205_2HOLD_H63
  rect 0.61x0.991 smd: 1(-1.85,-2.2) 2(-1.85,2.2) 3(1.85,-2.2) 4(1.85,2.2)
  rect 0.457x0.991 smd: 5(-2.525,0) 6(2.525,0)
VX_TRANS_24P_39_595X394_BO
  rect 0.584x1.956 smd: 1(-5.5,-4.632) 2(-4.5,-4.632) 3(-3.5,-4.632) 4(-2.5,-4.632) 5(-1.5,-4.632) 6(-0.5,-4.632) 7(0.5,-4.632) 8(1.5,-4.632) 9(2.5,-4.632) 10(3.5,-4.632) 11(4.5,-4.632) 12(5.5,-4.632) 13(5.5,4.632) 14(4.5,4.632) 15(3.5,4.632) 16(2.5,4.632) 17(1.5,4.632) 18(0.5,4.632) 19(-0.5,4.632) 20(-1.5,4.632) 21(-2.5,4.632) 22(-3.5,4.632) 23(-4.5,4.632) 24(-5.5,4.632)
VX_USB_9P_4HOLD_RA_SINGA
  rect 0.991x0.991 hole 0.737: 1(-3.5,-0.6)
  round 0.991 hole 0.737: 2(-1,-0.6) 3(1,-0.6) 4(3.5,-0.6)
  round 1.143 hole 0.737: 5(4,0.9) 6(2,0.9) 7(0,0.9) 8(-2,0.9) 9(-4,0.9)
  oval 0.813x2.21 hole 0.559: 10(-6.4,0) 11(6.4,0)
  oval 0.965x2.972 hole 0.559: 12(-7.85,-6.6) 13(7.85,-6.6)
VX_VARISTOR_0402_H24
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
VX_WTOB_4P_31_2H_RA
  rect 0.508x0.991 smd: 1(1.2,1.95) 2(0.4,1.95) 3(-0.4,1.95) 4(-1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
VX_WTOB_4P_39_2H_ACES
  rect 0.61x1.549 smd: 1(1.5,2.525) 2(0.5,2.525) 3(-0.5,2.525) 4(-1.5,2.525)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
VX_WTOB_4P_49_2HD_ACE
  rect 0.787x1.6 smd: 1(1.875,2.9) 2(0.625,2.9) 3(-0.625,2.9) 4(-1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
VX_WTOB_4P_49_2HD_RA_ACES
  rect 0.787x2.007 smd: 1(1.875,4.05) 2(0.625,4.05) 3(-0.625,4.05) 4(-1.875,4.05)
  rect 2.007x2.489 smd: 5(-4.075,0) 6(4.075,0)
VX_WTOB_5P_39_2HOLD_ENTE
  rect 0.61x1.549 smd: 1(2,2.425) 2(1,2.425) 3(0,2.425) 4(-1,2.425) 5(-2,2.425)
  rect 1.194x2.007 smd: 6(-3.3,0) 7(3.3,0)
VX_WTOB_6P_31_2H
  rect 0.508x0.991 smd: 1(2,1.95) 2(1.2,1.95) 3(0.4,1.95) 4(-0.4,1.95) 5(-1.2,1.95) 6(-2,1.95)
  rect 1.194x1.702 smd: 7(3.3,0) 8(-3.3,0)
VX_WTOB_7P_59_4HOLD_RA
  rect 0.838x2.21 smd: 1(4.5,0.9) 2(3,0.9) 3(1.5,0.9) 4(0,0.9) 5(-1.5,0.9) 6(-3,0.9) 7(-4.5,0.9)
  rect 0.66x1.295 smd: 8(5.875,0) 9(-5.875,0)
  rect 0.66x2.489 smd: 10(5.875,-2.65) 11(-5.875,-2.65)
VX_WTOB_10P_79_2HD_RA_CUIL
  rect 0.559x1.803 smd: 1(9,5.275) 2(7,5.275) 3(5,5.275) 4(3,5.275) 5(1,5.275) 6(-1,5.275) 7(-3,5.275) 8(-5,5.275) 9(-7,5.275) 10(-9,5.275)
  rect 1.295x2.057 smd: 11(12.1,0) 12(-12.1,0)
VX_WTOB_20P_20_6HOLD_ENTERY
  round 0.914 hole 0.914 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(4.75,2.125) 2(4.25,2.125) 3(3.75,2.125) 4(3.25,2.125) 5(2.75,2.125) 6(2.25,2.125) 7(1.75,2.125) 8(1.25,2.125) 9(0.75,2.125) 10(0.25,2.125) 11(-0.25,2.125) 12(-0.75,2.125) 13(-1.25,2.125) 14(-1.75,2.125) 15(-2.25,2.125) 16(-2.75,2.125) 17(-3.25,2.125) 18(-3.75,2.125) 19(-4.25,2.125) 20(-4.75,2.125)
  rect 1.295x1.397 smd: 21(5.8,2) 22(-5.8,2) 23(5.8,-2) 24(-5.8,-2)
VX_WTOB_40P_20_6HD_STAR
  round 0.864 hole 0.864 unplated: (-10.5,0) (10.5,0)
  rect 0.305x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
VX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
VX_XTAL_4P_126X98_HOSON_H28
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
VX_XTAL_4P_126X98_RAK
  rect 1.397x1.143 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
VX_XTAL_4P_126X98_TXC_H35
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
VX_XTAL_4P_272X55
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
1.0VSUS_BST: R8200.2 U8200.10
1.0VSUS_BST_R: C8207.2 R8200.1
1.0VSUS_EN: C8205.1 D8200.1 R8201.2 U8200.15
1.0VSUS_FB: R8205.2 R8206.1 R8207.2 U8200.13
1.0VSUS_FB_R: JP8200.1 R8205.1
1.0VSUS_LX: C8207.1 L8200.1 R8202.2 R8208.1 T8200.1 U8200.9
1.0VSUS_RC: C8208.1 R8202.1
1.05V_BST: R9603.2 U9600.10
1.05V_BST_R: C9609.2 R9603.1
1.05V_EN: C9603.1 D9600.1 R9602.2 U9600.13
1.05V_FB: R9604.2 R9605.1 R9606.2 U9600.12
1.05V_FB_R: C9601.1 JP9601.1 R9606.1
1.05V_FB_R1: C9601.2 R9600.1 R9605.2
1.05V_LX: C9609.1 L9600.2 R9600.2 R9601.2 T9603.1 U9600.8 U9600.9 U9600.15 U9600.16
1.05V_RC: C9611.1 R9601.1
1.05V_VOUT: C9608.1 JP9602.1 U9600.7
1.5VS_EN: C8402.1 R8402.2 U8400.5
1.5VS_IN: C8404.1 SR8400.1 U8400.8
1.5VS_VDD: C8403.1 R8400.2 U8400.6
2.5VO_BST: R9500.2 U9500.10
2.5VO_EN: C9511.1 R9503.2 R9507.2 U9500.13
2.5VO_FB: R9504.1 R9505.2 R9506.2 U9500.12
2.5VO_VOUT: C9503.1 JP9502.1 U9500.7
3V_BST: SR8101.2 U8100.9
3V_BST_R: C8108.2 SR8101.1
3V_FB: C8114.1 R8105.2 R8107.2 U8100.4
3V_FB_R: C8114.2 C8116.2 JP8105.1 R8105.1
3V_HG: Q8101.1 T8103.1 U8100.10
3V_LG: Q8101.8 T8101.1 U8100.11
3V_LX: C8108.1 L8101.1 Q8101.9 R8101.2 T8105.1 U8100.8
3V_RC: C8112.1 R8101.1
5V_BST: SR8100.1 U8100.17
5V_BST_R: C8107.1 SR8100.2
5V_FB: C8113.2 R8104.2 R8106.2 U8100.2
5V_FB_R: C8113.1 C8115.1 JP8103.2 R8104.1
5V_HG: Q8100.1 T8102.1 U8100.16
5V_LG: Q8100.8 T8106.1 U8100.15
5V_LX: C8107.2 L8100.2 Q8100.9 R8100.2 T8104.1 U8100.18
5V_RC: C8111.1 R8100.1
5V_VO1: JP8104.2 U8100.14
+0.6VO: C8300.1 C8301.1 C8302.1 C8327.1 C8328.1 JP8300.1 JP8301.2 T8308.1 T8309.1 T8310.1 U8300.20
+1.0V: C1003.2 C1006.2 C9101.1 R0707.1 R0708.2 R0729.2 R0736.1 R0737.1 R0738.1 R0739.1 R0747.1 R2450.1 T9100.1 U0300.H28 U0300.H30 U0300.J28 U9100.14
+1.0VO: C8209.1 C8210.1 C8211.1 C8212.1 C8213.1 C8216.1 C9107.1 JP8200.2 JP8202.2 L8200.2 T8201.1 U8200.6 U9100.1 U9100.7
+1.0VS: C1004.1 C1005.1 C9110.1 R0706.2 T9102.1 U0300.G30 U0300.H29 U9100.8
+1.0VSUS: C2608.1 C2609.1 C80134.1 JP8202.1 R2512.2 R2604.1 R2606.1 R2607.1 R2613.1 R4400.1 R4401.1 R4410.1 R80147.1 R80148.1 R80149.1 R80150.1 T4401.1 T8202.1 T8204.1 U2000.N17 U2000.R17 U2000.R19 U2000.U20 U2000.U21 U2000.U23 U2000.U25 U2000.U26 U2000.V17 U2000.V26 U2000.V28
+1.0VSUS_PWRGD: R9213.1 T9210.1 U8200.12
+1.2VO_DDR: C8311.1 C8312.1 C8313.1 C8315.1 C8316.1 C8317.1 JP8302.1 JP8303.1 JP8304.1 L8300.2 SR8300.1 T8302.1 T8303.1 T8304.1
+1.5VO: C8400.1 C8401.1 C8405.1 JP8400.1 R8401.1 U8400.1
+1.05VO_VGA: C9600.1 C9602.1 C9607.1 C9613.1 C9614.1 JP9600.1 JP9601.2 JP9602.2 L9600.1 T9602.1
+1.5VS: C5171.1 C8406.1 JP8400.2 L3600.1 R3612.1 U5102.5
+1.5VS_PWRGD: R9210.1 T9201.1 U8400.3
+1.05VS_VGA_PWRGD: R9207.1 T9208.1 U9600.4
+1.35VO_VGA: C8905.1 C8917.1 CE8900.1 CE8901.1 JP8901.1 JP8902.1 L8900.2 R8909.2 T8901.1 T8902.1
+1V_DCPDSW: C2622.1 U2000.BA29
+1V_PRIM_W12MIL: C2600.1 C2601.1 R2613.2 U2000.AA23 U2000.AA26 U2000.AA28 U2000.AC17 U2000.AC23 U2000.AC26 U2000.AC28 U2000.AD15 U2000.AE23 U2000.AE26 U2000.AJ20 U2000.AJ21 U2000.AJ23 U2000.AJ25 U2000.AL22 U2000.Y23 U2000.Y25
+2.5V_PWRGD: R9209.1 T9200.1 U9500.4
+2.5VO: C9506.1 C9507.1 C9508.1 C9509.1 C9510.1 JP9500.2 JP9501.2 JP9502.2 L9500.1 T9503.1
+3V: C9119.1 T9105.1 U9102.14
+3V3_AON: C7026.1 C7027.1 C7028.1 C7591.1 C7592.1 C7593.1 C8746.1 C8747.1 C9133.1 Q7000.1 Q7400.1 Q7401.1 Q7402.1 Q9105.2 R5702.1 R7000.2 R7001.1 R7208.1 R7307.1 R7308.1 R7309.1 R7310.1 R7311.1 R7405.1 R7406.1 R7409.1 R7410.1 R7414.1 R7419.1 R7423.2 R7437.2 R7438.1 R7439.1 R7443.1 R7444.2 R7445.1 R8736.2 R8737.2 R8738.2 R8739.2 T9114.1 U7000.AW17 U7000.AW30 U7000.AW32 U7000.AY17 U7002.5 U8702.4 U8702.16
+3V3_AON_DISCH_A: Q5702.3 R5702.2
+3V3_FLASH: C1129.1 C1206.1 R1103.2 R1104.2 R1105.2 R1106.2 R1155.2 R1223.1 R1224.1 R1225.1 U1103.8 U1201.G1
+3V3_MAIN: C7301.1 C7302.1 C7303.1 C7304.1 C7306.1 C7307.1 C7308.1 C7400.1 C7590.1 C7594.1 C7595.1 C7596.1 C9102.1 L7100.2 L7203.1 Q9100.2 R5707.1 R7215.1 R7216.1 R7217.1 R7218.1 R7304.1 R7305.1 R7306.2 R7400.2 R7411.1 R8706.2 R8902.1 T9101.1 U7000.AJ10 U7000.AJ11 U7000.AK11 U7000.AM11 U7000.AN11 U7000.AR11 U7000.AW15 U7000.AY15 U7401.3 U7401.7 U7401.8
+3V3_MAIN_DISCH_A: Q5705.3 R5707.2
+3V3_TBTA_SX: C1205.1 U1201.H2
+3V_WLAN: C5300.1 C5303.1 C5306.2 C5307.1 CON5300.2 CON5300.4 CON5300.72 CON5300.74 L5300.2 L5302.2 R5300.1 R5308.1
+3VA: CON5602.20 D6005.2 D6006.2 JP8106.2 JP9300.1 JP9301.1 JP9302.1 JP9303.1 R2619.2 R3000.1 R3161.2 R4412.1 R4592.1 R5704.1 R6001.1 R8811.2 SR8102.2 T8121.1
+3VA_EC: C3000.1 C3001.1 C3002.1 C3003.1 C3004.1 C3019.1 C3020.1 C3023.1 C3024.1 C3025.1 D5004.1 R3000.2 R3001.1 R3005.1 R3047.1 R3053.1 R3061.1 R3065.1 R3070.1 R3071.1 R5004.1 R5014.2 U3001.3 U3001.26 U3001.50 U3001.92 U3001.114 U3001.121 U3001.127
+3VA_PWR: CON402.20 PSR701.1
+3VA_PWR_HS: PC701.1 PR700.2 PR702.2 PSR701.2 PU701.1
+3VACC: C3021.1 R3047.2 U3001.74
+3VO: C8110.1 C9115.1 C9122.1 CE8101.1 CE8103.1 JP8102.2 JP8105.2 JP8108.2 JP8109.2 L8101.2 Q9100.3 Q9105.3 R8203.2 R9404.2 SR8200.1 SR8400.2 SR9400.1 T8124.1 T8125.1 U9101.1 U9101.2 U9101.6 U9101.7 U9102.1
+3VS: C1604.1 C1605.2 C1606.1 C1607.1 C1608.2 C1609.1 C1704.1 C1705.2 C1706.1 C1707.2 C1708.1 C1709.1 C2403.1 C2620.1 C3009.1 C3602.1 C4400.1 C4536.1 C4540.1 C4541.1 C5000.2 C5007.2 C5600.1 C5801.1 C5802.1 C5803.1 C6707.1 C9112.1 C9113.1 CON1600.255 CON1601.255 CON1700.255 CON1701.255 CON4400.10 CON4400.12 CON5602.18 CON6701.1 CON6701.2 L5302.1 Q1201.1 Q1202.1 Q4601.2 Q4801.1 Q4802.1 Q4803.1 Q4805.1 R0301.1 R0306.1 R0704.1 R1159.1 R1238.1 R1303.1 R1408.1 R1604.1 R1605.1 R1606.1 R1607.1 R1608.1 R1609.1 R1623.1 R1624.1 R1704.1 R1705.1 R1706.1 R1707.1 R1708.1 R1709.1 R2106.1 R2128.1 R2129.1 R2131.1 R2132.1 R2133.1 R2134.1 R2135.1 R2136.1 R2144.1 R2151.1 R2152.1 R2153.1 R2154.1 R2155.1 R2162.1 R2202.1 R2203.1 R2204.1 R2205.1 R2206.1 R2207.1 R2208.1 R2209.1 R2210.1 R2244.1 R2245.1 R2246.1 R2247.1 R2249.1 R2251.1 R2360.1 R2361.1 R2364.1 R2365.1 R2379.1 R2380.1 R2403.1 R2404.1 R2405.1 R2419.1 R2449.1 R2451.1 R2497.1 R2618.2 R3081.1 R3104.1 R3105.1 R3112.2 R3141.1 R3143.1 R3145.1 R3147.1 R3149.1 R3170.2 R3603.2 R3604.1 R3605.1 R3608.1 R3609.1 R3632.1 R4302.1 R4303.1 R4304.1 R4305.1 R4306.1 R4307.1 R4308.1 R4309.1 R4310.1 R4311.1 R4501.1 R4502.1 R4504.1 R4518.1 R4526.1 R4587.2 R4593.1 R4603.1 R4800.1 R4817.1 R4818.1 R5000.1 R5001.1 R5002.1 R5003.1 R5007.1 R5008.1 R5011.1 R5012.1 R5013.1 R5018.1 R5127.1 R5129.1 R5130.1 R5132.1 R5134.1 R5603.1 R5806.2 R5808.1 R6101.1 R6103.1 R6113.1 R6115.1 R6117.1 R6119.1 R6121.1 R6123.1 R6202.1 R7010.1 R9200.1 R9203.1 T9104.1 U2301.2 U2301.5 U2401.5 U3001.11 U3600.36 U4502.2 U5000.1 U5003.5 U5800.7 U9101.8 U9101.9 U9101.13 U9101.14
+3VS_CAM: C4539.1 CON4500.31 R4502.2 T4508.1
+3VS_DACVDD: C7200.1 C7228.1 C7229.1 R7215.2 U7000.AW18
+3VS_DMIC: CON4500.27 R4504.2 T4507.1
+3VS_DMIC L: CON300.4 CON302.6 SR300.1
+3VS_DMIC R: CON400.4 SR400.1
+3VS_DPSW: C1413.1 C1414.2 R1402.1 R1403.1 R1405.1 R1407.1 R1408.2 R1414.1 R1415.1 U1401.1 U1401.6 U1401.12 U1401.25 U1401.32 U1401.36
