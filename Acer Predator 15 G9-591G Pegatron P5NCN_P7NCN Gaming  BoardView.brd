# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+FBVDDQ_DISCH_A: length 3
  BOTTOM w0.254: Q5700.3 152.71,130.93 152.99,130.64 R5700.2 v1(153.98,130.32)
+FBVDDQ_ENABLE: length 142.3
  TOP w0.102: SR8902.1 174.24,82.2 174.24,87.98 v2(174.12,88.1)
  IN1 w0.102: v2(159.27,85.13) 158.85,85.54 158.85,86.7 161.6,89.45 172.77,89.45 v2(174.12,88.1)
  IN4 w0.102: v2(95.68,110.58) 97.28,110.58 98.67,111.98 99.36,111.98 99.59,111.74 99.59,111.15 99.49,111.05 99.49,103.4 109.85,93.04 109.85,89.62 115.22,84.25 115.78,84.25 116.71,83.32 118.87,83.32 122.66,79.53 123.4,79.53 124.2,78.73 125.29,78.73 126.86,77.17 126.86,76.65 128.05,75.46 138.14,75.46 139.26,76.58 146.14,76.58 146.6,76.12 150.96,76.12 152.07,77.23 152.07,77.92 152.56,78.4 157.7,78.4 159.08,79.78 159.08,84.94 v2(159.27,85.13)
  BOTTOM w0.102: D7402.3 105.86,114.76 R7448.2 107.03,113.59 107.03,110.55 105.93,109.46 105.93,108.21 105.4,107.67 97.1,107.67 95,109.78 v1(94.76,109.78) 94.76,110.1 95.25,110.58 v2(95.68,110.58)
+LX:
  vias: v1(231.7,90.8)
+NVVDD: length 198.7
  TOP w0.457: C75026.1 100.64,139.34 v6(100.89,139.59)
  IN1 w0.102: 107.35,127.52 107.76,127.47 ; 114.22,100.91 114.58,100.91 114.58,100.91 ; 101.68,128.31 102.13,128.31 ; 115.58,101.5 115.58,101.14 ; 107.31,125.09 107.77,125.09 ; 115.56,100.7 115.56,100.32 ; 107.1,128.5 107.12,128.97 ; 114.78,101.46 114.78,101.1 ; 115.02,101.71 115.38,101.71 ; 114.99,100.93 115.39,100.93 ; 106.54,127.47 106.94,127.5 ; 107.13,127.31 107.11,126.86 ; 114.77,100.34 114.77,100.74 ; 107.35,128.26 107.83,128.33 ; 114.19,101.68 114.57,101.7 ; 107.31,124.29 107.68,124.29
  IN1 w0.508: 143.18,95.34 145.34,95.34 146.48,94.2 146.48,92.93 149.15,90.26 v2(154.97,90.26) 161.06,90.26 162.14,91.35 162.14,92.82 158.51,96.45 158.37,96.66 158.23,96.87 157.99,97.38 157.89,97.59 157.71,98.19 157.69,98.27 157.64,98.79 157.62,99.03 157.62,101.74 157.83,102.59 158.04,103.11 158.99,104.72 158.99,104.8 160.71,106.52 160.71,109.72 160,111.68 159.78,112.31 159.71,112.49 159.54,112.96 159.43,113.07 159.28,113.22 159.28,113.68 159.19,113.93 159.18,113.98 159.15,114.04 158.12,115.07 157.58,115.07 156.92,115.73 156.92,116.31 158.06,117.45 158.06,141.26 v2(157.48,141.85)
  IN2 w0.102: 91.09,124.89 91.08,124.58 ; 135.7,108.36 135.69,108.78 ; 92.69,141.66 92.69,141.32 ; 135.9,112.17 136.32,112.17 ; 107.31,123.48 107.7,123.47 ; 96.7,141.65 96.7,141.32 ; 138.43,112.57 138.87,112.59 ; 127.29,123.49 127.7,123.49 ; 135.09,108.96 135.51,108.97 ; 135.93,111.38 136.31,111.38 ; 97.27,123.49 96.92,123.5 ; 94.3,130.09 94.3,130.47 ; 97.5,142.93 97.5,143.29 ; 135.16,113 135.5,112.97 ; 94.31,150.14 94.31,150.45 ; 134.86,111.97 134.86,111.6 ; 135.13,110.53 135.48,110.57 ; 123.32,124.33 123.71,124.32 ; 93.49,136.49 93.49,136.83 ; 92.71,136.47 92.71,136.87 ; 127.91,126.94 127.91,127.27 ; 134.92,109.24 134.92,109.55 ; 96.71,149.28 96.71,149.67 ; 123.32,125.9 123.74,125.88 ; 95.08,130.12 95.08,130.51 ; 137.55,112.16 137.88,112.15 ; 93.29,145.89 92.92,145.89 ; 93.74,143.48 97.26,143.48 ; 97.49,141.66 97.49,141.29 ; 107.29,125.09 107.67,125.11 ; 92.7,144.04 92.7,143.76 ; 93.5,131.69 93.5,132.05 ; 135.68,112.73 135.68,112.36 ; 127.11,123.35 127.11,122.88 ; 125.48,128.06 125.5,127.63 ; 92.71,150.1 92.71,150.46 ; 93.51,147.76 93.51,148.07 ; 107.37,127.51 107.71,127.5 ; 93.49,141.66 93.49,141.32 ; 94.29,141.67 94.29,141.34 ; 135.13,111.37 135.44,111.38 ; 95.85,130.13 95.87,130.49 ; 101.74,128.29 102.2,128.31 ; 135.71,109.56 135.71,109.12 ; 95.89,148.04 95.9,147.71 ; 127.1,127.27 127.1,126.87 ; 95.92,149.29 95.92,149.65 ; 95.88,145.31 95.88,145.69 ; 96.69,147.7 96.69,148.1 ; 95.9,141.65 95.9,141.32 ; 87.5,123.8 87.96,123.81 ; 91.88,124.55 91.91,124.89 ; 93.5,150.11 93.5,150.44 ; 95.09,141.65 95.09,141.33 ; 91.88,136.5 91.88,136.83 ; 107.11,128.93 107.12,128.45 ; 107.38,128.28 107.77,128.32 ; 93.5,146.08 93.5,146.4 ; 122.89,129.9 122.5,129.89 ; 137.57,117.09 137.8,116.98 ; 99.11,144.27 98.71,144.3 ; 89.42,123.09 89.82,123.09 ; 134.35,108.97 134.75,108.97 ; 97.27,122.71 96.9,122.7 ; 107.34,124.28 107.7,124.29 ; 138.45,111.74 138.81,111.77 ; 122.33,125.67 122.33,125.19 ; 135.91,109.75 136.35,109.77 ; 123.09,129.67 123.08,129.3 ; 138.09,109.61 138.12,109.19 ; 135.94,108.97 136.36,108.97 ; 96.48,145.91 96.12,145.91 ; 123.09,125.72 123.09,125.27 ; 89.38,122.32 89.81,122.32 ; 107.13,127.31 107.1,126.86 ; 125.72,128.3 126.11,128.29 ; 122.29,132.1 122.3,131.72 ; 135.1,112.17 135.51,112.18 ; 123.31,125.1 123.73,125.11 ; 135.68,111.14 135.68,110.74 ; 93.26,138.68 92.99,138.68 ; 135.12,109.76 135.53,109.77 ; 135.69,111.95 135.7,111.59 ; 92.7,145.33 92.7,145.65 ; 95.9,132.09 95.93,131.73
  IN3 w0.102: 135.71,112.59 135.67,112.34 ; 125.72,128.3 126.11,128.29 ; 94.3,130.47 94.3,130.11 ; 134.34,108.93 134.73,108.99 ; 92.7,136.51 92.7,136.86 ; 97.49,141.68 97.49,141.29 ; 95.88,130.5 95.84,130.13 ; 95.33,139.5 95.73,139.5 95.73,139.49 ; 93.48,146.11 93.53,146.46 ; 127.11,123.35 127.11,122.88 ; 134.9,109.53 134.9,109.15 134.91,109.14 ; 122.17,103.3 122.6,103.27 ; 135.15,110.56 135.52,110.57 ; 94.29,141.33 94.3,141.69 ; 91.1,124.87 91.1,124.55 ; 94.9,139.5 94.9,139.5 94.54,139.5 ; 95.72,138.72 95.7,138.71 95.34,138.71 ; 93.51,136.85 93.51,136.8 93.5,136.5 ; 116.38,101.52 116.38,101.16 ; 91.89,124.87 91.89,124.5 ; 127.09,126.92 127.08,127.28 ; 123.09,125.65 123.09,125.24 ; 94.31,138.51 94.3,138.51 94.3,138.13 ; 93.51,150.48 93.51,150.09 ; 135.93,108.96 136.3,108.95 ; 92.91,145.89 93.37,145.89 ; 116.39,107.07 116.38,106.75 ; 137.55,112.15 137.87,112.15 ; 120.85,101.61 120.41,101.61 ; 92.71,144.06 92.71,143.7 ; 135.69,109.49 135.69,109.25 ; 91.89,136.84 91.87,136.51 ; 135.15,112.21 135.49,112.15 ; 123.85,101.71 124.39,101.71 ; 93.55,143.5 97.31,143.5 ; 92.71,150.47 92.73,150.08 ; 123.32,124.33 123.71,124.32 ; 89.43,123.1 89.75,123.1 ; 96.89,122.72 97.26,122.72 ; 98.69,144.31 99.1,144.27 ; 92.96,138.69 93.26,138.67 ; 95.09,138.93 95.1,138.93 95.1,139.26 ; 95.09,130.5 95.09,130.14 ; 96.71,149.32 96.69,149.7 ; 96.92,123.5 97.29,123.5 ; 115.58,103.87 115.61,103.48 ; 94.3,150.46 94.33,150.09 ; 116.62,107.34 117,107.33 ; 135.68,111.14 135.69,110.77 ; 121.34,104.12 121.74,104.09 ; 135.7,111.88 135.67,111.64 ; 95.9,145.67 95.87,145.34 ; 94.53,138.7 94.86,138.7 94.86,138.7 ; 113.26,105.6 113.67,105.64 ; 95.89,144.08 95.89,142.88 ; 109.54,124.88 109.53,124.55 ; 95.13,140.07 95.13,139.68 95.13,139.67 ; 135.15,113.01 135.49,112.96 ; 96.71,143.27 96.71,142.92 ; 95.1,138.1 95.1,138.11 95.1,138.47 ; 123.32,125.9 123.74,125.88 ; 107.29,125.09 107.76,125.09 ; 106.56,127.51 106.94,127.5 ; 96.71,141.32 96.71,141.67 ; 117.03,101.72 116.59,101.72 ; 122.21,101.68 122.62,101.68 ; 92.7,145.31 92.72,145.73 ; 93.5,148.09 93.5,147.73 ; 107.12,127.3 107.12,126.86 ; 117.19,106.25 117.18,105.91 ; 127.29,123.49 127.7,123.49 ; 135.2,111.35 135.52,111.38 ; 135.88,112.17 136.32,112.16 ; 107.33,123.49 107.74,123.48 ; 123.31,125.1 123.73,125.11 ; 115.85,104.91 116.2,104.91 ; 122.01,104.7 121.98,104.34 ; 135.12,108.97 135.5,108.97 ; 120.93,103.17 120.5,103.2 ; 96.72,147.72 96.71,148.08 ; 123.01,102.5 123.4,102.52 ; 137.51,117.08 137.94,116.92 ; 95.11,144.12 95.11,142.9 ; 107.32,124.31 107.75,124.28 ; 116.97,103.32 116.54,103.32 ; 92.71,141.31 92.72,141.69 ; 107.37,127.52 107.76,127.47 ; 93.49,141.32 93.5,141.68 ; 97.5,142.93 97.51,143.29 ; 96.7,144.06 96.7,143.72 96.69,143.72 ; 114.19,101.67 114.65,101.71 ; 93.51,138.46 93.51,138.12 ; 95.9,149.32 95.9,149.71 ; 134.89,111.93 134.87,111.6 ; 115.59,105.49 115.6,105.14 ; 122.89,129.9 122.5,129.89 ; 95.1,141.33 95.1,141.71 ; 94.32,144.11 94.32,142.9 ; 115.54,100.37 115.57,100.69 ; 95.92,141.33 95.9,141.66 ; 115,104.08 115.34,104.1 ; 107.14,128.93 107.08,128.47 ; 120.88,102.39 120.44,102.39 ; 123.09,129.67 123.08,129.3 ; 138.11,109.6 138.11,109.21 ; 107.38,128.3 107.71,128.33 ; 122.29,132.1 122.3,131.72 ; 93.53,132.03 93.53,131.71 ; 127.91,127.28 127.88,126.91 ; 116.61,106.5 117,106.5 ; 96.11,145.92 96.55,145.92 ; 109.53,123.32 109.52,122.85 ; 122.78,103.86 122.79,103.51 ; 135.71,108.74 135.71,108.46
  IN4 w0.102: 94.49,149.88 95.71,149.9 ; 94.55,139.51 95.76,139.51 ; 96.88,122.71 97.3,122.71 ; 92.69,136.84 92.69,136.47 ; 101.75,128.29 102.08,128.29 ; 94.3,150.45 94.3,150.1 ; 96.12,145.92 96.47,145.92 ; 93.51,138.49 93.52,138.08 ; 96.7,141.66 96.7,141.32 ; 96.71,148.09 96.71,147.67 ; 95.89,141.68 95.89,141.32 ; 96.69,149.69 96.7,149.32 ; 93.52,148.07 93.52,147.7 ; 92.69,141.66 92.69,141.33 ; 93.68,143.5 97.31,143.5 ; 92.71,150.47 92.71,150.06 ; 93.49,150.46 93.49,150.11 ; 89.43,123.1 89.76,123.1 ; 95.89,145.68 95.89,145.33 ; 97.49,141.65 97.49,141.28 ; 95.87,130.49 95.86,130.13 ; 93.5,141.67 93.5,141.34 ; 95.08,130.5 95.1,130.11 ; 95.92,132.11 95.92,131.68 ; 94.3,141.65 94.3,141.32 ; 91.09,124.88 91.07,124.55 ; 95.1,141.67 95.1,141.32 ; 93.48,136.81 93.48,136.49 ; 95.89,148.02 95.89,147.69 ; 93.51,146.42 93.51,146.05 ; 96.94,123.52 97.27,123.49 ; 93.51,132.05 93.51,131.72 ; 98.7,144.32 99.09,144.26 ; 94.3,130.47 94.3,130.09 ; 92.71,145.66 92.71,145.33 ; 91.9,136.81 91.9,136.47 ; 92.92,145.88 93.32,145.88 ; 95.89,149.68 95.89,149.23 ; 91.92,124.88 91.91,124.55 ; 92.97,138.66 93.29,138.66 ; 92.71,144.05 92.71,143.69
  BOTTOM w0.254: v2(154.97,90.26) 155.34,90.26 157.5,88.1 157.5,87.72 158.6,86.62 159.14,86.62 160.38,85.39 R8715.2
  BOTTOM w0.508: v2(157.48,141.85) 157.24,141.61 R5703.1
  vias: v3(88.44,156.43) v3(88.44,155.54) v3(88.44,154.65) v3(88.44,153.76) v3(88.44,152.87) v3(89.33,156.43) v3(89.33,155.54) v3(89.33,154.65) v3(89.33,153.76) v3(89.33,152.87) v3(100.76,106.9) v3(100.76,106.01) v3(101.65,106.9) v3(101.65,106.01) v3(102.13,104.86) v3(102.54,106.9) v3(102.54,106.01) v3(103.02,104.91) v3(103.02,104.02) v3(103.43,106.9) v3(103.43,106.01) v3(103.88,104.98) v3(103.88,104.09) v3(103.88,103.2) v3(104.74,104) v3(104.74,103.11) v3(104.76,102.22) v3(105.57,103.58) v3(105.57,102.69) v3(105.57,101.8) v3(106.45,102.57) v3(106.45,101.68) v3(106.45,100.79) v3(112.5,97.68) v3(112.5,96.66) v3(112.5,95.65) v3(113.39,97.68) v3(113.39,96.66) v3(113.39,95.65) v3(114.27,97.68) v3(114.27,96.66) v3(114.27,95.65) v3(115.16,97.68) v3(115.16,96.66) v3(115.16,95.65) v3(122.23,96.28) v3(122.23,95.33) v3(122.35,92.22) v3(122.35,91.2) v3(123.11,96.28) v3(123.11,95.34) v3(123.24,92.22) v3(123.24,91.2) v3(124,96.28) v3(124,95.39) v3(124.13,92.22) v3(124.13,91.2) v3(124.89,96.28) v3(124.89,95.39) v3(125.02,92.22) v3(125.02,91.2) v3(125.78,96.28) v3(125.78,95.39) v3(125.91,92.22) v3(125.91,91.2) v3(126.67,96.28) v3(127.56,96.28) v3(128.96,92.47) v3(128.96,91.58) v3(129.85,92.47) v3(129.85,91.58) v3(130.48,96.38) v3(130.73,92.47) v3(130.73,91.58) v3(131.03,95.49) v3(131.37,96.38) v3(131.62,92.47) v3(131.62,91.58) v3(131.97,95.45) v3(132.26,96.38) v3(132.51,92.47) v3(132.51,91.58) v3(133.15,96.38) v3(133.4,92.47) v3(133.53,91.58) v3(134.04,95.09) v3(134.04,94.2) v3(134.93,95.09) v3(134.93,94.2) v3(138.86,95.09) v3(138.86,94.2) v3(140.13,106.77) v3(140.13,105.88) v3(140.13,105) v3(140.13,104.11) v3(140.13,103.22) v3(140.13,102.33) v3(140.13,101.44) v3(141.02,108.93) v3(141.02,108.04) v3(141.02,107.15) v3(141.02,103.22) v3(141.02,102.33) v3(141.02,101.44) v3(141.02,100.55) v3(141.91,108.93) v3(141.91,108.04) v3(141.91,107.15) v3(141.91,103.22) v3(141.91,102.33) v3(141.91,101.44) v3(141.91,100.55) v3(142.8,108.93) v3(142.8,108.04) v3(142.8,107.15) v3(142.8,103.22) v3(142.8,102.33) v3(142.8,101.44) v3(142.8,100.55) v3(143.69,101.44) v3(143.69,100.55) v6(88.32,125.11) v6(90.54,160.12) v6(90.73,155.08) v6(90.7,154.28) v6(90.7,152.72) v6(91.5,159.9) v6(91.5,159.1) v6(91.5,158.3) v6(91.5,157.5) v6(91.5,156.7) v6(91.49,155.08) v6(91.49,154.32) v6(91.5,152.72) v6(92.3,159.9) v6(92.3,159.1) v6(92.3,158.3) v6(92.3,157.5) v6(92.3,156.7) v6(92.3,155.1) v6(92.29,154.32) v6(93.14,159.1) v6(93.14,158.33) v6(93.12,157.53) v6(93.11,156.7) v6(93.1,155.1) v6(93.09,154.32) v6(93.9,159.1) v6(93.9,158.34) v6(93.9,157.55) v6(93.9,156.68) v6(93.9,155.08) v6(93.89,154.32) v6(93.9,152.7) v6(93.92,151.9) v6(94.67,159.1) v6(94.67,158.33) v6(94.69,157.55) v6(94.67,156.68) v6(94.7,155.1) v6(94.69,154.32) v6(94.7,152.7) v6(95.43,159.1) v6(95.43,155.16) v6(95.5,158.3) v6(95.5,157.5) v6(95.5,156.7) v6(95.49,154.3) v6(95.53,152.72) v6(96.32,158.34) v6(96.3,157.56) v6(96.32,156.68) v6(96.31,155.93) v6(96.31,155.12) v6(96.33,152.72) v6(96.32,151.1) v6(96.3,150.3) v6(97.1,157.56) v6(97.15,151.85) v6(97.1,151.1) v6(97.1,150.3) v6(97.2,156.68) v6(97.21,155.92) v6(97.21,155.16) v6(97.84,156.68) v6(97.84,154.27) v6(97.91,157.47) v6(97.9,155.9) v6(97.91,155.13) v6(97.97,151.1) v6(97.97,150.28) v6(98.73,156.68) v6(98.73,155.92) v6(98.7,155.16) v6(98.73,154.27) v6(98.93,151.11) v6(98.93,150.3) v6(98.98,149.45) v6(99.5,155.9) v6(99.5,155.1) v6(99.49,154.27) v6(99.49,153.26) v6(100,150.59) v6(100,149.57) v6(100,148.68) v6(100.27,152.61) v6(100.29,151.66) v6(100.89,143.65) v6(100.89,141.62) v6(100.89,137.56) v6(100.89,135.65) v6(100.9,133.61) v6(100.89,131.59) v6(100.98,150.58) v6(100.97,149.59) v6(101.15,151.66) v6(101.06,147.66) v6(101.54,131.47) v6(101.9,153.5) v6(101.91,150.59) v6(102.03,149.62) v6(102.03,148.6) v6(102.03,147.59) v6(102.16,145.56) v6(102.16,143.65) v6(102.16,141.62) v6(102.16,139.59) v6(102.16,137.56) v6(102.16,133.62) v6(103.05,149.62) v6(103.05,147.59) v6(103.94,144.54) v6(103.94,143.52) v6(103.94,142.64) v6(103.94,141.62) v6(103.94,140.6) v6(103.94,139.59) v6(103.94,138.57) v6(103.94,137.56) v6(103.94,136.54) v6(103.94,135.52) v6(103.94,134.51) v6(104.02,150.45) v6(104.06,149.62) v6(104.06,148.6) v6(104.06,147.59) v6(104.06,146.57) v6(104.06,145.56) v6(104.95,149.62) v6(104.95,147.59) v6(104.95,145.56) v6(104.95,143.52) v6(104.95,141.62) v6(104.95,139.59) v6(104.95,137.56) v6(104.95,135.52) v6(105.97,150.45) v6(105.97,149.62) v6(105.97,148.6) v6(105.97,147.59) v6(105.97,146.57) v6(105.97,134.49) v6(106.13,133.55) v6(106.07,131.72) v6(106.58,131.35) v6(106.99,149.62) v6(106.99,147.59) v6(106.99,131.78) v6(107.11,143.52) v6(107.11,141.62) v6(107.11,139.59) v6(107.11,137.68) v6(107.11,135.65) v6(107.11,133.62) v6(107.36,131.33) v6(107.92,149.69) v6(108.03,132.6) v6(108,131.67) v6(108.89,145.56) v6(108.89,143.52) v6(108.89,141.62) v6(108.89,139.59) v6(108.89,137.68) v6(108.89,135.65) v6(108.89,133.62) v6(109.97,149.68) v6(110.15,143.62) v6(110.14,142.64) v6(110.15,141.6) v6(110.15,140.65) v6(110.15,138.67) v6(110.14,137.65) v6(110.13,136.64) v6(110.13,135.62) v6(110.14,134.62) v6(110.15,144.56) v6(110.16,139.62) v6(110.17,133.63) v6(110.16,132.6) v6(111.05,147.59) v6(112.07,149.62) v6(112.07,148.6) v6(112.07,147.59) v6(112.07,146.57) v6(112.07,145.56) v6(112.07,143.65) v6(112.07,141.62) v6(112.07,139.59) v6(112.07,137.56) v6(112.07,135.65) v6(112.07,133.62) v6(112.95,147.59) v6(112.98,132.66) v6(113.87,149.67) v6(113.87,145.56) v6(113.87,143.65) v6(113.87,141.62) v6(113.87,139.59) v6(113.87,137.56) v6(113.87,135.52) v6(113.87,133.62) v6(115.11,147.69) v6(115.11,145.56) v6(115.11,143.65) v6(115.11,141.62) v6(115.11,139.59) v6(115.11,137.56) v6(115.11,135.52) v6(115.11,133.62) v6(116,149.64) v6(116.76,145.61) v6(116.79,144.62) v6(116.79,143.6) v6(116.76,142.61) v6(116.79,141.59) v6(116.81,140.63) v6(116.81,139.64) v6(116.81,138.62) v6(116.79,137.58) v6(116.81,136.57) v6(116.81,135.63) v6(116.81,134.63) v6(116.81,133.59) v6(116.89,132.6) v6(117.15,148.6) v6(117.15,147.59) v6(117.15,146.57) v6(118.08,145.68) v6(118.08,143.65) v6(118.08,141.62) v6(118.08,139.59) v6(118.08,137.56) v6(118.08,135.65) v6(118.08,133.62)
+NVVDD_DISCH_A: length 2.8
  BOTTOM w0.508: Q5703.3 156.26,139.67 156.13,139.79 R5703.2 155.1,140.27 v1(154.98,140.4)
+RTC_POWER: length 26.3
  TOP w0.229: U8100.3 218.62,76.93
  IN1 w0.508: v2(224.08,58.26) 224.08,60.2 222.09,62.2 222.09,65.69 220.78,67 220.78,70.3 217.42,73.65 217.42,75.21 218.62,76.4 v2(218.62,78.76)
  BOTTOM w0.508: D2801.1 223.19,58.76 223.7,58.26 v2(224.08,58.26)
+V_SM_VREF_R: length 2.9
  TOP w0.203: U8300.4 134.94,60.24 135.15,60.04 135.15,59.57 C8303.1
  TOP w0.305: C8303.1 v1(135.7,58.03)
+VCORE: length 45.3
  TOP w0.254: v2(13.14,179.85) R80112.1
  IN1 w0.102: 53.87,142.37 54.28,142.37 ; 49.76,141.86 50.13,141.86 ; 47.51,141.82 47.85,141.82 ; 43.95,136.67 44.34,136.67
  IN2 w0.102: 44.33,135.9 43.95,135.9 ; 51.44,136.67 51.06,136.67 ; 51.46,135.9 51.04,135.9 ; 48.08,136.67 47.58,136.67 ; 50.14,141.86 49.7,141.86 ; 54.24,142.37 53.9,142.37 ; 48.01,135.9 47.63,135.9 ; 47.86,141.82 47.51,141.82 ; 44.37,136.67 43.95,136.67
  IN3 w0.102: 53.89,142.37 54.24,142.37 ; 49.74,141.86 50.14,141.86 ; 47.5,141.82 47.89,141.82
  IN3 w0.254: v2(13.14,179.85) 13.14,179.42 13.83,178.73 23.16,178.73 24.08,177.81 24.08,175.07 24.48,174.68 25.44,174.68 26.87,173.25 29.54,173.25 32.06,170.73 33.47,170.73 37.64,166.56 v3(37.64,161.81)
  IN4 w0.102: 55.67,147.03 55.67,146.63
  BOTTOM w0.203: U0300.AF35 v6(44.26,150.09)
  vias: v1(43.34,152.99) v3(37.64,160.92) v3(38.53,161.81) v3(38.53,160.92) v3(39.42,161.81) v3(39.42,160.92) v3(39.42,160.03) v3(39.42,159.15) v3(39.42,158) v3(39.42,157.11) v3(39.42,156.22) v3(40.95,162.07) v3(40.95,161.18) v3(40.95,160.29) v3(40.95,159.4) v3(40.95,158.26) v3(40.95,157.37) v3(40.95,156.35) v3(40.95,155.46) v3(41.83,162.07) v3(41.83,161.18) v3(41.83,160.29) v3(41.83,159.4) v3(41.83,158.26) v3(41.83,157.37) v3(41.83,156.35) v3(41.83,155.46) v3(42.09,154.57) v3(42.72,162.07) v3(42.72,161.18) v3(42.72,160.29) v3(42.72,156.35) v3(42.72,155.46) v3(42.98,154.57) v3(43.61,162.07) v3(43.61,161.18) v3(43.61,160.29) v3(43.61,156.35) v3(43.61,155.46) v3(43.87,154.57) v3(44.5,156.35) v3(44.5,155.46) v3(44.88,154.57) v3(51.11,155.18) v3(51.11,154.29) v3(52.2,156.45) v3(52.22,155.23) v3(53.09,156.45) v3(53.11,155.23) v3(53.24,154.35) v3(53.98,156.45) v3(54.13,155.23) v3(54.13,154.35) v3(55.02,154.35) v3(55.14,155.23) v3(56.44,158.62) v3(56.44,157.73) v3(56.4,156.77) v3(57.31,158.62) v3(57.31,157.73) v3(57.26,156.82) v3(58.19,158.61) v3(58.19,157.72) v3(59.08,158.61) v3(59.08,157.72) v6(44.26,151.39) v6(44.26,150.74) v6(45.14,142.81) v6(45.14,142.25) v6(45.14,141.47) v6(45.14,140.91) v6(45.14,140.15) v6(45.14,139.59) v6(45.14,138.96) v6(45.14,138.4) v6(45.39,144.37) v6(45.39,143.6) v6(45.39,133.21) v6(45.83,150.74) v6(45.83,150.09) v6(45.83,149.43) v6(45.83,147.49) v6(45.83,146.84) v6(46.15,137.05) v6(46.15,136.29) v6(46.15,135.52) v6(46.15,134.89) v6(46.15,134.25) v6(46.26,133.22) v6(46.41,142.81) v6(46.41,142.25) v6(46.41,141.47) v6(46.41,140.91) v6(46.41,140.15) v6(46.41,139.59) v6(46.41,138.96) v6(46.41,138.4) v6(46.62,150.74) v6(46.62,150.09) v6(46.62,149.43) v6(46.62,147.49) v6(46.62,146.84) v6(46.66,145.25) v6(46.66,144.49) v6(46.66,143.73) v6(47.21,133.22) v6(48.11,133.24) v6(48.19,150.74) v6(48.19,150.09) v6(48.19,149.43) v6(48.19,147.48) v6(48.19,146.83) v6(48.98,150.74) v6(48.98,150.09) v6(48.98,149.43) v6(48.98,147.48) v6(48.98,146.83) v6(49.33,137.05) v6(49.33,136.29) v6(49.33,135.52) v6(49.33,134.89) v6(49.33,134.25) v6(49.95,133.22) v6(50.56,150.74) v6(50.56,150.09) v6(50.56,149.43) v6(50.56,147.48) v6(50.56,146.83) v6(50.98,145.25) v6(50.98,144.49) v6(50.98,143.73) v6(51.34,150.74) v6(51.34,150.09) v6(51.34,149.43) v6(51.34,147.48) v6(51.34,146.84) v6(51.26,142.81) v6(51.26,142.25) v6(51.26,141.47) v6(51.26,140.91) v6(51.26,140.27) v6(51.26,139.71) v6(51.26,139.08) v6(51.26,138.52) v6(51.77,133.22) v6(52.5,144.49) v6(52.5,143.73) v6(52.7,133.22) v6(52.76,142.81) v6(52.76,142.25) v6(52.76,141.47) v6(52.76,140.91) v6(52.76,140.27) v6(52.76,139.71) v6(52.76,139.08) v6(52.76,138.52) v6(52.76,137.05) v6(52.76,136.29) v6(52.76,135.52) v6(52.76,134.89) v6(52.76,134.25) v6(52.92,150.74) v6(52.92,150.09) v6(52.92,149.43) v6(52.92,147.48) v6(52.92,146.84) v6(53.61,133.22) v6(53.71,150.74) v6(53.71,150.09) v6(53.71,149.43) v6(53.71,147.48) v6(53.71,146.84) v6(55.91,136.09) v6(55.91,135.53) v6(55.91,134.97) v6(55.91,134.36)
+VTT_DDR: length 67.2
  TOP w0.305: C1701.1 99.8,66.57 99.88,66.49 CON1700.258 99.88,63.62 v2(100.13,63.37) ; CON1600.258 99.88,76.24 100.2,75.91 100.84,75.91 101.32,76.39 101.32,80.36 100.77,80.91 97.26,80.91 v2(96.85,81.32)
  TOP w1.524: 106.26,57.37 110.23,57.37 110.77,57.91 116.92,57.91 117.72,57.11 126.03,57.11 126.67,57.75 127.43,57.75
  BOTTOM w0.305: v2(99.77,67.84) 98.13,67.84 97.88,68.1 CON1601.258 ; CON1701.258 97.88,55.96 96.99,55.07 C1819.1 C1700.1
  BOTTOM w0.508: v2(99.77,67.84) 99.77,68.39 101.72,70.35 ; C1601.1 C1600.1 C1809.1 C1818.1 ; 102.58,70.61 102.59,70.59 102.59,67.34 100.13,64.88 v2(100.13,63.37) ; v2(96.85,81.32) 97.61,81.32 100.13,78.8 100.13,74.26
  vias: v1(127.74,58.51) v2(96.42,54.12) v2(97.05,54.12)
A_DVDD: length 9.1
  TOP w0.229: U3600.1 22.63,67.31 22.91,67.02 22.91,66.36 23.04,66.24
  TOP w0.254: 23.33,65.59 23.04,65.87 23.04,66.24
  TOP w0.457: C3623.1 24.33,62.48 24.33,63.6 ; 23.33,65.59 23.75,65.17 23.75,64.84 24.33,64.26 24.33,63.6 ; 24.33,63.6 C3624.1
  TOP w0.508: R3605.2 24.47,60.76 v1(24.44,60.8) 24.17,61.06 C3623.1
AC_IN_OC: length 131.5
  TOP w0.102: U8800.5 220.67,29.41 218.95,31.13 R8808.2 R8806.1 217.84,32.04 217.84,32.81 v1(217.97,32.94) 218.47,33.44 218.47,34.72 217.97,35.22 R8815.1 217.73,34.72 v2(217.85,34.6) ; U3001.120 123.14,40.35 121.92,41.57 120.07,41.57 118.11,39.62 118.11,35.45 119.76,33.8 119.76,32.61 v2(120.07,32.3)
  IN3 w0.102: v2(120.07,32.3) 120.47,32.71 122.43,32.71 123.99,31.15 144.43,31.15 144.91,30.67 154.21,30.67 155.32,29.56 160.63,29.56 161.56,28.63 166.09,28.63 167.02,27.7 177.48,27.7 177.56,27.78 195.98,27.78 196.66,28.46 198.94,28.46 199.36,28.87 199.47,28.87 200.15,29.56 200.15,30.19 200.86,30.9 203.83,30.9 205.2,29.54 206.23,29.54 206.96,30.27 207.29,30.27 209.34,32.32 211.28,32.32 213.57,34.6 v2(217.85,34.6)
ACDRV: length 5.3
  TOP w0.279: v1(220.32,30.64) 221.17,29.8 U8800.4
  TOP w0.508: v1(220.32,30.64) 221.16,31.48 221.16,32.19 R8803.1 220.81,32.44 220.52,32.73 R8816.2
ACG: length 308.2
  TOP w0.508: Q8801.4 10.89,114.44 10.26,113.81 C8800.2 9.27,113.81 8.89,114.19 C8801.1 8.89,115.36 9.32,115.79 9.32,119.39 9.83,119.9 Q8802.4 12.5,119.9 12.52,119.93 v1(15.01,119.93) 15.11,119.83 20.65,119.83 23.55,116.93 23.55,114.08 26.44,111.19 27.26,111.19 29.16,109.29 29.16,106.19 30.62,104.73 30.62,96.3 v2(30.61,96.29) ; v2(220.69,34.48) 220.9,34.26 R8803.2
  IN1 w0.508: v2(96.04,33.84) 96.98,32.89 104.93,32.89 111.62,26.19 134.94,26.19 135.59,26.84 152.45,26.84 155.69,23.6 178,23.6 178.26,23.35 178.31,23.35 178.33,23.33 199.78,23.33 203.97,27.52 204.54,27.52 205.16,28.14 205.36,28.14 206.16,28.93 207.4,28.93 208.05,29.58 208.74,29.58 209.24,29.58 210.65,28.18 211.37,28.18 212.33,27.22 215.48,27.22 219.18,30.92 219.18,32.79 220.69,34.29 v2(220.69,34.48)
  IN3 w0.508: v2(30.61,96.29) 30.81,96.49 32.56,96.49 34.21,94.84 34.21,90.26 35.1,89.37 35.1,87.6 32.94,85.44 32.94,78.33 35.23,76.04 35.23,68.67 35.22,68.66 35.22,66.63 38.58,63.28 38.58,60.81 39.06,60.32 39.06,57.95 39.98,57.03 39.98,56.15 41.83,54.31 48.86,54.31 51.84,51.33 90.21,51.33 93.47,48.06 v2(93.47,47.6)
  BOTTOM w0.508: v2(96.04,33.84) 97.05,34.85 97.05,43.12 93.47,46.7 v2(93.47,47.6)
ACPRESENT_EC: length 7.9
  TOP w0.102: U3001.16 119.12,46.04 119.25,46.17 119.25,48.43 118.9,48.77 118.9,49.39 118.83,49.46 118.83,49.79 118.92,49.88 118.92,51.03 118.76,51.2 R3037.2 118.42,52.1 v1(118.15,52.36)
AD_IINP: length 132.7
  TOP w0.102: v2(111.48,29.1) 112.22,29.84 112.22,31.03 112.5,31.31 112.93,31.31 113.12,31.12 U3001.66 ; SR8800.1 C8831.1 C8815.2 215.57,29.96 215.57,31.04 216.24,31.71 216.24,31.87 217.75,33.38 217.75,33.73 v2(217.95,33.92)
  IN1 w0.102: v2(111.48,29.1) 113.37,27.21 134.53,27.21 135.17,27.86 156.97,27.86 157.6,27.22 175.82,27.22 178.68,24.36 192.95,24.36 195.35,26.76 202.64,26.76 203.8,27.92 204.37,27.92 204.99,28.54 205.19,28.54 205.99,29.34 206.1,29.34 206.78,30.02 210.21,30.02 211.44,31.24 214.75,31.24 217.43,33.92 v2(217.95,33.92)
  BOTTOM w0.102: U8801.1 221.17,37.07 221.03,36.92 221.03,35.15 221.29,34.89 221.29,34.38 220.85,33.95 v1(218.69,33.95) 218.67,33.92 v2(217.95,33.92)
ALERT#: length 2.5
  TOP w0.102: v1(11.54,180.8) 11.44,180.9 v2(10.89,180.9)
  BOTTOM w0.102: R8013.1 10.96,180.97 v2(10.89,180.9) 11.07,180.73 U8000.44
ALL_SYSTEM_PWRGD: length 60.7
  TOP w0.102: U9201.2 144.35,49.8 144.68,50.13 144.68,50.79 144.18,51.3 D9202.2 143.36,52.21 143.1,52.47 143.1,54.07 142.68,54.49 141.12,54.49 140.03,55.57 T9203.1 138.91,54.81 138.91,53.59 138.16,52.83 136.48,52.83 136.23,52.58 136.23,52.15 135.35,51.28 135.35,49.31 135.06,49.02 U9200.4 134.72,48.62 134.86,48.48 SR9204.1 134.86,46.62 v2(135.01,46.46) ; U3001.68 113.92,31.08 113.63,31.37 113.63,33.1 v2(114.31,33.77)
  IN2 w0.102: v2(128.55,31.79) 122.62,31.79 121.91,31.08 120.04,31.08 119.25,31.87 116.07,31.87 114.31,33.63 v2(114.31,33.77)
  BOTTOM w0.102: v2(135.01,46.46) 134.36,46.46 132.99,45.1 132.99,44.51 132.74,44.26 132.74,43.92 132.91,43.74 132.94,43.7 132.94,43.67 132.94,40.21 130.11,37.38 130.11,33.35 v2(128.55,31.79)
AMP_EN: length 181.9
  TOP w0.089: U3001.104 125.93,33.95 125.54,34.35
  TOP w0.102: v2(119.06,37.36) 119.8,36.61 120.82,36.61 121.22,36.21 123.11,36.21 124.98,34.35 125.54,34.35 ; v1(12.42,88.36) 12.42,87.97 v2(12.76,87.62)
  IN3 w0.102: v2(119.06,37.36) 119.06,37.2 118.79,36.92 112.07,36.92 111.68,36.54 108.26,36.54 107.53,37.26 82.12,37.26 81.68,37.71 43.04,37.71 37.36,43.38 37.36,44.39 34.8,46.96 34.8,53.68 33.12,55.35 33.12,56.05 28.98,60.19 28.98,61.31 28.79,61.5 28.79,63.08 29.36,63.64 29.36,66.74 27.48,68.62 27.48,80.25 26.98,80.75 26.98,81.04 21.19,86.83 20.9,86.83 20.7,87.04 13.35,87.04 v2(12.76,87.62)
  BOTTOM w0.102: v1(118.31,36.69) 118.39,36.69 v2(119.06,37.36) ; CON6700.15 6.69,68.75 5.45,69.98 5.45,79.28 6.17,80 6.17,81.06 6.96,81.85 6.96,82.17 9.7,84.91 11.71,84.91 12.76,85.97 v2(12.76,87.62)
AMP_G0: length 145.8
  TOP w0.102: v2(119.99,35.73) 119.99,34.74 120.6,34.13 120.6,33.78 121.26,33.11 122.6,33.11 124.32,31.39 U3001.94 ; v2(7.32,62.78) 7.32,63.22 v1(7.56,63.46)
  IN2 w0.102: v2(119.99,35.73) 119.63,36.09 117.32,36.09 117.32,36.08 110.9,36.08 110.14,35.32 107.1,35.32 106.57,35.84 97.89,35.84 97.15,36.58 49.52,36.58 48.61,35.67 40.67,35.67 37.72,38.62 37.72,39.55 27.41,49.87 27.41,54 23.7,57.7 23.7,59.59 21.7,61.58 19.46,61.58 18.95,62.1 12.41,62.1 12.14,62.37 7.72,62.37 v2(7.32,62.78)
  BOTTOM w0.102: v2(7.32,62.78) 7.15,62.95 7.15,66.88 7.52,67.25 CON6700.12
AMP_G1: length 146.9
  TOP w0.102: U3001.95 124.72,31.28 122.68,33.32 121.35,33.32 120.8,33.86 120.8,34.54 120.62,34.72 v2(120.62,35.78)
  IN2 w0.102: v2(7.95,62.79) 7.95,63.09 8.1,63.24 10.25,63.24 10.43,63.06 11.74,63.06 12.5,62.3 19.04,62.3 19.55,61.79 21.79,61.79 23.9,59.67 23.9,57.79 27.64,54.06 27.64,49.93 37.95,39.61 37.95,38.68 40.75,35.87 48.52,35.87 49.44,36.79 97.23,36.79 97.97,36.05 106.66,36.05 107.18,35.52 110.05,35.52 110.82,36.29 117.23,36.29 117.24,36.29 120.12,36.29 v2(120.62,35.78)
  BOTTOM w0.102: v1(11.86,66.56) 10.98,66.56 10.79,66.75 CON6700.11 7.89,66.75 7.63,66.49 7.63,63.35 7.95,63.04 v2(7.95,62.79)
AMP_SPK_LN: length 29.2
  BOTTOM w0.762: 15.14,87.88 15.14,88.51 17.12,90.49 17.12,96.07 18.93,97.87 v1(18.93,101.74) 18.93,104.35 13.38,109.9 13.38,113.18
AMP_SPK_LP: length 29.6
  BOTTOM w0.762: 12.36,113.61 12.36,109.48 17.91,103.93 v1(17.91,103.77) 17.91,98.29 16.11,96.49 16.11,90.91 14.13,88.93 14.13,87.88
AMP_SPK_RN: length 27
  BOTTOM w0.762: 14.66,112.78 14.66,110.46 20.2,104.92 v1(20.2,103.77) 20.2,97.34 18.39,95.54 18.39,89.97 17.61,89.18
AMP_SPK_RP: length 28.9
  BOTTOM w0.762: 15.67,113.49 15.67,110.88 21.21,105.34 v1(21.21,101.74) 21.21,96.92 19.41,95.12 19.41,89.55 18.62,88.76 18.62,88
AMP_WOF_LN: length 4.9
  BOTTOM w0.508: L3703.2 195.43,32.22 195.38,32.17 C3707.1 v1(193.35,32.17) 193.29,32.17 192.32,31.2 CON3700.3
AMP_WOF_LP: length 3.9
  BOTTOM w0.508: CON3700.4 193.57,30.98 193.98,31.39 C3708.1 195.62,31.39 195.85,31.16 L3704.2
AMP_WOF_RN: length 7.5
  BOTTOM w0.508: L3701.2 193.51,35.2 C3705.1 191.82,35.2 191.59,34.97 191.59,33.74 191.69,33.64 v1(191.69,33.39) 191.69,32.21 191.07,31.59 CON3700.2
AMP_WOF_RN_R: length 5.4
  BOTTOM w0.229: 197.54,33.3 197.57,33.26 197.6,33.26
  BOTTOM w0.254: U3700.5 198.34,32.52 197.6,33.26
  BOTTOM w0.508: 197.54,33.3 196.98,33.85 196.98,34.28 v1(196.44,34.82) 196.44,34.84 196.27,35.02 195.25,35.02 195.12,34.89 L3701.1
AMP_WOF_RP: length 9.1
  BOTTOM w0.508: 192.3,35.96 191.31,35.96 190.86,35.5 v1(190.86,35.43) 190.83,35.4 190.83,33.43 190.91,33.35 190.91,32.58 189.96,31.63 189.96,31.13 189.82,31 CON3700.1 ; 192.3,35.96 193.49,35.96 L3702.2 ; 192.3,35.96 C3706.1
AMP_WOF_RP_R: length 6
  BOTTOM w0.254: v1(197.97,33.98) 198.34,33.6 198.34,33.2 198.57,32.97 U3700.6
  BOTTOM w0.508: v1(197.97,33.98) 197.97,34.71 196.77,35.91 195.54,35.91 L3702.1
ANALOG_INL: length 4
  TOP w0.203: v2(17.32,73.93) 16.96,73.93 16.7,73.67 16.7,73.15 17.1,72.75 U3600.24
  BOTTOM w0.203: C3710.1 17.58,74.18 v2(17.32,73.93) 17.06,73.93 16.62,74.37 v1(16.62,74.58)
ANALOG_INL_C: length 2
  BOTTOM w0.203: R3704.1 C3710.2 17,75.95 v1(16.6,75.95)
ANALOG_INL_CR: length 4.5
  BOTTOM w0.203: v1(15.62,78.2) 15.87,78.45 C3703.2 17.82,78.2 17.82,77.27 R3704.2 17.25,77.03 17.12,76.91 R3712.1
ANALOG_INR: length 3
  TOP w0.203: v2(17.34,73.24) 17.5,73.08 U3600.23
  BOTTOM w0.203: v2(17.34,73.24) 17.75,73.24 18.59,74.08 C3704.1
ANALOG_INR_C: length 1.9
  BOTTOM w0.203: v1(19.59,75.07) 19.29,75.38 C3704.2 R3700.1
ANALOG_INR_CR: length 4
  BOTTOM w0.203: C3702.2 18.2,78.06 18.2,77.42 R3700.2 R3711.1 19.87,77.03 20.35,76.54 v1(20.62,76.54)
BAT: length 31.8
  BOTTOM w0.508: CON2800.1 246,48.21 244.75,49.46 244.75,52.93 243.28,54.4 243.28,55.85 242.76,56.37 234.91,56.37 234.44,55.89 232.59,55.89 232.13,56.35 v1(231.32,56.35) 231.19,56.23 R2811.1
BAT1_IN_OC#: length 5.8
  TOP w0.102: U3001.124 128.45,41.95 v1(128.65,42.16) 128.68,42.18 129.39,42.18 R3065.2 130.1,41.47 131.24,41.47 131.5,41.72 JP9000.1
BAT_LEARN: length 105.3
  TOP w0.102: v2(206.88,29.54) 207.68,28.75 208.71,28.75 209.04,28.42 v1(210.7,28.42) 211.63,28.42 213.66,30.45 SR8807.2 ; v2(118.44,32.28) 118.58,32.28 120.36,30.5 120.55,30.5 120.72,30.32 U3001.85
  IN3 w0.102: v2(206.88,29.54) 206.68,29.34 205.11,29.34 203.75,30.7 200.97,30.7 200.58,30.32 200.58,29.61 199.64,28.67 199.44,28.67 199.03,28.25 196.75,28.25 196.07,27.58 177.64,27.58 177.56,27.5 166.87,27.5 165.94,28.43 161.43,28.43 160.51,29.35 155.23,29.35 154.12,30.47 144.82,30.47 144.35,30.94 119.78,30.94 v2(118.44,32.28)
BATT_IN: length 69.7
  TOP w0.102: v2(245.51,20.25) 245.36,20.1 243.32,20.1 v1(243,19.78)
  IN4 w0.102: v2(245.51,20.25) 245.63,20.36 246.84,20.36 247.98,21.5 247.98,23.93 247.98,23.93 247.98,24.27 247.98,24.27 247.98,26.08 249.51,27.61 254.81,27.61 257.37,30.17 257.52,30.17 257.76,30.41 257.76,34.21 254.1,37.87 254.1,51.85 255.99,53.74 255.99,53.76 257.99,55.75 v2(257.99,55.97)
  BOTTOM w0.102: CON6000.4 240,21.91 240.72,21.19 242.05,21.19 243.14,20.1 245.36,20.1 v2(245.51,20.25) ; Q6001.3 256.01,65.67 258.33,63.36 v1(258.33,61.33) 258.75,60.91 258.75,56.86 257.99,56.1 v2(257.99,55.97)
BKLT_EN: length 27
  TOP w0.102: v2(34.04,181.83) 34.34,182.14 35.26,182.14 35.49,182.37 R4594.2 ; v2(42.9,182.2) 43.49,182.79 43.49,182.9 R4525.2 43.87,183.53 42.55,183.53 42.29,183.79 R4527.1 42.09,183.91 D4502.3 41.58,182.85 41.2,182.47 D4503.1
  IN1 w0.102: v2(42.9,182.2) 42.64,181.94 38.32,181.94 37.41,181.03 37.41,180.93 37.13,180.64 35.16,180.64 34.93,180.88 34.93,181.53 34.63,181.83 v2(34.04,181.83)
  BOTTOM w0.102: v1(48.9,181.17) 48.49,181.58 44.39,181.58 44.35,181.53 43.57,181.53 v2(42.9,182.2)
BOOT_C:
  vias: v1(69.29,172.41)
BP_PWRGD_RST#: length 19.9
  BOTTOM w0.102: v1(12.85,131.1) 12.83,131.08 10.45,131.08 10.18,131.35 XDP4400.41 7.98,131.35 7.79,131.16 7.65,131.16 7.49,131 7.14,131 6.75,130.61 6.75,130.01 6.59,129.85 6.59,129.4 6.75,129.24 6.75,125.73 7.54,124.93 7.54,121.86 C4401.1 R4415.1 8.28,120.54 8.48,120.34 8.48,119.36 8.97,118.87 R4412.2
BPM_N2: length 1.7
  TOP w0.102: T0700.1 23.65,147.46 v6(23.86,147.68)
  BOTTOM w0.102: v6(23.86,147.68) 23.86,147.68 24.19,147.34 U0300.BM31
BPM_N3: length 1.8
  TOP w0.102: v6(20.63,146.26) 20.82,146.45 20.93,146.45 T0701.1
  BOTTOM w0.102: U0300.BT30 21.13,146.5 20.89,146.26 v6(20.63,146.26)
BT_DISABLE#: length 150.3
  TOP w0.102: R5300.2 248.59,94.49 v2(248.59,94.04) ; v1(167.77,34) 167.77,34.13 168.32,34.69 v2(168.71,34.69)
  IN2 w0.102: v2(248.59,94.04) 247.98,93.43 247.98,93.24 247.6,92.86 235.43,92.86 233.75,94.54 230.61,94.54 229.95,93.87 226.25,93.87 225.45,93.08 225.45,89.79 224.37,88.71 222.24,88.71 221.25,87.72 216.32,87.72 211.79,83.18 211.79,80.65 212.98,79.46 212.98,68.48 216.81,64.65 216.81,62.43 213.8,59.42 213.8,51.93 212.09,50.23 212.09,49.04 210.81,47.75 210.81,46.65 210.39,46.23 210.39,42.68 205.57,37.86 205.57,37.33 204.46,36.22 202.17,36.22 201.86,35.91 200.22,35.91 199.49,35.18 196.69,35.18 194.37,32.86 194.36,32.86 193.75,32.25 192.13,32.25 190.55,33.83 178.28,33.83 178.23,33.88 169.52,33.88 v2(168.71,34.69)
  BOTTOM w0.089: 169.06,37.73 170.01,38.68 170.01,40.45 170.03,40.47 170.03,40.48 170.36,40.81 170.36,41.28 170.47,41.39 170.47,41.62 170.46,41.63 170.46,41.9 170.71,42.15 U2000.AC43
  BOTTOM w0.102: v2(168.71,34.69) 168.29,35.11 168.29,36.35 R2141.1 168.71,37.38 169.06,37.73 ; v2(248.59,94.04) 249,93.63 CON5300.54
BVREF_CA_RC: length 1.8
  TOP w0.305: R0511.1 v1(13.64,130.08) C0502.2
C_CC1: length 45.5
  TOP w0.102: v2(251.69,48.57) 251.38,48.89 251.17,48.89 250.7,49.36 C1223.1 250.37,49.37 250.11,49.62 250.11,50.51 249.43,51.19 249.43,51.69 248.06,53.06 245.04,53.06 244.68,52.7 U1201.L9 ; CON1201.A5 264.14,25.3 v2(263.7,24.86) ; v1(259.82,27.2) 259.89,27.27 v2(259.89,28.1)
  IN4 w0.102: v2(259.89,28.1) 260.67,28.1 263.7,25.06 v2(263.7,24.86) ; v2(256.72,30.57) 256.34,30.95 256.34,34.97 253.66,37.64 253.66,46.9 251.98,48.57 v2(251.69,48.57)
  BOTTOM w0.102: v2(256.72,30.57) 255.96,29.81 255.96,29.46 256.08,29.33 U1207.9 257.06,29.33 257.1,29.29 259.17,29.29 259.89,28.57 v2(259.89,28.1)
C_CC2: length 53.5
  TOP w0.102: U1201.L10 244.64,53.2 244.98,53.54 248.16,53.54 248.61,53.08 249.77,53.08 249.86,53.08 249.88,53.08 250.13,52.83 250.13,52.81 250.13,52.81 v2(250.13,51.57) 250.23,51.57 C1224.1 ; v1(257.61,29.15) 257.75,29.15 258.16,29.56 v2(258.16,29.73)
  IN4 w0.102: v2(258.16,29.73) 258.16,30.24 260.99,33.07 266.63,33.07 269.29,30.41 269.29,27.37 268.77,26.85 CON1201.B5 ; v2(257.35,30.57) 257.1,30.83 257.1,34.5 253.87,37.73 253.87,46.99 250.15,50.71 250.15,51.55 v2(250.13,51.57)
  BOTTOM w0.102: v2(257.35,30.57) 256.85,30.07 256.85,29.94 257.05,29.73 U1207.1 v2(258.16,29.73)
C_USB_BN: length 26.5
  TOP w0.114: U1201.L7 244.49,51.57 244.67,51.39 244.8,51.39 245.09,51.68 247.5,51.68 v2(247.96,51.22)
  BOTTOM w0.114: 254.96,37.43 254.96,37.79 254.36,38.39 254.36,50.08 252.25,52.18 249.64,52.18 249.07,51.62 248.46,51.62 248.39,51.56 248.39,51.29 248.32,51.22 247.96,51.22 v2(247.96,51.22) ; 254.96,37.43 v1(254.73,37.43) ; 254.96,37.43 254.96,36.8 254.83,36.67 254.75,36.67 254.62,36.54 RN1201.4
C_USB_BN_CON: length 21.2
  BOTTOM w0.114: CON1201.B7 267.29,25.86 264.36,25.86 ; RN1201.3 254.84,34.22 254.84,33.95 253.69,32.79 253.69,29.54 255.93,27.3 257.38,27.3 U1207.4 257.52,27.3 258.01,27.3 258.3,27.02 261.77,27.02 262.93,25.86 264.36,25.86 ; v1(264.36,25.6) 264.36,25.86
C_USB_BP: length 26.5
  TOP w0.076: 244.89,51.94 244.23,51.94 U1201.K7
  TOP w0.114: 244.89,51.94 244.92,51.91 247.9,51.91 v2(247.96,51.86)
  BOTTOM w0.114: 254.59,39.44 254.59,50.18 252.35,52.42 249.54,52.42 248.98,51.86 v2(247.96,51.86) ; 254.59,39.44 254.59,38.49 255.19,37.89 255.19,36.33 RN1201.2 ; 254.59,39.44 v1(254.81,39.44)
C_USB_BP_CON: length 21
  BOTTOM w0.114: 261.57,27.25 258.39,27.25 258.11,27.54 256.59,27.54 U1207.7 256.4,27.54 256.02,27.54 253.92,29.64 253.92,32.69 255.08,33.85 255.08,34.22 255.31,34.45 RN1201.1 ; 261.57,27.25 261.87,27.25 263.03,26.09 267.15,26.09 267.5,26.44 CON1201.B6 ; 261.57,27.25 v1(261.57,27.48)
C_USB_TN: length 27.6
  TOP w0.114: U1201.L6 245.95,51.2 246.83,50.32 247.05,50.32 247.23,50.49 247.23,50.49 v2(247.32,50.59)
  BOTTOM w0.114: 253.5,41.24 253.5,42.22 253.75,42.47 253.75,47.71 251.12,50.34 247.57,50.34 v2(247.32,50.59) ; 253.5,41.24 253.5,33.77 252.64,32.9 252.64,32.52 253.01,32.14 RN1202.2 ; 253.5,41.24 v1(253.73,41.24)
C_USB_TN_CON: length 16.5
  TOP w0.114: CON1201.A7 265.9,26.3 265.64,26.04 261.77,26.04 v2(261.42,26.38)
  BOTTOM w0.114: v1(260.2,26.31) 260.2,26.06 ; 260.2,26.06 261.1,26.06 v2(261.42,26.38) ; 260.2,26.06 258.44,26.06 257.88,26.63 256.6,26.63 U1207.6 256.39,26.63 255.71,26.63 252.68,29.66 252.68,29.93 RN1202.1
C_USB_TP: length 27.6
  TOP w0.076: U1201.K6 244.23,50.95 244.74,50.95
  TOP w0.114: v2(247.32,49.95) 247.19,50.08 246.73,50.08 245.85,50.96 244.74,50.96 244.74,50.95
  BOTTOM w0.114: v1(253.3,42.94) 253.52,42.94 ; 253.52,42.94 253.52,47.62 251.03,50.11 247.47,50.11 v2(247.32,49.95) ; 253.52,42.94 253.52,42.56 253.27,42.32 253.27,33.87 252.4,33 252.4,32.1 RN1202.4
C_USB_TP_CON: length 16.5
  TOP w0.114: CON1201.A6 261.47,25.8 v2(261.42,25.75)
  BOTTOM w0.114: 258.62,25.83 261.34,25.83 v2(261.42,25.75) ; 258.62,25.83 258.35,25.83 257.78,26.39 257.5,26.39 U1207.5 257.39,26.39 255.61,26.39 252.44,29.57 252.44,30.02 RN1202.3 ; 258.62,25.83 v1(258.62,25.6)
CA_DET: length 30.5
  TOP w0.102: Q7201.1 245.9,98.71 v2(245.92,98.73) 245.94,98.71 246.87,98.71 247.32,99.15 R4628.2 R4609.1
  IN2 w0.102: CON4601.13 258.72,116.45 257.76,115.49 257.76,111.24 249.86,103.34 247.83,103.34 247.32,102.84 247.32,99.41 246.62,98.71 245.94,98.71 v2(245.92,98.73)
  BOTTOM w0.102: v2(245.92,98.73) 245.92,98.72 v1(245.92,98.04)
CATERR#: length 1.2
  TOP w0.102: T0745.1 24.16,146.88 24.14,146.89 v6(23.87,146.89)
  BOTTOM w0.102: U0300.BM30 23.87,146.82 v6(23.87,146.89)
CFG_RCOMP: length 5.2
  BOTTOM w0.254: U0300.BT25 19.71,142.56 v1(19.58,142.69) 19.45,142.82 17.13,142.82 R0742.1
CGH_SRN: length 8.6
  TOP w0.203: SR8805.2 227.32,24.52 v1(226.75,23.94) 226.54,24.15 226.26,24.15 225.64,23.53 224.5,23.53 223.47,24.55 221.85,24.55 221.17,25.24 U8800.12
CGH_SRP: length 8.5
  TOP w0.102: v1(224.21,24.55) 224.05,24.4
  TOP w0.203: U8800.13 221.67,25.17 221.98,24.86 223.6,24.86 224.63,23.83 225.48,23.83 226.12,24.48 226.61,24.48 227.73,25.6 SR8804.2
CHA_DIMM0_EVENT#: length 6.2
  TOP w0.102: v2(67.74,80.13) 67.62,80.13 66.88,79.39 CON1600.134
  BOTTOM w0.102: v2(67.74,80.13) v1(66.83,80.13) 66.65,80.31 C1619.1 R1600.2
CHA_DIMM1_EVENT#: length 21.6
  IN3 w0.102: v2(67.21,86.3) 66.95,86.04 v2(66.95,71.52)
  BOTTOM w0.102: v2(66.95,71.52) 66.7,71.26 66.18,71.26 64.88,69.96 CON1601.134 ; C1620.1 R1601.2 67.23,86.27 v2(67.21,86.3) v1(67.21,87)
CHB_DIMM0_EVENT#: length 9.7
  TOP w0.102: v2(64.8,55.72) 65.28,55.24 68.53,55.24 68.68,55.39 v2(71.43,55.39)
  BOTTOM w0.102: R1700.2 C1718.1 v2(71.43,55.39) ; v2(64.8,55.72) 64.88,55.8 CON1701.134
CHB_DIMM1_EVENT#: length 47.4
  TOP w0.102: v2(67.51,62.48) 67.28,62.7 66.95,62.7 66.88,62.78 CON1700.134
  IN1 w0.102: v2(67.51,62.48) 67.74,62.7 69.19,62.7 70.6,64.11 98.23,64.11 100.19,62.15 104.92,62.15 v2(106.37,63.59)
  BOTTOM w0.102: v2(106.37,63.59) 106.99,63.59 v1(107.25,63.33) 107.9,62.68 R1701.2 C1719.1
CHG_ACN: length 326.2
  TOP w0.203: v2(85.51,29.18) 84.44,30.25 84.44,38.75 71.8,51.39 51.6,51.39 48.64,54.35 33.19,54.35 32.37,55.16 32.37,56.7 28.47,60.61 28.47,63.08 30.24,64.85 30.24,70.88 29.47,71.65 28.66,72.46 28.66,76.1 29.64,77.07 29.64,83.73 29.62,83.74 29.62,93.16 31.45,94.98 31.45,104.99 30.07,106.36 30.07,109.46 27.58,111.95 26.76,111.95 24.31,114.4 24.31,117.44 21.15,120.6 16.67,120.6 16.22,121.05 12.67,121.05 11.78,121.94 4.55,121.94 ; 2.94,114.78 2.86,114.87 2.23,114.87 1.45,115.65 1.45,119.63 3.75,121.94 4.55,121.94 ; 4.55,121.94 v1(4.55,122.17) ; U8800.1 222.67,29.92 224.11,31.37 224.11,32.73 224.29,32.91 C8809.2 224.64,33.55 C8807.2 224.05,34.13 224.05,34.25 v2(223.82,34.49)
  IN1 w0.203: v2(223.82,34.49) 223.82,33.11 222.3,31.59 221.87,31.59 216.06,25.79 211.82,25.79 210.84,26.76 205.74,26.76 205.12,26.15 204.54,26.15 200.35,21.96 177.58,21.96 177.31,22.23 155.12,22.23 152.08,25.27 146,25.27 145.42,24.68 110.31,24.68 108.84,26.15 90.92,26.15 87.31,29.76 86.09,29.76 v2(85.51,29.18)
CHG_ACP: length 325.2
  TOP w0.203: v2(84.83,29.17) 84.1,29.9 84.1,38.66 71.67,51.09 51.47,51.09 48.52,54.04 33.06,54.04 32.07,55.04 32.07,56.58 28.16,60.48 28.16,63.2 29.94,64.98 29.94,70.76 29.41,71.28 28.36,72.34 28.36,76.23 29.33,77.2 29.33,83.61 29.32,83.62 29.32,93.29 31.14,95.11 31.14,104.86 29.77,106.23 29.77,109.33 27.45,111.65 26.63,111.65 24.01,114.27 24.01,117.23 20.95,120.29 16.54,120.29 16.09,120.74 12.55,120.74 11.66,121.63 6.27,121.63 ; JP8801.2 2.94,115.31 2.82,115.18 2.4,115.18 1.75,115.83 1.75,119.51 3.88,121.63 6.27,121.63 ; 6.27,121.63 v1(6.27,121.43) ; U8800.2 222.17,29.9 223.75,31.48 223.75,32.71 223.54,32.91 C8808.2 223.24,33.42 C8807.1 223.17,34.15 v2(223.17,34.5)
  IN1 w0.203: v2(84.83,29.17) 85.72,30.06 87.44,30.06 91.02,26.48 109.04,26.48 110.54,24.99 145.29,24.99 145.88,25.57 152.2,25.57 155.25,22.53 177.51,22.53 177.78,22.26 200.22,22.26 204.41,26.45 205,26.45 205.61,27.07 210.97,27.07 211.94,26.09 215.91,26.09 221.74,31.92 222.2,31.92 223.17,32.89 v2(223.17,34.5)
CHG_BST:
  vias: v1(224.43,26.84)
CHG_BST_R: length 2.3
  TOP w0.102: 227.38,28.95 227.38,29.48 v1(227.3,29.56)
  TOP w0.508: D8800.3 228.64,28.96 228.3,28.62 227.66,28.62
CHG_HG: length 10.8
  IN1 w0.762: v3(224.49,27.61) 224.49,26.48 229.67,21.3 v3(230.94,21.3)
  BOTTOM w0.508: T8800.1 223.83,28.28 v3(224.49,27.61)
CHG_LDO: length 21.8
  TOP w0.381: R8806.2 217.29,31.72 v2(217.29,32.35)
  TOP w0.508: v2(225.14,24.41) 225.45,24.73 C8821.1 ; D8800.2 D8800.1 228.13,26.64 225.86,26.64 225.45,26.23 C8821.1 ; C8821.1 225.08,26.12 224.05,26.12
  BOTTOM w0.508: v2(217.29,32.35) 217.95,31.69 218.53,31.69 219.12,31.11 219.12,30.57 v1(219.74,29.94) 219.74,28.21 220.36,27.6 222.86,27.6 225.14,25.32 v2(225.14,24.41)
CHG_LED_RED: length 263.4
  TOP w0.102: U3001.25 115.52,44.49 115.93,44.09 115.93,41.18 v2(115.66,40.91)
  IN2 w0.102: v2(46.53,182.21) 46.08,181.75 45.78,181.75 45.36,181.33 41.17,181.33 40.82,180.98 40.4,180.98 40.03,180.62 38.99,180.62 37.31,178.93 35.88,178.93 34.57,177.62 32.36,177.62 31.99,177.24 27.25,177.24 25.87,175.86 25.87,172.67 23.13,169.93 23.13,167.21 23.62,166.71 23.62,165.19 22.31,163.88 22.31,157.05 17.25,151.99 17.25,148.17 16.36,147.29 15.93,147.29 15.55,146.91 15.55,146.02 14.94,145.41 14.94,144.54 15.18,144.3 15.18,143.24 14.99,143.05 14.99,141.09 15.37,140.71 15.52,140.71 15.8,140.43 15.8,139.12 12.86,136.18 12.86,133.46 14.74,131.58 14.74,124.05 16.2,122.59 16.2,121.77 18.84,119.14 18.84,89.91 27.05,81.71 27.05,70.55 29.55,68.06 29.55,65.18 32.3,62.43 33,62.43 33.76,61.67 33.76,58.38 39.9,52.24 40.81,52.24 45.85,47.2 47.84,47.2 49.33,45.71 67.36,45.71 68.17,44.9 72.83,44.9 73.06,44.67 99.87,44.67 102.19,42.34 114.22,42.34 v2(115.66,40.91)
  BOTTOM w0.102: v1(115.99,40.27) 115.99,40.57 v2(115.66,40.91) ; CON5602.22 40.25,178.49 40.82,179.06 40.82,180.78 41.39,181.35 41.39,181.85 42.63,183.1 R5602.1 46.53,182.77 v2(46.53,182.21)
CHG_LED_RED_IO: length 19.1
  TOP w0.114: v2(173,172.98) PCON700.5 173,170.15 v1(173.19,169.96) ; v2(184.71,179.04) 184.7,179.03 CON402.22
  IN1 w0.102: v2(184.71,179.04) 183.2,177.53 176.77,177.53 173,173.76 v2(173,172.98)
CHG_LED_RED_LED: length 12.4
  TOP w0.114: v1(185.82,156.45) 185.55,156.72 CON1.4 185.55,159.09 185.01,159.63 181.88,159.63 180.62,158.36 180.07,158.36 179.96,158.47 179.96,159.47 LC801.1 179.32,160.11 LQ801.1
CHG_LED_YELLOW: length 262.1
  TOP w0.102: U3001.28 114.32,44.49 114.63,44.19 114.63,41.18 v2(114.9,40.91)
  IN2 w0.102: v2(45.92,182.21) 45.92,182.19 45.27,181.53 41.69,181.53 41.43,181.8 40.32,181.8 40.06,181.53 40.06,181.26 39.62,180.82 38.91,180.82 37.23,179.14 35.8,179.14 34.49,177.82 32.28,177.82 31.9,177.45 27.16,177.45 25.67,175.95 25.67,172.76 22.92,170.01 22.92,167.12 23.42,166.63 23.42,165.28 22.11,163.97 22.11,157.13 17.04,152.07 17.04,148.26 16.28,147.49 15.84,147.49 15.34,146.99 15.34,146.11 14.36,145.13 14.36,143.75 14.68,143.44 14.68,140.89 14.33,140.53 14.33,137.93 12.66,136.26 12.66,133.38 14.54,131.5 14.54,123.97 16,122.51 16,121.58 18.64,118.94 18.64,89.83 26.85,81.62 26.85,70.47 29.34,67.97 29.34,62.39 29.41,62.32 29.41,60.82 33.79,56.44 35.29,56.44 39.72,52.02 40.74,52.02 45.76,47 47.76,47 49.25,45.51 67.27,45.51 68.09,44.7 72.75,44.7 73,44.44 99.81,44.44 102.11,42.14 114.04,42.14 114.9,41.28 v2(114.9,40.91)
  BOTTOM w0.102: CON5602.23 40.75,178.61 41.05,178.91 41.05,180.57 41.69,181.21 41.69,181.84 42.52,182.68 45.46,182.68 v2(45.92,182.21) 46.36,181.78 46.7,181.78 46.94,182.02 46.94,182.03 R5601.1 ; v2(114.9,40.91) 114.77,41.04 v1(114.77,41.56)
CHG_LED_YELLOW_IO: length 20.5
  TOP w0.114: v2(183.95,179.04) 184.2,178.78 CON402.23 ; v2(172.5,172.5) PCON700.6 172.5,170.37 172.27,170.14 v1(172.27,168.41)
  IN1 w0.102: v2(172.5,172.5) 172.5,173.74 176.63,177.87 182.78,177.87 v2(183.95,179.04)
CHG_LED_YELLOW_LED: length 9.7
  TOP w0.114: CON1.3 186.05,158.41 186.71,159.07 189.67,159.07 190.5,159.89 v1(190.5,159.92) 190.5,161.54 LC802.1 LQ802.1
CHG_LG: length 18.6
  IN1 w0.762: v3(223.28,25.49) 223.28,18.8 230.18,11.89 v3(230.18,11.43)
  BOTTOM w0.508: v3(223.28,25.49) 223.31,25.45 223.31,25.19 224.21,24.3 T8801.1
CHG_LX: length 11
  IN1 w0.762: v3(225.72,28.48) 225.72,27.5 227.55,25.67 227.55,24.91 229.89,22.57 231.63,22.57 232.57,21.63 v3(232.57,21.3)
  vias: v1(224.56,28.62)
CHG_RC:
  vias: v1(231.57,17.57)
CHG_SRN_R: length 30.1
  TOP w0.203: JP8805.2 246.53,12.31 v2(246.05,12.79) ; v2(233.06,24.35) 233.35,24.64 233.35,24.73 233.12,24.96 232.66,24.96 C8823.2 232.16,24.81 230.18,24.81 230,24.63 C8826.2 229.58,24.3 229.36,24.52 SR8805.1
  IN1 w0.203: v2(233.06,24.35) 233.58,23.83 234.57,23.83 236.91,21.48 241.5,21.48 242.96,20.02 244.39,20.02 245.05,19.36 245.05,16.21 244.75,15.92 244.75,12.68 245.15,12.29 245.54,12.29 v2(246.05,12.79)
  BOTTOM w0.102: v1(232.82,23.54) 232.82,24.11 v2(233.06,24.35)
CHG_SRP_R: length 28.1
  TOP w0.203: v2(245.29,12.79) 245.15,12.65 JP8804.2 ; v2(233.73,24.35) 233.73,24.86 233.32,25.27 232.57,25.27 C8823.1 231.99,25.15 230.54,25.15 C8825.2 229.09,25.7 SR8804.1
  IN1 w0.203: v2(245.29,12.79) 245.07,13.01 245.07,15.75 245.38,16.06 245.38,19.5 244.55,20.33 243.09,20.33 241.6,21.81 237.04,21.81 234.69,24.16 233.92,24.16 v2(233.73,24.35)
  BOTTOM w0.102: v1(233.65,25.11) 233.65,24.43 v2(233.73,24.35)
CHG_VCC: length 269.8
  TOP w0.381: v2(29.4,97.39) 29.4,103.79 27.6,105.59 v1(27.6,105.96) 27.6,106.55 R8812.2
  IN1 w0.508: v2(218.32,32.41) 217.77,32.96 217.04,32.96 214.88,30.8 214.88,29.29 214.39,28.8 v2(213.27,28.8)
  IN3 w0.508: v2(96.96,33.84) 98.44,32.35 110.35,32.35 111.66,31.05 112.87,29.83 143.91,29.83 144.29,29.45 153.7,29.45 155.74,27.41 165.23,27.41 166.16,26.48 179.19,26.48 179.25,26.55 196.48,26.55 196.84,26.91 204.16,26.91 205.46,28.21 207.1,28.21 208.25,27.06 211.54,27.06 v2(213.27,28.8) ; v2(94.08,47.6) 94.08,48.31 90.46,51.94 52.1,51.94 49.07,54.97 43.06,54.97 41.73,56.3 41.59,56.3 39.69,58.2 39.69,60.57 39.19,61.06 39.19,63.54 35.87,66.87 35.87,71.47 36.63,72.23 36.63,75.53 33.58,78.58 33.58,85.18 35.74,87.34 35.74,89.88 34.85,90.77 34.85,95.22 32.56,97.5 29.52,97.5 v2(29.4,97.39)
  BOTTOM w0.508: v2(96.96,33.84) 97.66,34.54 97.66,43.37 94.08,46.96 v2(94.08,47.6) ; v2(218.32,32.41) 218.72,32.41 220.62,30.52 v2(224.03,30.52)
CHG_VCC_R: length 3.9
  TOP w0.254: D8801.3 23.77,110.01 23.77,110.23 v1(23.22,110.79)
  TOP w0.508: R8812.1 25.26,109.49 25.17,109.58 D8801.3
CK_24M_85OHM_BCK: length 6.8
  BOTTOM w0.114: U2000.G1 162.53,62.96 162.53,63.16 161.87,63.82 161.87,64.63 161.01,65.5 159.28,65.5 158.75,66.03 158.75,66.46 R2503.1
CK_24M_85OHM_BCK#: length 6.8
  BOTTOM w0.114: R2505.1 158.52,66.42 158.52,65.93 159.19,65.26 160.91,65.26 161.31,64.86 161.64,64.54 161.64,63.72 161.8,63.56 162.3,63.06 162.3,62.92 U2000.F1
CK_24M_BCK: length 186.3
  IN4 w0.089: v6(59.94,147.12) 60.21,146.85 60.21,146.77 60.89,146.09 61.34,146.09 61.62,145.82 61.62,142.92 62.16,142.38 63.6,142.38 64.31,141.66 66.67,141.66 67.38,142.38 69.56,142.38 70.54,141.4 70.54,140.3 71.55,139.29 73.96,139.29 75.2,140.53 76.71,140.53 79.1,138.15 79.1,123.79 83.38,119.51 83.38,113.15 105.88,90.65 105.88,83.92 107.84,81.96 107.84,79.46 108.99,78.3 108.99,78.28 109.06,78.22 109.06,76.4 108.09,75.43 108.09,56.03 109.75,54.37 115.6,54.37 116.63,55.4 118.96,55.4 119.87,56.32 130.57,56.32 132.59,58.34 140.45,58.34 142.87,60.75 147.3,60.75 147.81,60.24 150.9,60.24 155.8,65.13 155.8,67.43 158.42,70.06 v2(158.42,70.88)
  BOTTOM w0.076: U0300.E31 59.61,147.45 v6(59.94,147.12)
  BOTTOM w0.114: R2503.2 158.72,67.96 158.72,68.24 158.25,68.72 158.25,70.05 ; 158.25,70.05 158.25,70.71 v2(158.42,70.88) ; 158.25,70.05 v1(158.47,70.05)
CK_24M_BCK#: length 186.3
  IN4 w0.089: v6(60.59,147.12) 60.59,146.64 60.96,146.27 61.41,146.27 61.79,145.89 61.79,142.99 62.23,142.55 63.67,142.55 64.38,141.84 66.59,141.84 67.31,142.55 69.63,142.55 70.71,141.47 70.71,140.38 71.63,139.46 73.88,139.46 75.13,140.71 76.78,140.71 79.27,138.22 79.27,123.87 83.56,119.59 83.56,113.22 106.06,90.72 106.06,83.99 108.02,82.03 108.02,79.53 109.17,78.38 109.17,78.35 109.23,78.29 109.23,76.32 108.27,75.36 108.27,56.1 109.82,54.55 115.53,54.55 116.56,55.58 118.89,55.58 119.8,56.49 130.49,56.49 132.51,58.51 140.38,58.51 142.79,60.93 147.37,60.93 147.88,60.42 150.83,60.42 155.62,65.21 155.62,67.51 158.24,70.13 158.24,70.32 158.12,70.45 157.76,70.45 157.63,70.58 157.63,70.75 157.76,70.88 v2(157.79,70.88)
  BOTTOM w0.076: v6(60.59,147.12) 60.59,147.45 60.53,147.51 U0300.D31
  BOTTOM w0.114: v1(157.79,68.75) 158.01,68.75 ; 158.01,68.75 158.01,68.62 158.49,68.14 158.49,67.95 R2505.2 ; 158.01,68.75 158.01,70.65 v2(157.79,70.88)
CK_100M_85OHM_BCK: length 9.1
  BOTTOM w0.102: 162.99,63.25 162.99,62.59 U2000.G2
  BOTTOM w0.114: 160.66,66.58 160.21,66.58 159.75,67.04 159.75,68.86 R2500.1 ; 160.66,66.58 161.06,66.58 162.1,65.53 162.1,64.14 162.99,63.25 ; 160.66,66.58 v1(160.66,66.36)
CK_100M_85OHM_BCK#: length 9
  BOTTOM w0.102: U2000.H2 163.22,63.36 163.16,63.42
  BOTTOM w0.114: v1(160.21,68.09) 159.99,68.09 ; 159.99,68.09 159.99,68.72 160.1,68.83 160.23,68.83 R2501.1 ; 159.99,68.09 159.99,67.14 160.31,66.81 161.15,66.81 162.34,65.63 162.34,64.24 163.16,63.42
