# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQS5: length 84.9
  TOP w0.159: v2(83.24,71.26) 83.92,71.95 83.92,74.96 85.38,76.41 CON1600.200
  IN1 w0.076: 57.51,115.2 57.51,116.08 51.38,122.2 51.38,122.38 v2(51.62,122.62)
  IN1 w0.114: 57.51,115.2 57.51,114.43 63.67,108.27 64.05,108.27 64.3,108.53 64.77,108.53 65.03,108.27 66.06,108.27 71.06,103.27 72.31,103.27 72.67,102.91 86,89.58 86,85.12 86.55,84.57 86.55,78.54 85.72,77.71 85.72,76.87 83.99,75.13 83.99,72.77 84.14,72.62 84.14,72.17 v2(83.24,71.26)
  BOTTOM w0.076: v2(51.62,122.62) 51.21,122.62 49.47,124.35 49.47,125.92 49.78,126.22 49.81,126.22 U0300.V3
  BOTTOM w0.159: v2(83.24,71.26) 83.49,71.26 83.59,71.16 83.59,70.88 83.49,70.78 83.14,70.78 83.06,70.7 83.06,70.3 83.38,69.99 CON1601.200
M_CHA_DQS5#: length 84.9
  TOP w0.159: CON1600.198 84.88,76.28 83.66,75.07 83.66,72.63 83.52,72.48 82.91,72.48 82.81,72.38 82.81,72 82.91,71.9 v2(83.24,71.9)
  IN1 w0.076: v7(51.22,123.2) 51.22,122.13 57.34,116.01 57.34,115.3 57.32,115.28 57.32,115.23 57.3,115.21 57.3,115.2
  IN1 w0.114: 57.3,115.2 57.3,114.35 63.58,108.07 64.13,108.07 64.39,108.32 64.69,108.32 64.94,108.07 65.97,108.07 70.98,103.06 72.22,103.06 72.52,102.76 85.79,89.5 85.79,85.04 86.35,84.48 86.35,78.63 85.52,77.8 85.52,76.95 83.78,75.22 83.78,72.68 83.94,72.53 83.94,72.25 83.58,71.9 v2(83.24,71.9)
  BOTTOM w0.076: U0300.U3 50.71,126.16 50.6,126.06 49.85,126.06 49.64,125.85 49.64,124.42 50.98,123.07 51.09,123.07 v7(51.22,123.2)
  BOTTOM w0.159: v2(83.24,71.9) 83.13,71.9 82.8,71.56 82.8,70.19 82.88,70.12 CON1601.198
M_CHA_DQS6: length 91
  TOP w0.159: CON1600.221 90.63,70.06 89.59,71.1 89.59,73.52 88.95,74.16 88.95,74.18 v2(88.57,74.56)
  IN1 w0.076: 61.61,115.2 61.58,115.2 60.13,116.66 60.13,117.28 59.84,117.57 59.84,118.81 58.24,120.41 56.23,120.41 54.3,122.35 54.11,122.35 v2(54.03,122.27)
  IN1 w0.114: v2(88.57,74.56) 89.13,75.12 89.13,76.27 90.75,77.89 90.75,78.65 91.11,79.01 91.11,79.79 90.75,80.15 90.75,81.44 90.98,81.68 91.36,81.68 91.43,81.75 91.43,83.78 91.33,83.89 90.94,83.89 90.75,84.08 90.75,85.11 91.31,85.67 91.31,85.86 91.18,85.99 90.3,85.99 90.09,86.2 90.09,86.73 90.3,86.93 91.24,86.93 91.43,87.13 91.43,87.47 91.32,87.59 90.2,87.59 89.97,87.82 89.97,88.28 90.2,88.52 91.32,88.52 91.43,88.63 91.43,88.94 91.23,89.14 90.3,89.14 90.1,89.34 90.1,90.27 73.47,106.9 72.5,106.9 64.43,114.98 61.83,114.98 61.61,115.2
  BOTTOM w0.076: U0300.R3 52.33,126.23 52.22,126.23 52.01,126.01 52.01,124.49 52.73,123.77 52.73,123.37 53.24,122.86 53.24,122.67 53.19,122.62 52.77,122.62 52.69,122.54 52.69,122.43 52.77,122.35 53.95,122.35 v2(54.03,122.27)
  BOTTOM w0.159: CON1601.221 88.63,76.13 88.39,75.89 88.39,75.33 88.6,75.12 88.9,75.12 89.03,75 89.03,74.67 88.93,74.56 v2(88.57,74.56)
M_CHA_DQS6#: length 90.8
  TOP w0.159: v2(88.57,73.93) 88.57,73.93 88.57,73.34 88.67,73.24 88.85,73.24 88.95,73.34 88.95,73.5 89.03,73.57 89.17,73.57 89.33,73.41 89.33,70.99 90.13,70.19 CON1600.219
  IN1 w0.076: v7(53.67,122.85) 54.03,122.85 56.3,120.58 58.31,120.58 60.01,118.88 60.01,117.64 60.29,117.35 60.29,116.72 61.6,115.42 61.68,115.42
  IN1 w0.114: v2(88.57,73.93) 89,74.36 89,74.71 89.33,75.04 89.33,76.19 90.95,77.8 90.95,78.57 91.31,78.93 91.31,79.88 90.95,80.24 90.95,81.36 91.07,81.47 91.44,81.47 91.64,81.67 91.64,83.87 91.41,84.09 91.03,84.09 90.95,84.17 90.95,85.02 91.52,85.59 91.52,85.95 91.27,86.2 90.38,86.2 90.3,86.28 90.3,86.65 90.38,86.73 91.32,86.73 91.64,87.05 91.64,87.56 91.4,87.79 90.28,87.79 90.17,87.91 90.17,88.2 90.28,88.31 91.4,88.31 91.64,88.55 91.64,89.02 91.31,89.35 90.38,89.35 90.31,89.42 90.31,90.35 73.55,107.11 72.59,107.11 64.52,115.18 61.92,115.18 61.68,115.42
  BOTTOM w0.076: v7(53.67,122.85) 53.48,122.85 52.89,123.44 52.89,123.84 52.17,124.56 52.17,125.94 52.29,126.06 52.9,126.06 U0300.P3
  BOTTOM w0.159: v2(88.57,73.93) 88.13,74.37 CON1601.219
M_CHA_DQS7: length 90.5
  TOP w0.159: CON1600.242 95.88,76.13 95.05,75.3 95.05,72.56 v2(94.41,71.92)
  IN1 w0.076: 66.6,121.17 66.54,121.23 66.54,121.29 65.33,122.5 64.08,123.75 56.19,123.75 v6(55.78,123.33)
  IN1 w0.114: v2(94.41,71.92) 93.81,72.53 93.81,74.28 96.91,77.38 96.91,80.32 96.18,81.05 96.18,82.35 96.83,82.99 96.83,83.78 96.18,84.42 96.18,85.31 95.62,85.86 95.62,89.83 74.96,110.5 74.08,110.5 68.02,116.56 68.02,119.75 66.6,121.17
  BOTTOM w0.076: U0300.M3 54.84,126.23 54.81,126.23 54.52,125.94 54.52,124.08 55.11,123.48 55.23,123.48 55.38,123.33 v6(55.78,123.33)
  BOTTOM w0.159: CON1601.242 93.88,70.06 93.64,70.3 93.64,71.54 93.73,71.64 93.99,71.64 94.06,71.57 94.06,71.49 94.13,71.41 94.34,71.41 94.41,71.49 v2(94.41,71.92)
M_CHA_DQS7#: length 90.8
  TOP w0.159: v2(94.41,72.56) 93.94,72.56 93.84,72.66 93.84,72.99 93.99,73.14 94.62,73.14 94.79,73.31 94.79,75.41 95.38,76 CON1600.240
  IN1 w0.076: v7(55.36,123.87) 55.41,123.91 64.15,123.91 65.45,122.61 66.7,121.35 66.73,121.33 66.74,121.32
  IN1 w0.114: v2(94.41,72.56) 94.4,72.55 94.07,72.55 94.01,72.61 94.01,74.19 97.11,77.3 97.11,80.4 96.38,81.13 96.38,82.26 97.03,82.91 97.03,83.86 96.38,84.51 96.38,85.39 95.83,85.95 95.83,89.91 75.04,110.7 74.16,110.7 68.22,116.64 68.22,119.83 66.74,121.32
  BOTTOM w0.076: v7(55.36,123.87) 54.96,123.87 54.69,124.14 54.69,125.87 54.88,126.06 55.41,126.06 U0300.L3
  BOTTOM w0.159: v2(94.41,72.56) 94.08,72.56 93.98,72.46 93.98,71.97 93.9,71.9 93.62,71.9 93.38,71.65 CON1601.240
M_CHA_MAA0: length 84.6
  TOP w0.222: v2(68.52,70.79) 68.65,70.93 68.65,73.1 68.46,73.29 68.46,75.27 69.38,76.19 CON1600.144
  IN1 w0.076: 42.27,119.04 42.05,119.26 42.05,121.11 42.23,121.29 42.23,123.04 41.92,123.34 v6(41.83,123.34)
  IN1 w0.152: 42.27,119.04 44.86,116.45 44.86,109.65 48.29,106.22 48.29,105.05 66.51,86.84 67.3,86.84 70.1,84.03 70.1,81.64 70.51,81.24 70.51,76.66 70.71,76.45 70.71,73.67 70.42,73.37 70.42,71.13 69.88,70.59 68.71,70.59 v2(68.52,70.79)
  BOTTOM w0.076: U0300.AH3 42.27,126.23 42.23,126.23 41.94,125.94 41.94,124.77 42.1,124.61 42.1,123.61 v6(41.83,123.34)
  BOTTOM w0.222: v2(68.52,70.79) 68.94,70.37 68.94,68.55 68.76,68.37 68.25,68.37 68.12,68.5 68.12,70.1 67.88,70.34 67.58,70.34 67.38,70.14 CON1601.144
M_CHA_MAA1: length 76
  TOP w0.222: v2(66.05,73.45) 66.33,73.45 66.78,72.99 66.78,72.29 66.49,71.99 66.49,70.94 66.63,70.8 CON1600.133
  IN1 w0.152: v2(66.05,73.45) 65.77,73.73 65.77,76.39 65.63,76.53 65.63,77.16 64.59,78.2 64.59,80.39 63.28,81.7 63.28,82.82 38.99,107.12 38.99,115.53 38.13,116.39 38.13,125.38 37.78,125.72 37.78,126.56 v6(36.95,127.39)
  BOTTOM w0.076: U0300.AP4 37.31,127.04 v6(36.95,127.39)
  BOTTOM w0.222: v2(66.05,73.45) 65.63,73.87 65.63,75.19 64.63,76.2 CON1601.133
M_CHA_MAA2: length 82.8
  TOP w0.102: v6(38.54,126.07) 38.56,126.05 38.56,125.95 38.71,125.65 v1(38.84,125.52)
  TOP w0.222: v2(66.22,74.18) 66.45,74.18 66.65,74.39 66.65,76.11 66.38,76.39 CON1600.132
  IN1 w0.152: v6(38.54,126.07) 38.96,126.07 39.07,126.17 39.07,128.67 38.71,129.02 38.02,129.02 37.82,128.82 37.82,128.06 38.02,127.86 38.02,125.82 38.54,125.31 38.54,116.35 39.48,115.41 39.48,107.33 63.78,83.03 63.78,81.9 65.46,80.23 65.46,78.04 66.13,77.36 66.13,76.74 66.27,76.6 66.27,74.23 v2(66.22,74.18)
  BOTTOM w0.076: v6(38.54,126.07) 38.54,126.64 U0300.AN4
  BOTTOM w0.222: CON1601.132 64.38,70.59 65.99,72.2 66.47,72.2 66.7,72.43 66.7,73.7 v2(66.22,74.18)
M_CHA_MAA3: length 77.4
  TOP w0.222: v2(66.05,72.81) 66.05,72.36 65.92,72.23 65.92,70.55 66.13,70.35 CON1600.131
  IN1 w0.152: v6(36.95,127.97) 36.55,127.56 36.55,127.22 37.54,126.23 37.54,125.62 37.77,125.39 37.77,116.41 38.49,115.69 38.49,106.92 62.79,82.62 62.79,81.49 64.1,80.19 64.1,78 65.14,76.95 65.14,76.31 65.28,76.17 65.28,73.52 65.85,72.95 65.91,72.95 v2(66.05,72.81)
  BOTTOM w0.076: U0300.AP5 37.24,127.69 v6(36.95,127.97)
  BOTTOM w0.222: CON1601.131 64.13,76.09 65.07,75.15 65.07,73.53 65.79,72.81 v2(66.05,72.81)
M_CHA_MAA4: length 80.6
  TOP w0.222: v2(64.26,72.36) 64.8,72.36 65.16,72.72 65.16,73.42 65.63,73.9 65.63,74.29 66.08,74.74 66.08,75.73 65.38,76.43 CON1600.128
  IN1 w0.152: v6(36.14,118.89) 37.01,118.89 37.53,118.37 37.53,116.25 38,115.78 38,106.51 61.36,83.14 61.36,81.58 62.1,80.84 62.74,80.84 63.6,79.98 63.6,77.79 64.64,76.75 64.64,76.1 64.78,75.96 64.78,72.61 64.53,72.36 v2(64.26,72.36)
  BOTTOM w0.076: 37.39,121.59 38.05,122.25 38.05,124.43 37.78,124.7 37.78,125.36 U0300.AP2
  BOTTOM w0.222: CON1601.128 63.38,70.45 64.26,71.34 v2(64.26,72.36) ; v6(36.14,118.89) 34.93,118.89 34.68,119.13 v1(34.68,120.03) 34.68,120.9 35.03,121.25 37.05,121.25 37.39,121.59
M_CHA_MAA5: length 77.8
  TOP w0.222: CON1600.126 64.88,76.32 65.52,75.67 65.52,74.78 65.07,74.33 65.07,74.13 64.26,73.32 v2(64.26,72.99)
  IN1 w0.076: 35.94,119.26 37.35,119.26 37.52,119.42 37.52,122.3 v6(37.35,122.47)
  IN1 w0.152: v2(64.26,72.99) 64.29,73.02 64.29,75.76 64.15,75.9 64.15,76.54 63.11,77.59 63.11,79.77 62.54,80.35 61.89,80.35 60.87,81.37 60.87,82.94 37.5,106.3 37.5,115.87 37.26,116.11 37.26,118.15 36.93,118.48 35.87,118.48 35.74,118.61 35.74,119.06 35.94,119.26
  BOTTOM w0.076: v6(37.35,122.47) 37.88,123 37.88,124.27 37.4,124.75 U0300.AP1
  BOTTOM w0.222: v2(64.26,72.99) 64.14,72.99 63.65,72.5 63.65,71.42 62.88,70.64 CON1601.126 ; v1(36.6,121.8) 36.99,121.8 37.35,122.17 v6(37.35,122.47)
M_CHA_MAA6: length 82
  TOP w0.222: v6(37.35,123.61) 37.35,124.21 v1(37.39,124.25) ; CON1600.127 65.13,70.59 63.51,72.21 63.51,73.9 62.62,74.79 v2(62.22,74.79)
  IN1 w0.152: v2(62.22,74.79) 62.17,74.84 62.17,75.72 60.73,77.16 60.73,77.36 61.01,77.64 61.01,77.77 60.81,77.97 60.65,77.97 60.38,77.71 60.18,77.71 60,77.89 60,78.15 60.28,78.43 60.28,78.64 60.13,78.78 59.93,78.78 59.68,78.54 59.35,78.54 58.88,79.01 58.88,82.12 35.52,105.48 35.52,114.97 34.9,115.59 34.9,119.5 36.68,121.27 36.68,123.26 36.83,123.41 36.83,125.54 36.93,125.65 37.18,125.65 37.35,125.47 v6(37.35,123.61)
  BOTTOM w0.076: v6(37.35,123.61) 36.91,124.05 36.91,125.93 37.26,126.28 37.29,126.28 U0300.AP3
  BOTTOM w0.222: CON1601.127 63.13,76.13 63.37,75.88 63.37,75.38 63.12,75.12 62.79,75.12 62.69,75.22 62.38,75.22 62.22,75.06 v2(62.22,74.79)
M_CHA_MAA7: length 84.9
  TOP w0.222: CON1600.122 63.88,76.2 64.01,76.07 64.59,76.07 65.13,75.53 65.13,74.95 64.72,74.54 64.49,74.54 64.35,74.68 64.35,75.34 64.21,75.48 63.93,75.48 63.83,75.37 v2(63.83,74.94)
  IN1 w0.152: v6(35.76,117.67) 35.76,118 35.89,118.12 36.83,118.12 36.91,118.05 36.91,117.71 36.81,117.62 36.37,117.62 36.25,117.49 36.25,117.24 36.37,117.12 36.89,117.12 36.98,117.03 36.98,116.78 36.91,116.7 36.35,116.7 36.25,116.6 36.25,116.37 36.35,116.27 36.8,116.27 36.91,116.17 36.91,115.92 37,115.82 37,106.1 60.37,82.73 60.37,81.17 61.69,79.85 62.33,79.85 62.61,79.57 62.61,77.38 63.65,76.34 63.65,75.12 v2(63.83,74.94)
  BOTTOM w0.076: 37.9,121.07 37.9,121.64 38.28,122.02 38.28,124.95 U0300.AN1
  BOTTOM w0.222: v6(35.76,117.67) v1(36.6,117.67) 36.76,117.67 36.89,117.54 36.89,117.08 37.16,116.8 37.62,116.8 37.81,117 37.81,119.45 37.49,119.78 36.63,119.78 36.47,119.93 36.47,120.31 36.68,120.51 37.64,120.51 37.9,120.77 37.9,121.07 ; CON1601.122 61.88,70.43 63.02,71.57 63.02,72.67 64.29,73.94 64.29,74.65 64,74.94 v2(63.83,74.94)
M_CHA_MAA8: length 82.5
  TOP w0.102: v1(36.63,122.52) 37.13,123.03 v6(37.35,123.03)
  TOP w0.222: v2(62.23,74.13) 62.51,74.13 62.94,73.7 62.94,71.97 64.63,70.29 CON1600.125
  IN1 w0.152: v6(37.35,123.03) 37.01,123.03 36.93,122.95 36.93,121 37.01,120.92 37.21,120.92 37.29,120.84 37.29,120.61 37.19,120.51 36.35,120.51 36.25,120.41 36.25,120.1 36.33,120.02 37.14,120.02 37.26,119.89 37.26,119.62 37.16,119.52 35.36,119.52 35.25,119.42 35.25,115.74 35.36,115.64 35.53,115.64 35.61,115.71 35.61,115.84 35.69,115.92 35.89,115.92 36.01,115.79 36.01,105.69 59.38,82.32 59.38,80.76 60.95,79.19 60.95,78.53 61.51,77.98 61.51,77.08 62.66,75.93 62.66,74.23 62.56,74.13 v2(62.23,74.13)
  BOTTOM w0.076: U0300.AN3 37.81,126.06 37.28,126.06 37.08,125.87 37.08,124.22 37.24,124.07 37.62,124.07 37.72,123.97 37.72,123.15 37.59,123.03 v6(37.35,123.03)
  BOTTOM w0.222: CON1601.125 62.63,75.83 62.41,75.61 61.9,75.61 61.34,75.05 61.34,74.36 61.57,74.13 v2(62.23,74.13)
M_CHA_MAA9: length 76.6
  TOP w0.222: CON1600.121 63.63,70.49 62.33,71.78 62.33,73.4 v2(62.23,73.5)
  IN1 w0.152: v2(62.23,73.5) 62.03,73.5 61.67,73.85 61.67,75.52 58.39,78.8 58.39,81.91 35.02,105.28 35.02,114.77 34.59,115.2 34.59,115.43 34.54,115.48 34.54,119.59 36.3,121.36 36.3,124.1 36.5,124.29 36.5,126.59 36.38,126.71 v6(36.09,126.71)
  BOTTOM w0.076: v6(36.09,126.71) 35.77,127.04 U0300.AT4
  BOTTOM w0.222: v2(62.23,73.5) 61.47,73.5 60.93,74.03 60.93,75.3 61.63,75.99 CON1601.121
M_CHA_MAA10: length 80.7
  TOP w0.102: v6(43.59,126.07) 43.59,125.63 v1(43.38,125.42)
  TOP w0.222: v2(70.91,72.38) 70.51,72.38 70.35,72.54 70.35,74.92 71.88,76.45 CON1600.146
  IN1 w0.076: v6(43.59,126.07) 43.3,126.07 43.15,125.92 43.15,125.52 42.57,124.94 42.57,120.88 42.44,120.75
  IN1 w0.152: v2(70.91,72.38) 71.17,72.38 71.7,72.91 71.7,76.86 71.5,77.07 71.5,81.65 71.09,82.06 71.09,83.28 71.17,83.36 71.37,83.36 71.5,83.48 71.5,83.91 71.43,83.99 71.2,83.99 71.09,84.09 71.09,84.44 67.64,87.9 66.85,87.9 49.28,105.46 49.28,106.63 45.85,110.06 45.85,116.04 42.44,119.45 42.44,120.75
  BOTTOM w0.076: U0300.AH2 42.7,125.74 43.04,126.07 v6(43.59,126.07)
  BOTTOM w0.222: v2(70.91,72.38) 69.8,72.38 69.55,72.13 69.55,71.54 69.88,71.21 CON1601.146
M_CHA_MAA11: length 84.8
  TOP w0.222: CON1600.120 63.38,76.17 63.23,76.03 62.8,76.03 62.43,75.66 62.43,75.4 62.56,75.28 63.12,75.28 63.27,75.13 63.27,74.71 63.68,74.31 v2(63.83,74.31)
  IN1 w0.152: v6(35.79,116.45) 36.51,115.73 36.51,105.89 59.87,82.53 59.87,80.96 61.44,79.39 61.44,78.74 62,78.18 62,77.29 63.16,76.13 63.16,71.73 63.3,71.59 63.63,71.59 63.74,71.71 63.74,74.22 v2(63.83,74.31)
  BOTTOM w0.076: 38.47,121.68 38.47,125.02 38.48,125.02 38.48,125.4 U0300.AN2
  BOTTOM w0.222: v2(63.83,74.31) 63.02,74.31 62.87,74.16 62.87,73.32 62.43,72.88 62.43,71.7 61.38,70.64 CON1601.120 ; v1(34.8,117.52) 34.8,116.93 35.28,116.45 v6(35.79,116.45) 36.04,116.2 38.29,116.2 38.46,116.37 38.46,118.68 38.47,118.7 38.47,121.68
M_CHA_MAA12: length 84.5
  TOP w0.222: CON1600.119 63.13,70.19 62.03,71.29 60.81,71.29 60.43,71.67 60.43,72.05 60.55,72.18 60.81,72.18 61.06,71.92 v2(61.22,71.92) ; v6(34.48,126.7) 34.48,126.07 v1(34.52,126.03)
  IN1 w0.152: v2(61.22,71.92) 60.94,71.92 60.59,72.27 60.59,75.07 57.28,78.38 57.28,81.17 56.71,81.74 55.84,81.74 42.16,95.42 42.16,96.6 36.31,102.45 36.11,102.45 35.81,102.15 35.61,102.15 35.46,102.3 35.46,102.51 35.76,102.8 35.76,103.01 35.61,103.15 35.41,103.15 35.11,102.86 34.91,102.86 34.76,103 34.76,103.21 35.06,103.5 35.06,103.71 34.91,103.85 34.71,103.85 34.41,103.56 34.21,103.56 34.06,103.7 34.06,103.91 34.36,104.2 34.36,104.41 33.94,104.83 33.94,113.61 33.5,114.04 33.5,119.28 34.54,120.32 34.54,124.15 34.01,124.69 34.01,126.22 v6(34.48,126.7)
  BOTTOM w0.076: U0300.AU4 34.55,126.7 v6(34.48,126.7)
  BOTTOM w0.222: v2(61.22,71.92) 61.31,71.92 61.72,72.33 61.72,72.78 60.35,74.16 60.35,75.38 61.13,76.16 CON1601.119
M_CHA_MAA13: length 83.3
  TOP w0.222: v2(73.59,73.06) 73.59,74.31 74.88,75.6 CON1600.158
  IN1 w0.152: v2(73.59,73.06) 72.83,73.06 72.7,73.19 72.7,73.45 72.82,73.57 73.08,73.57 73.19,73.69 73.19,78.02 72.99,78.22 72.99,84.83 68.29,89.52 67.32,89.52 50.77,106.08 50.77,107.24 47.34,110.67 47.34,115.57 43.23,119.68 43.23,120.66 43.36,120.79 43.5,120.79 43.61,120.91 43.61,121.08 43.5,121.2 43.32,121.2 43.21,121.32 43.21,121.49 43.32,121.6 43.48,121.6 43.59,121.72 43.59,121.87 43.48,121.99 43.26,121.99 43.18,122.06 43.18,122.32 43.28,122.42 43.49,122.42 43.59,122.52 43.59,122.75 43.49,122.85 43.36,122.85 43.23,122.98 43.23,123.92 43.31,123.99 43.5,123.99 43.63,123.87 43.63,123.41 43.89,123.14 44.07,123.14 v6(44.07,123.15)
  BOTTOM w0.076: v6(44.07,123.15) 44.23,123.15 44.35,123.27 44.35,123.53 44.45,123.63 44.59,123.63 44.68,123.53 44.68,123.05 44.81,122.93 45,122.93 45.17,123.1 45.17,123.93 45.06,124.05 44.7,124.05 44.63,124.12 44.63,124.35 44.81,124.53 44.81,124.67 44.63,124.85 44.63,126.33 44.68,126.39 U0300.AE3
  BOTTOM w0.222: v2(73.59,73.06) 73.28,72.75 73.28,70.53 72.88,70.12 CON1601.158
M_CHA_MAA14: length 83.7
  TOP w0.222: CON1600.151 73.13,72.03 72.69,72.46 72.69,74.07 v2(72.7,74.07) ; v6(43.59,127.34) 43.22,127.7 v1(43,127.7)
  IN1 w0.076: v6(43.59,127.34) 43.22,126.96 42.98,126.96 42.9,127.04 42.9,129.06 43.14,129.3 43.81,129.3 43.99,129.12 43.99,127.68 44.13,127.54 44.13,125.85 42.96,124.68 42.96,119.61 43.36,119.22
  IN1 w0.152: 43.36,119.22 46.84,115.73 46.84,110.47 50.27,107.04 50.27,105.87 67.12,89.03 68.09,89.03 72.49,84.63 72.49,78.01 72.7,77.81 v2(72.7,74.07)
  BOTTOM w0.076: v6(43.59,127.34) 43.29,127.04 U0300.AG4
  BOTTOM w0.222: CON1601.151 71.13,76.18 71.27,76.03 71.27,75.43 71.43,75.28 71.73,75.28 71.93,75.48 72.24,75.48 72.7,75.02 v2(72.7,74.07)
M_CHA_MAA15: length 83.4
  TOP w0.222: CON1600.156 74.38,76.22 72.91,74.75 72.58,74.75 72.13,74.31 72.13,71.78 v2(72.16,71.74)
  IN1 w0.076: 43.57,120.05 43.57,120.24 v6(44.01,120.69)
  IN1 w0.152: v2(72.16,71.74) 72.16,71.97 72.75,72.55 73.78,72.55 74.13,72.9 74.13,73.43 73.69,73.88 73.69,78.22 73.48,78.42 73.48,85.04 68.5,90.02 67.53,90.02 51.26,106.29 51.26,107.45 47.83,110.88 47.83,115.42 43.57,119.69 43.57,120.05
  BOTTOM w0.076: U0300.AD1 45.68,122.6
  BOTTOM w0.222: CON1601.156 72.38,70.46 72.5,70.59 72.76,70.59 72.92,70.76 72.92,71.85 72.75,72.03 72.44,72.03 v2(72.16,71.74) ; 45.68,122.6 45.68,122.25 45.57,122.14 45.22,122.14 45.06,121.97 45.06,121.66 v1(45.33,121.39) 45.49,121.23 45.49,119.82 45.37,119.71 45.02,119.71 44.88,119.85 44.88,120.97 44.73,121.12 44.64,121.12 44.2,120.69 v6(44.01,120.69)
M_CHA_MAA16: length 81.1
  TOP w0.127: v6(43.59,126.71) 43.64,126.76 v1(44.55,126.76)
  TOP w0.222: CON1600.152 73.38,76.02 72.68,75.32 72.34,75.32 71.55,74.53 v2(71.55,71.34)
  IN1 w0.076: v6(43.59,126.71) 43.61,126.71 43.96,126.36 43.96,125.91 42.76,124.71 42.76,120.02
  IN1 w0.152: 42.76,120.02 42.76,119.47 46.35,115.88 46.35,110.26 49.78,106.83 49.78,105.67 67.06,88.39 67.84,88.39 72,84.24 72,77.27 72.2,77.07 72.2,72.71 71.55,72.06 v2(71.55,71.34)
  BOTTOM w0.076: v6(43.59,126.71) 42.76,126.71 U0300.AH4
  BOTTOM w0.222: CON1601.152 71.38,70.22 70.89,70.71 70.89,71.04 71.19,71.34 v2(71.55,71.34)
M_CHA_ODT0: length 85.1
  TOP w0.178: v2(74.09,70.62) 74.09,70.15 74.13,70.11 CON1600.155 ; v6(46.08,126.05) 46.08,126.05 v1(46.08,125.42)
  IN1 w0.076: 46.58,120.9 45.36,122.12 45.36,125.05 46.08,125.77 v6(46.08,126.05)
  IN1 w0.121: 46.58,120.9 51.2,116.28 51.2,111.8 64.41,98.59 65.42,98.59 77.35,86.66 77.35,83.34 77.11,83.1 77.11,82.39 77.65,81.85 77.65,78.1 76.75,77.2 76.75,73.42 76.85,73.33 76.85,71.44 76.61,71.19 76.61,70.3 76.52,70.21 76.52,69.79 76.39,69.66 76,69.66 75.87,69.79 75.87,69.92 75.74,70.05 75.47,70.05 75.35,69.92 75.35,69.53 75.23,69.41 75.04,69.41 74.92,69.53 74.92,69.93 74.8,70.05 74.62,70.05 74.49,69.93 74.49,69.53 74.37,69.41 74.19,69.41 74.07,69.53 74.07,69.93 73.95,70.05 73.76,70.05 73.64,69.93 73.64,69.53 73.52,69.41 73.34,69.41 73.22,69.53 73.22,69.93 73.1,70.05 72.91,70.05 72.79,69.93 72.79,69.53 72.67,69.41 72.49,69.41 72.37,69.53 72.37,69.93 72.13,70.17 72.13,70.5 72.23,70.6 72.92,70.6 72.94,70.62 v2(74.09,70.62)
  BOTTOM w0.076: v6(46.08,126.05) 46.02,126.05 45.69,126.39 U0300.AD3
M_CHA_ODT1: length 84.4
  TOP w0.178: v2(76,72.02) 75.63,71.65 CON1600.161
  IN1 w0.121: v7(44.06,123.81) 43.57,124.3 43.33,124.3 43.23,124.4 43.23,124.65 43.46,124.88 44.07,124.88 44.26,125.07 44.26,125.58 44.4,125.72 44.4,128.16 44.5,128.26 45.23,128.26 45.34,128.15 45.34,127.93 45.11,127.7 45.11,125.62 44.79,125.3 44.79,121.83 49.59,117.02 49.59,111.6 53.02,108.18 53.02,107.01 62.72,97.31 64.89,97.31 76.08,86.13 76.08,83.99 75.76,83.68 75.76,78.01 75.48,77.73 75.48,74.28 75.53,74.23 75.53,72.49 v2(76,72.02)
  BOTTOM w0.076: v7(44.06,123.81) 44.45,124.19 44.45,126.54 U0300.AE4
M_CHA_ODT2: length 84.7
  IN1 w0.121: v6(44.02,122.57) 44.22,122.78 44.45,122.78 44.58,122.65 44.58,122.52 44.4,122.35 44.4,122.19 44.58,122.01 44.58,121.65 45.45,120.78 45.45,120.53 45.14,120.22 45.14,120.05 45.27,119.92 45.44,119.92 45.75,120.23 45.93,120.23 46.06,120.1 46.06,119.93 45.74,119.62 45.74,119.45 45.87,119.32 46.04,119.32 46.36,119.63 46.53,119.63 46.66,119.5 46.66,119.33 46.35,119.02 46.35,118.85 46.48,118.72 46.65,118.72 46.96,119.03 47.13,119.03 47.26,118.9 47.26,118.73 46.95,118.41 46.95,118.24 47.08,118.11 47.25,118.11 47.56,118.43 47.73,118.43 47.86,118.29 47.86,118.12 47.55,117.81 47.55,117.64 47.68,117.51 47.85,117.51 48.16,117.82 48.33,117.82 48.46,117.69 48.46,117.52 48.15,117.21 48.15,117.04 48.28,116.91 48.45,116.91 48.76,117.22 48.94,117.22 49.16,116.99 49.16,111.43 52.59,108 52.59,106.84 62.54,96.89 63.51,96.89 69.63,90.77 69.8,90.77 70.02,90.99 70.19,90.99 70.32,90.86 70.32,90.69 70.1,90.47 70.1,90.3 70.23,90.17 70.4,90.17 70.62,90.39 70.8,90.39 70.93,90.25 70.93,90.08 70.71,89.86 70.71,89.69 70.84,89.56 71.01,89.56 71.23,89.78 71.4,89.78 71.53,89.65 71.53,89.48 71.39,89.35 71.31,89.26 71.31,89.09 71.44,88.96 71.61,88.96 71.83,89.18 72,89.18 72.13,89.05 72.13,88.88 71.91,88.66 71.91,88.49 72.04,88.36 72.21,88.36 72.43,88.58 72.6,88.58 72.73,88.45 72.73,88.28 72.51,88.06 72.51,87.89 72.64,87.76 72.81,87.76 73.03,87.98 73.2,87.98 73.33,87.85 73.33,87.68 73.11,87.46 73.11,87.29 73.24,87.16 73.41,87.16 73.63,87.38 73.81,87.38 73.94,87.24 73.94,87.07 73.72,86.85 73.72,86.68 73.92,86.48 74.93,86.48 75.36,86.06 75.65,85.76 75.65,84.17 75.33,83.85 75.33,78.19 75.05,77.9 75.05,74.11 v2(75.11,74.06)
  BOTTOM w0.076: v6(44.02,122.57) 44.88,122.57 45.34,123.03 45.34,124.43 45.15,124.61 45.15,124.88 U0300.AE1
  BOTTOM w0.178: CON1601.155 72.13,76.15 73.68,74.59 74.57,74.59 v2(75.11,74.06)
M_CHA_ODT3: length 86.9
  IN1 w0.076: v6(46.09,126.7) 46.09,126.56 46.45,126.21 46.45,125.9 45.53,124.98 45.53,122.19 46.48,121.24 46.54,121.24
  IN1 w0.121: v2(78.2,73.27) 77.93,73.27 77.83,73.17 77.83,72.41 77.72,72.31 77.42,72.31 77.29,72.44 77.29,73.83 77.21,73.91 77.21,77.06 78.08,77.92 78.08,82.6 77.78,82.9 77.78,87.54 76.81,88.51 76.1,88.51 69.06,95.55 69.06,95.72 69.55,96.21 69.55,96.38 69.42,96.51 69.25,96.51 68.76,96.02 68.59,96.02 68.46,96.16 68.46,96.33 68.94,96.81 68.94,96.98 68.81,97.11 68.64,97.11 68.16,96.63 67.99,96.63 67.86,96.76 67.86,96.93 68.34,97.41 68.34,97.59 68.21,97.72 68.04,97.72 67.56,97.23 67.38,97.23 67.25,97.36 67.25,97.53 67.74,98.02 67.74,98.19 67.61,98.32 67.44,98.32 66.95,97.83 66.78,97.83 66.65,97.96 66.65,98.13 67.14,98.62 67.14,98.79 67.01,98.92 66.84,98.92 66.35,98.43 66.18,98.43 65.6,99.01 64.59,99.01 51.63,111.97 51.63,116.15 46.54,121.24
  BOTTOM w0.076: v6(46.09,126.7) 45.75,127.04 U0300.AD4
  BOTTOM w0.178: CON1601.161 73.63,76.01 74.08,75.56 75,75.56 75.51,75.05 76.2,75.05 77.98,73.27 v2(78.2,73.27)
M_CHA_PAR: length 84.1
  TOP w0.222: v2(69.66,75.64) 69.66,75.64 69.5,75.49 69.48,75.49 69.21,75.22 69.21,72.05 69.86,71.4 69.86,70.58 69.72,70.44 69.31,70.44 69.13,70.26 CON1600.143
  IN1 w0.076: v7(41.83,122.68) 41.45,122.3 41.45,121.67
  IN1 w0.152: 41.45,121.67 41.59,121.53 41.59,119.03 43.87,116.75 43.87,110.44 43.76,110.33 43.45,110.33 43.36,110.23 43.36,109.69 43.45,109.59 43.74,109.59 43.87,109.46 43.87,108.07 44.19,107.75 44.41,107.75 44.75,108.09 44.96,108.09 45.28,107.77 45.28,107.55 44.95,107.21 44.95,107 45.27,106.68 45.48,106.68 45.82,107.01 46.04,107.01 46.36,106.69 46.36,106.48 46.02,106.14 46.02,105.92 67.51,84.43 67.78,84.43 67.87,84.35 67.87,84.17 67.97,84.07 68.15,84.07 68.3,84.22 68.33,84.24 68.49,84.24 68.59,84.14 68.59,83.95 68.38,83.74 68.38,83.57 68.51,83.43 68.68,83.43 68.76,83.51 68.96,83.51 69.11,83.35 69.11,82.87 68.96,82.72 68.76,82.72 68.63,82.59 68.63,81.72 69.52,80.83 69.52,76.04 69.66,75.9 v2(69.66,75.64)
  BOTTOM w0.076: U0300.AG3 43.02,126.53 42.85,126.53 42.77,126.46 42.77,126.14 42.7,126.07 42.31,126.07 42.11,125.87 42.11,124.85 42.27,124.7 42.27,122.82 42.12,122.68 v7(41.83,122.68)
  BOTTOM w0.222: v2(69.66,75.64) 68.96,75.64 68.78,75.83 68.78,76.14 69.04,76.39 69.04,76.67 68.91,76.8 68.63,76.8 68.45,76.98 68.45,77.83 68.32,77.97 67.94,77.97 67.79,77.82 67.79,76.29 67.67,76.16 67.28,76.16 67.13,76.32 CON1601.143
M_CHB_ACT#: length 94.9
  TOP w0.222: CON1700.114 61.88,64.2 60.88,63.21 59.26,63.21 v2(58.07,62.02)
  IN4 w0.076: v6(36.3,130.62) 36.61,130.3 36.61,129.18 36.39,128.95 35.86,128.95 35.67,128.77 35.67,124.06 35.92,123.81 35.92,122.23 35.81,122.12
  IN4 w0.152: v2(58.07,62.02) 58.43,62.38 58.43,64.49 58.07,64.85 58.07,65.13 57.18,66.03 57.18,68.41 56.03,69.55 56.03,70.32 54.94,71.41 54.94,73.06 50.85,77.15 50.85,79.6 50.41,80.04 50.41,84.36 31.52,103.25 31.52,117.83 35.81,122.12
  BOTTOM w0.076: v6(36.3,130.62) 36.1,130.62 U0300.AT9
  BOTTOM w0.222: CON1701.114 59.88,59.77 58.7,60.95 58.7,61.66 58.34,62.02 v2(58.07,62.02)
M_CHB_ALERT#: length 92.5
  TOP w0.178: v2(60.51,61.99) 62.06,61.99 62.69,62.62 62.69,63.51 62.38,63.82 CON1700.116
  IN4 w0.076: 36.4,121.36 36.49,121.45 36.49,124.01 37.05,124.57 37.05,126.5 37.44,126.9 37.44,128.82 37.52,128.9 37.52,129.47 37.15,129.85 v6(37.15,129.95)
  IN4 w0.121: v2(60.51,61.99) 60.38,61.99 59.96,62.41 59.96,65.13 59.61,65.48 59.61,65.77 58.71,66.67 58.71,70.48 57.82,71.37 57.16,71.37 56.47,72.05 56.47,73.7 52.38,77.79 52.38,84.55 33.08,103.86 33.08,109.92 33.41,110.25 33.41,118.38 36.4,121.36
  BOTTOM w0.076: U0300.AR8 37,129.95 v6(37.15,129.95)
  BOTTOM w0.178: CON1701.116 60.38,58.18 60.51,58.31 v2(60.51,61.99)
M_CHB_BA0: length 96.9
  TOP w0.222: v2(71.88,60.95) 71.88,63.36 72.88,64.36 CON1700.150
  IN4 w0.076: 43.08,118.9 43.01,118.97 43.01,129.53 42.64,129.9 v6(42.64,129.97)
  IN4 w0.152: 43.08,118.9 44.98,116.99 44.98,111.59 46.56,110.01 46.56,108.38 64.18,90.76 65.54,90.76 65.94,90.36 65.94,90.24 65.42,89.72 65.42,89.52 65.57,89.37 65.77,89.37 66.25,89.85 66.45,89.85 66.6,89.7 66.6,89.5 66.12,89.02 66.12,88.82 66.27,88.67 66.47,88.67 66.95,89.15 67.15,89.15 67.35,88.95 67.35,88.76 67.21,88.62 67.21,88.47 67.39,88.29 68.01,88.29 71.43,84.87 71.43,83.58 71.09,83.25 71.09,81.84 72,80.93 72,77.39 72.26,77.13 72.26,73.89 72.66,73.49 72.66,72.67 73.16,72.17 73.16,70.72 72.09,69.65 72.09,61.68 71.88,61.48 v2(71.88,60.95)
  BOTTOM w0.076: v6(42.64,129.97) 42.51,129.97 U0300.AH8
  BOTTOM w0.222: v2(71.88,60.95) 71.83,60.9 71.83,60.19 71.36,59.72 71.1,59.72 70.69,59.31 70.69,58.65 70.88,58.46 CON1701.150
M_CHB_BA1: length 97.5
  TOP w0.222: v2(70.59,61.75) 70.59,58.89 71.01,58.47 71.21,58.47 71.63,58.06 CON1700.145
  IN4 w0.076: 42.78,118.29 42.67,118.4 42.67,128.59 42.27,128.99 42.27,130.25 v6(42.64,130.62)
  IN4 w0.152: v2(70.59,61.75) 71.08,62.24 71.08,71.56 71.67,72.14 71.67,73.08 71.24,73.51 71.24,76.75 71.01,76.98 71.01,80.52 69.93,81.6 69.93,83.5 70.43,84.01 70.43,84.24 70.28,84.39 70.08,84.39 69.72,84.03 69.57,84.03 69.32,84.28 69.32,84.43 69.77,84.89 69.77,85.12 67.6,87.3 66.24,87.3 45.57,107.97 45.57,109.6 43.89,111.28 43.89,114.49 42.8,115.58 42.8,115.76 42.95,115.92 43.21,115.92 43.76,115.36 43.97,115.36 44.12,115.51 44.12,115.71 43.36,116.47 42.93,116.47 42.82,116.58 42.82,116.83 42.93,116.93 43.38,116.93 43.51,117.06 43.51,117.56 42.78,118.29
  BOTTOM w0.076: U0300.AH9 42.51,130.62 v6(42.64,130.62)
  BOTTOM w0.222: v2(70.59,61.75) 70,62.34 70,63.81 69.63,64.19 CON1701.145
M_CHB_BG0: length 93.6
  TOP w0.222: v2(59.33,61.09) 59.33,60.98 62.13,58.19 CON1700.115
  IN4 w0.076: 36.03,121.84 36.12,121.94 36.12,124.11 36.46,124.45 36.46,127.13 36.42,127.17 36.42,128.35 36.78,128.71 36.78,130.25 v6(37.15,130.62)
  IN4 w0.152: v2(59.33,61.09) 59.1,61.09 58.84,61.36 58.84,62.06 58.92,62.14 58.92,64.7 58.57,65.05 58.57,65.34 57.67,66.24 57.67,68.61 56.53,69.76 56.53,70.53 55.44,71.62 55.44,73.27 51.35,77.36 51.35,79.8 50.9,80.25 50.9,84.57 32.03,103.44 32.03,117.85 36.03,121.84
  BOTTOM w0.076: v6(37.15,130.62) 37.02,130.62 U0300.AR9
  BOTTOM w0.222: v2(59.33,61.09) 59.56,61.09 59.9,61.43 59.9,63.98 60.13,64.2 CON1701.115
M_CHB_BG1: length 93.6
  TOP w0.222: v2(59.33,61.73) 59.12,61.73 58.76,61.37 58.76,60.89 61.63,58.03 CON1700.113
  IN4 w0.076: 36.19,121.6 36.3,121.71 36.3,124.06 36.88,124.64 36.88,126.94 36.58,127.24 36.58,128.23 37.15,128.8 v6(37.15,129.32)
  IN4 w0.152: 36.19,121.6 32.54,117.95 32.54,103.63 51.4,84.77 51.4,80.45 51.84,80.01 51.84,77.56 55.93,73.47 55.93,71.82 57.18,70.58 57.84,70.58 58.17,70.25 58.17,70.02 58.04,69.89 57.46,69.89 57.35,69.79 57.35,69.63 58.17,68.82 58.17,66.44 59.06,65.54 59.06,65.26 59.42,64.9 59.42,61.81 v2(59.33,61.73)
  BOTTOM w0.076: v6(37.15,129.32) 37.02,129.32 U0300.AR7
  BOTTOM w0.222: CON1701.113 59.63,64.39 59.33,64.1 59.33,63.08 59.18,62.93 58.91,62.93 58.75,62.77 58.75,62.41 58.86,62.3 59.18,62.3 59.33,62.14 v2(59.33,61.73)
M_CHB_CKE0: length 97.1
  TOP w0.222: v2(58.07,60.79) 58.28,60.79 60.63,58.45 CON1700.109
  IN4 w0.076: v6(36.25,129.99) 36.25,129.86 35.13,128.74 35.13,128.53
  IN4 w0.108: 35.13,128.53 34.93,128.33 34.93,126.18 34.82,126.07 34.5,126.07 34.39,125.96 34.39,125.74 34.5,125.64 34.82,125.64 34.93,125.53 34.93,125.19
  IN4 w0.121: v2(58.07,60.79) 57.95,60.67 57.35,60.67 57.05,60.97 57.05,64.88 55.32,66.6 55.32,68.01 52.79,70.54 52.79,73.93 49.5,77.22 49.5,83.99 30.61,102.88 30.61,117.79 31.45,118.63 31.45,118.81 30.9,119.36 30.9,119.53 31.07,119.7 31.24,119.7 31.8,119.15 31.97,119.15 32.14,119.32 32.14,119.49 31.58,120.05 31.58,120.22 31.75,120.39 31.92,120.39 32.48,119.83 32.65,119.83 32.82,120 32.82,120.17 32.26,120.73 32.26,120.9 32.43,121.07 32.6,121.07 33.16,120.51 33.33,120.51 33.5,120.68 33.5,120.85 32.94,121.41 32.94,121.58 33.11,121.75 33.29,121.75 33.84,121.19 34.01,121.19 34.55,121.73 34.55,123.83 34.37,124.02 34.37,124.63 34.93,125.19
  BOTTOM w0.076: v6(36.25,129.99) 36.12,129.99 U0300.AT8
M_CHB_CKE1: length 97
  TOP w0.222: CON1700.110 60.88,63.97 60.5,63.59 57.94,63.59 v2(56.62,62.27)
  IN4 w0.076: 34.87,128.65 34.87,128.77 35.88,129.77 35.88,130.91 v6(36.24,131.27)
  IN4 w0.121: v2(56.62,62.27) 56.62,60.44 56.49,60.32 55.32,60.32 55.19,60.44 55.19,60.75 55.32,60.88 55.96,60.88 56.16,61.08 56.16,62.27 55.98,62.45 55.98,62.76 56.11,62.88 56.49,62.88 56.62,63.01 56.62,63.26 56.49,63.39 56.16,63.39 55.98,63.57 55.98,63.9 56.11,64.03 56.49,64.03 56.62,64.15 56.62,64.56 56.49,64.69 56.11,64.69 55.98,64.81 55.98,65.34 54.9,66.43 54.9,67.83 52.37,70.37 52.37,73.76 49.08,77.05 49.08,83.81 30.18,102.71 30.18,119.58 33.53,122.93 33.53,124.65 33.91,125.03 33.91,127.69 34.87,128.65
  BOTTOM w0.178: v6(36.24,131.27) 36.11,131.27 U0300.AT10
M_CHB_CKE2: length 98.2
  IN4 w0.076: 35.41,128.49 35.41,128.76 35.97,129.32 v6(36.24,129.32)
  IN4 w0.108: 35.41,124.27 35.41,128.49
  IN4 w0.121: v2(58.07,61.41) 57.77,61.1 57.56,61.1 57.47,61.18 57.47,62.67 57.58,62.78 57.84,62.78 57.95,62.89 57.95,64.19 57.81,64.33 57.56,64.33 57.47,64.41 57.47,65.05 56.29,66.24 56.29,66.61 56.21,66.69 55.84,66.69 55.75,66.78 55.75,67.19 55.85,67.3 56.19,67.3 56.29,67.4 56.29,67.6 56.19,67.71 55.85,67.71 55.75,67.81 55.75,68.11 55.83,68.19 56.13,68.19 56.34,68.39 56.34,68.57 56.03,68.88 55.83,68.88 55.52,68.57 55.36,68.57 55.22,68.71 55.22,68.88 55.58,69.24 55.58,69.39 55.41,69.56 55.21,69.56 54.89,69.24 54.69,69.24 54.53,69.4 54.53,69.59 54.92,69.97 54.92,70.17 54.79,70.3 54.58,70.3 54.18,69.89 54.04,69.89 53.85,70.09 53.85,70.26 54.53,70.95 54.53,71.14 54.36,71.32 54.12,71.32 53.53,70.73 53.35,70.73 53.22,70.86 53.22,71.66 53.34,71.78 54.06,71.78 54.18,71.9 54.18,72.15 54.06,72.27 53.34,72.27 53.22,72.39 53.22,72.63 53.34,72.75 54.06,72.75 54.18,72.87 54.18,73.11 54.06,73.23 53.34,73.23 53.22,73.35 53.22,74.11 49.93,77.4 49.93,84.17 31.04,103.05 31.04,117.81 35.03,121.79 35.03,123.89 35.41,124.27
  BOTTOM w0.076: U0300.AT7 36.11,129.32 v6(36.24,129.32)
  BOTTOM w0.178: CON1701.109 58.63,63.49 57.63,62.5 57.63,61.84 58.06,61.41 v2(58.07,61.41)
M_CHB_CKE3: length 97.3
  IN4 w0.076: 34.91,129.09 35.71,129.89 35.71,131.4 v6(36.24,131.92)
  IN4 w0.121: 34.91,129.09 32.86,127.04 32.86,122.68 29.75,119.57 29.75,102.54 48.65,83.64 48.65,76.87 51.94,73.58 51.94,70.19 54.47,67.66 54.47,66.25 55.55,65.17 55.55,64.93 55.43,64.81 54.58,64.81 54.46,64.69 54.46,64.45 54.58,64.32 55.43,64.32 55.55,64.2 55.55,63.96 55.43,63.84 54.49,63.84 54.37,63.72 54.37,63.48 54.49,63.36 55.43,63.36 55.55,63.24 55.55,63 55.43,62.88 54.44,62.88 54.32,62.76 54.32,62.51 54.44,62.39 55.43,62.39 55.55,62.27 v2(55.55,61.48)
  BOTTOM w0.076: U0300.AT11 36.11,131.92 v6(36.24,131.92)
  BOTTOM w0.178: v2(55.55,61.48) 55.55,61.14 57.42,59.28 58.7,59.28 59.11,58.87 59.11,58.34 58.88,58.11 CON1701.110
M_CHB_CLK0: length 95
  TOP w0.089: CON1700.137 67.63,58.17 67.54,58.26 67.31,58.26 67.23,58.34 67.23,59.06 67.45,59.28 v2(67.74,59.28)
  IN4 w0.083: v2(67.74,59.28) 66.75,59.28 66.55,59.48 66.55,60.62 66.01,61.16 66.01,64.65 65.78,64.89 65.78,68.47 64.99,69.25 64.99,75.94 62.78,78.15 62.78,79.59 62.35,80.02 61.1,80.02 60.74,80.38 60.74,80.49 61.06,80.81 61.06,81.07 60.73,81.4 60.47,81.4 60.15,81.08 60.04,81.08 59.66,81.46 59.66,82.97 59.61,83.02 57.99,84.64 57.99,86.31 38.63,105.67 38.63,110.47 38.69,110.54 38.9,110.54 39.08,110.72 39.08,111.19 38.9,111.37 38.69,111.37 38.63,111.44 38.63,111.67 38.71,111.76 39.07,111.76 39.23,111.91 39.23,112.35 39.07,112.51 38.71,112.51 38.63,112.59 38.63,112.91 38.68,112.97 39.07,112.97 39.23,113.13 39.23,113.57 39.07,113.73 38.7,113.73 38.63,113.81 38.63,114.13 38.75,114.25 39.28,114.25 39.44,114.41 39.44,114.76 39.28,114.92 38.66,114.92 38.42,115.16 38.42,115.54 38.55,115.67 38.71,115.67 38.94,115.44 39.34,115.44 39.68,115.78 39.68,126.78 40.06,127.16 40.06,128.36 39.52,128.89 39.52,130.25 v6(39.9,130.62)
  BOTTOM w0.114: v6(39.9,130.62) 39.57,130.3 U0300.AM9
M_CHB_CLK0#: length 95
  TOP w0.089: v2(67.74,58.64) 68.13,58.26 CON1700.139
  IN4 w0.083: v6(38.98,130.62) 38.98,130.82 39.07,130.9 39.29,130.9 39.35,130.84 39.35,128.82 39.88,128.28 39.88,127.23 39.51,126.85 39.51,115.85 39.27,115.61 39.01,115.61 38.79,115.84 38.48,115.84 38.25,115.61 38.25,115.08 38.58,114.75 39.21,114.75 39.27,114.69 39.27,114.48 39.21,114.42 38.68,114.42 38.46,114.2 38.46,113.74 38.63,113.56 38.99,113.56 39.06,113.5 39.06,113.2 38.99,113.14 38.61,113.14 38.46,112.98 38.46,112.52 38.64,112.34 38.99,112.34 39.06,112.28 39.06,111.98 39,111.93 38.64,111.93 38.46,111.74 38.46,111.36 38.62,111.2 38.83,111.2 38.91,111.12 38.91,110.79 38.83,110.71 38.62,110.71 38.46,110.54 38.46,105.6 57.82,86.24 57.82,84.57 59.49,82.9 59.49,82.85 59.49,82.85 59.49,81.39 59.97,80.91 60.22,80.91 60.54,81.23 60.66,81.23 60.89,81 60.89,80.88 60.57,80.56 60.57,80.31 61.03,79.85 62.28,79.85 62.61,79.52 62.61,78.08 64.82,75.87 64.82,69.18 65.6,68.4 65.6,64.81 65.84,64.58 65.84,61.08 66.38,60.55 66.38,59.41 66.68,59.1 67.28,59.1 v2(67.74,58.64)
  BOTTOM w0.114: v6(38.98,130.62) 38.85,130.62 U0300.AN9
M_CHB_CLK1: length 97.2
  TOP w0.089: v2(66.57,61.98) 66.7,61.85 68.15,61.85 68.76,62.46 68.76,63.69 68.5,63.95 68.41,64.04 68.29,64.04 68.22,63.97 68.22,63.64 68.13,63.56 68.02,63.56 67.92,63.66 67.92,64.15 67.88,64.2 CON1700.138
  IN4 w0.076: 39.72,114.39 39.72,114.41 39.72,114.41 39.72,114.46 39.72,114.47 39.72,114.57 39.87,114.72 39.87,126.71 40.28,127.13 40.28,129.35 40.17,129.47 40.05,129.47 v6(39.91,129.32)
  IN4 w0.083: 39.72,114.39 39.72,110.65 39.14,110.08 39.14,105.85 58.48,86.51 58.48,84.87 58.98,84.37 59.37,84.37 60.63,83.11 60.63,82.64 62.61,80.67 62.87,80.67 63.16,80.96 63.16,81.27 62.99,81.44 62.99,81.58 63.11,81.71 63.33,81.71 63.71,81.33 63.94,81.1 63.94,80.89 63.2,80.14 63.2,79.88 63.58,79.49 63.82,79.49 64.16,79.83 64.29,79.83 64.45,79.68 64.45,79.36 63.68,78.59 63.68,77.94 63.98,77.64 64.36,77.64 64.54,77.81 64.54,78.03 64.64,78.13 65.33,78.13 65.48,77.98 65.48,77.49 65.41,77.41 65.03,77.41 64.82,77.2 64.82,76.8 65.48,76.14 65.48,69.46 65.66,69.28 66.01,69.28 66.22,69.49 66.22,70.11 66.29,70.18 66.45,70.18 66.58,70.05 66.58,68.38 66.26,68.07 66.26,65.41 66.82,64.85 66.82,62.07 66.73,61.98 v2(66.57,61.98)
  BOTTOM w0.076: v6(39.91,129.32) 39.5,129.32 39.44,129.26 U0300.AM7
M_CHB_CLK1#: length 97.2
  TOP w0.089: CON1700.140 68.38,64.41 68.48,64.3 68.6,64.18 68.99,63.79 68.99,62.37 68.24,61.62 66.84,61.62 v2(66.59,61.37)
  IN4 w0.076: v6(39.91,129.97) 40.11,129.77 40.11,129.76 40.45,129.42 40.45,127.06 40.03,126.64 40.03,114.65 39.89,114.51 39.89,114.39
  IN4 w0.083: 39.89,114.39 39.89,110.58 39.31,110 39.31,105.92 58.65,86.58 58.65,84.94 59.05,84.54 59.44,84.54 60.8,83.18 60.8,82.72 62.68,80.84 62.8,80.84 62.99,81.03 62.99,81.2 62.81,81.37 62.81,81.65 63.04,81.88 63.4,81.88 63.83,81.45 64.11,81.17 64.11,80.82 63.37,80.07 63.37,79.95 63.65,79.67 63.75,79.67 64.08,80 64.36,80 64.62,79.75 64.62,79.29 63.85,78.52 63.85,78.01 64.05,77.81 64.29,77.81 64.36,77.88 64.36,78.1 64.57,78.3 65.41,78.3 65.65,78.05 65.65,77.42 65.48,77.24 65.1,77.24 64.99,77.13 64.99,76.87 65.65,76.21 65.65,69.53 65.73,69.46 65.94,69.46 66.05,69.56 66.05,70.18 66.22,70.35 66.52,70.35 66.75,70.12 66.75,68.31 66.44,68 66.44,65.48 66.99,64.92 66.99,61.77 v2(66.59,61.37)
  BOTTOM w0.076: v6(39.91,129.97) 39.76,129.97 U0300.AM8
M_CHB_CLK2: length 98.4
  IN4 w0.076: 40.55,119.65 40.55,119.72 40.37,119.89 40.37,126.5 40.82,126.95 40.82,129.52 40.44,129.9 40.44,131.38 v6(39.9,131.92)
  IN4 w0.083: 40.55,119.65 40.55,110.21 40.12,109.79 40.12,108.39 42.05,106.46 42.05,104.21 56.93,89.33 57.04,89.33 57.47,89.76 57.76,89.76 58.16,89.36 58.16,89.12 57.7,88.67 57.7,88.55 58.49,87.77 58.6,87.77 59.02,88.18 59.28,88.18 59.68,87.78 59.68,87.52 59.27,87.11 59.27,86.99 59.99,86.27 59.99,86.01 59.68,85.69 59.51,85.52 59.51,85.41 59.74,85.18 59.85,85.18 60.92,86.24 61.15,86.24 61.48,85.91 61.48,85.63 60.44,84.59 60.44,84.47 60.67,84.24 60.79,84.24 61.85,85.31 62.09,85.31 62.42,84.98 62.42,84.7 61.38,83.65 61.38,83.54 61.61,83.31 61.72,83.31 62.21,83.79 62.46,83.79 62.8,83.45 62.92,83.45 63.39,83.92 63.62,83.92 64.02,83.52 64.02,83.24 63.58,82.79 63.58,82.68 66.31,79.94 66.31,75.78 66.79,75.31 66.79,72.39 66.47,72.07 66.47,71.35 67.42,70.39 67.42,65.44 67.45,65.4 67.92,64.94 67.92,63.5 v2(67.5,63.09)
  BOTTOM w0.076: U0300.AM11 39.76,131.92 v6(39.9,131.92)
  BOTTOM w0.114: v2(67.5,63.09) 66.09,63.09 65.63,63.55 CON1701.137
M_CHB_CLK2#: length 98.4
  IN4 w0.076: v6(39.9,131.27) 40.03,131.41 40.17,131.41 40.28,131.31 40.28,129.83 40.65,129.45 40.65,127.01 40.21,126.57 40.21,119.82 40.38,119.65 40.38,119.65
  IN4 w0.083: 40.38,119.65 40.38,110.28 39.95,109.86 39.95,108.32 41.88,106.39 41.88,104.14 56.85,89.16 57.11,89.16 57.54,89.59 57.69,89.59 57.99,89.29 57.99,89.19 57.53,88.74 57.53,88.48 58.42,87.6 58.68,87.6 59.09,88.01 59.21,88.01 59.51,87.71 59.51,87.59 59.09,87.18 59.09,86.92 59.82,86.19 59.82,86.08 59.34,85.59 59.34,85.34 59.66,85.01 59.92,85.01 60.99,86.07 61.08,86.07 61.31,85.84 61.31,85.7 60.27,84.66 60.27,84.4 60.6,84.07 60.86,84.07 61.93,85.14 62.02,85.14 62.25,84.91 62.25,84.77 61.21,83.72 61.21,83.47 61.53,83.14 61.79,83.14 62.28,83.62 62.39,83.62 62.73,83.28 62.99,83.28 63.46,83.75 63.55,83.75 63.85,83.45 63.85,83.31 63.41,82.86 63.41,82.61 66.14,79.87 66.14,75.71 66.62,75.24 66.62,72.46 66.29,72.14 66.29,71.28 67.25,70.32 67.25,65.36 67.75,64.86 67.75,63.97 v2(67.5,63.72)
  BOTTOM w0.076: U0300.AM10 39.44,131.17 39.57,131.31 39.86,131.31 v6(39.9,131.27)
  BOTTOM w0.114: v2(67.5,63.72) 67.26,63.72 67.2,63.66 67.2,63.42 67.13,63.35 66.2,63.35 65.89,63.66 65.89,63.9 65.94,63.95 66.55,63.95 66.62,64.03 66.62,64.2 66.56,64.27 66.26,64.27 66.13,64.4 CON1701.139
M_CHB_CLK3: length 99.4
  IN4 w0.076: v6(41.75,130.61) 41.59,130.78 41.5,130.78 41.34,130.62 41.34,126.91 40.7,126.27 40.7,121.3 41.08,120.93 41.08,120.93 41.09,120.92
  IN4 w0.083: v2(67.28,60.4) 67.6,60.4 67.69,60.5 67.69,61.56 68.58,62.44 68.58,65.21 68.08,65.71 68.08,68.84 68.17,68.93 68.37,68.93 68.58,69.14 68.58,70.17 67.69,71.06 67.69,71.95 67.45,72.19 67.45,75.14 67.52,75.21 68.05,75.21 68.21,75.37 68.21,75.83 68.06,75.98 67.05,75.98 66.97,76.06 66.97,76.4 67.04,76.47 67.56,76.47 67.76,76.67 67.76,77.08 67.52,77.33 67.06,77.33 66.99,77.4 66.99,77.62 67.04,77.67 67.39,77.67 67.59,77.86 67.59,78.43 67.39,78.62 67.08,78.62 66.97,78.72 66.97,80.66 65.77,81.87 65.77,82.73 50.62,97.87 50.36,97.87 50.16,97.67 50.04,97.67 49.81,97.9 49.81,98.01 50.01,98.22 50.01,98.48 49.68,98.81 49.43,98.81 49.22,98.6 49.1,98.6 48.88,98.83 48.88,98.95 49.08,99.15 49.08,99.41 48.75,99.74 48.49,99.74 48.29,99.54 48.17,99.54 47.94,99.77 47.94,99.88 48.14,100.09 48.14,100.35 47.81,100.68 47.56,100.68 47.35,100.47 47.23,100.47 47.01,100.7 47.01,100.82 47.21,101.02 47.21,101.28 46.88,101.61 46.62,101.61 46.42,101.41 46.3,101.41 46.07,101.64 46.07,101.75 46.27,101.96 46.27,102.22 45.94,102.55 45.69,102.55 45.48,102.34 45.36,102.34 45.14,102.57 45.14,102.69 45.34,102.89 45.34,103.15 45.01,103.48 44.75,103.48 44.52,103.25 44.35,103.25 44.19,103.42 44.19,103.61 44.41,103.83 44.41,104.09 44.07,104.42 43.82,104.42 43.38,103.98 43.27,103.98 43.04,104.21 43.04,104.33 43.47,104.76 43.47,105.02 43.02,105.47 43.02,106.77 42.12,107.68 42.12,109.48 41.21,110.39 41.21,120.8 41.09,120.92
  BOTTOM w0.076: v6(41.75,130.61) 41.39,130.61 41.27,130.73 U0300.AJ10
  BOTTOM w0.114: CON1701.138 65.88,58.13 65.95,58.2 66.03,58.2 66.11,58.28 66.11,58.86 67.39,60.13 67.39,60.29 v2(67.28,60.4)
M_CHB_CLK3#: length 99.4
  IN4 w0.076: 40.97,120.8 40.96,120.81 40.96,120.81 40.54,121.23 40.54,126.33 41.18,126.97 41.18,130.69 v6(41.75,131.26)
  IN4 w0.083: v2(67.28,61.04) 67.52,61.28 67.52,61.63 68.41,62.51 68.41,65.14 67.91,65.64 67.91,68.91 68.1,69.1 68.3,69.1 68.41,69.21 68.41,70.1 67.52,70.99 67.52,71.88 67.28,72.12 67.28,75.21 67.45,75.39 67.98,75.39 68.04,75.45 68.04,75.76 67.99,75.81 66.98,75.81 66.8,75.99 66.8,76.47 66.97,76.64 67.49,76.64 67.59,76.74 67.59,77.01 67.45,77.15 66.99,77.15 66.81,77.33 66.81,77.69 66.97,77.84 67.32,77.84 67.41,77.93 67.41,78.36 67.32,78.45 67.01,78.45 66.8,78.65 66.8,80.59 65.59,81.79 65.59,82.66 50.55,97.7 50.43,97.7 50.23,97.5 49.97,97.5 49.64,97.83 49.64,98.09 49.84,98.29 49.84,98.41 49.61,98.64 49.5,98.64 49.29,98.43 49.03,98.43 48.7,98.76 48.7,99.02 48.91,99.22 48.91,99.34 48.68,99.57 48.56,99.57 48.36,99.37 48.1,99.37 47.77,99.7 47.77,99.96 47.97,100.16 47.97,100.28 47.74,100.51 47.63,100.51 47.42,100.3 47.16,100.3 46.83,100.63 46.83,100.89 47.04,101.09 47.04,101.21 46.81,101.44 46.69,101.44 46.49,101.24 46.23,101.24 45.9,101.57 45.9,101.83 46.1,102.03 46.1,102.15 45.87,102.38 45.76,102.38 45.55,102.17 45.29,102.17 44.96,102.5 44.96,102.76 45.17,102.96 45.17,103.08 44.94,103.31 44.82,103.31 44.59,103.08 44.28,103.08 44.02,103.34 44.02,103.68 44.23,103.9 44.23,104.02 44,104.25 43.89,104.25 43.45,103.81 43.19,103.81 42.87,104.14 42.87,104.4 43.3,104.83 43.3,104.95 42.85,105.4 42.85,106.7 41.95,107.61 41.95,109.41 41.04,110.32 41.04,120.73 40.97,120.8
  BOTTOM w0.076: U0300.AJ11 41.6,131.26 v6(41.75,131.26)
  BOTTOM w0.114: CON1701.140 66.38,58.75 67.74,60.11 67.74,60.57 v2(67.28,61.04)
M_CHB_CS#0: length 93.6
  TOP w0.222: v2(71.88,59.1) 72.11,59.1 72.63,58.58 CON1700.149
  IN4 w0.076: v6(44.45,131.28) 45,130.73 45,129.17 45.05,129.12 45.05,125.53 45.72,124.86 45.72,122.23 45.84,122.1 45.84,121.75 46.38,121.21 46.38,119.7
  IN4 w0.121: 46.38,119.7 48.59,117.49 48.59,113.61 52.11,110.09 52.11,107.63 63.53,96.21 64.77,96.21 74.82,86.17 74.82,84.17 75.31,83.68 75.31,80.41 75.79,79.93 75.79,78.4 77.36,76.83 77.36,71.5 77.56,71.31 77.56,70.19 76.22,68.86 76.22,66.47 75.82,66.06 75.82,61.62 74.97,60.77 74.97,59.37 74.7,59.1 v2(71.88,59.1)
  BOTTOM w0.076: U0300.AF11 44.33,131.28 v6(44.45,131.28)
M_CHB_CS#1: length 96.5
  TOP w0.222: v2(76.33,62.88) 76.12,62.88 75.8,62.56 75.8,61.32 75.51,61.02 75.51,59.82 74.63,58.94 CON1700.157
  IN4 w0.076: 46.57,120 46.57,121.25 46.01,121.82 46.01,122.17 45.89,122.29 45.89,124.93 45.22,125.6 45.22,128.32 45.37,128.48 v6(45.37,129.32)
  IN4 w0.121: 46.57,120 49.02,117.55 49.02,113.78 52.58,110.22 52.58,107.77 63.7,96.64 64.95,96.64 75.71,85.87 75.71,83.9 75.92,83.7 76.49,83.7 76.67,83.52 76.67,83.38 76.55,83.26 75.86,83.26 75.74,83.14 75.74,82.93 75.84,82.83 76.52,82.83 76.66,82.7 76.66,82.51 76.55,82.4 75.86,82.4 75.74,82.28 75.74,82.06 75.84,81.97 76.52,81.97 76.67,81.82 76.67,81.61 76.58,81.53 75.9,81.53 75.73,81.36 75.73,81.03 75.82,80.95 76.72,80.95 76.8,80.87 76.8,80.24 76.61,80.05 76.35,80.05 76.24,79.94 76.24,78.56 77.79,77.01 77.79,71.68 78.24,71.22 78.24,70.28 78.02,70.06 78.02,69.89 78.16,69.76 78.16,69.61 77.98,69.44 77.79,69.44 77.68,69.55 77.51,69.55 77.34,69.38 77.34,69.21 77.5,69.05 77.5,68.88 77.33,68.71 77.16,68.71 77,68.87 76.83,68.87 76.65,68.68 76.65,68.4 76.71,68.34 77.05,68.34 77.16,68.24 77.16,67.74 76.65,67.24 76.65,66.29 76.33,65.97 v2(76.33,62.88)
  BOTTOM w0.076: U0300.AE7 45.25,129.32 v6(45.37,129.32)
M_CHB_CS#2: length 99.6
  IN4 w0.076: 46.15,121.18 45.68,121.65 45.68,122.03 45.56,122.16 45.56,124.79 44.85,125.5 44.85,128.89 44.84,128.9 44.84,130.23 v6(44.45,130.62)
  IN4 w0.121: v2(74.42,60.9) 74.5,60.9 75.39,61.79 75.39,66.24 75.8,66.64 75.8,69.04 76.72,69.96 76.72,71.31 76.94,71.52 76.94,76.66 75.37,78.23 75.37,79.76 74.88,80.24 74.88,83.51 74.39,83.99 74.39,85.99 64.59,95.79 63.35,95.79 51.69,107.45 51.69,109.91 51.51,110.09 51.34,110.09 50.31,109.06 50.14,109.06 49.97,109.23 49.97,109.41 50.99,110.43 50.99,110.6 50.77,110.83 50.6,110.83 49.85,110.08 49.7,110.08 49.44,110.33 49.44,110.53 50.17,111.25 50.17,111.42 49.92,111.68 49.75,111.68 49.45,111.39 49.28,111.39 49.03,111.64 49.03,111.82 49.32,112.11 49.32,112.28 49.06,112.53 48.89,112.53 48.6,112.24 48.43,112.24 48.17,112.5 48.17,112.67 48.47,112.96 48.47,113.13 48.06,113.54 48.06,117.58 46.15,119.48 46.15,121.18
  BOTTOM w0.076: v6(44.45,130.62) 44.34,130.62 U0300.AF10
  BOTTOM w0.222: v2(74.42,60.9) 74.18,60.9 72.9,62.18 72.12,62.18 70.63,63.68 CON1701.149
M_CHB_CS#3: length 101.4
  IN4 w0.076: v6(45.38,131.27) 45.38,131.14 45.75,130.78 45.75,130.46 46.07,130.14 46.07,128.47 45.71,128.12 45.71,125.88 47.1,124.49 47.1,120.9 47.13,120.87
  IN4 w0.121: 47.13,120.87 50.37,117.63 50.37,114.24 54.55,110.06 54.55,109.89 54.12,109.47 54.12,109.3 54.29,109.12 54.46,109.12 54.89,109.55 55.06,109.55 55.23,109.38 55.23,109.21 54.8,108.78 54.8,108.61 54.97,108.44 55.15,108.44 55.57,108.87 55.74,108.87 55.91,108.7 55.91,108.53 55.49,108.1 55.49,107.93 55.66,107.76 55.83,107.76 56.25,108.18 56.42,108.18 56.59,108.01 56.59,107.84 56.3,107.54 56.3,107.37 56.47,107.2 56.64,107.2 56.94,107.5 57.11,107.5 59.03,105.57 59.03,103.14 64.26,97.92 65.48,97.92 76.99,86.4 76.99,85.01 78.66,83.33 78.66,80.54 79.46,79.74 79.46,77.85 79.52,77.8 79.52,69.08 78.43,68 78.43,66.27 77.61,65.45 77.61,61.06 76.57,60.02 v2(75.98,60.02)
  BOTTOM w0.076: v6(45.38,131.27) 45.25,131.27 U0300.AE10
  BOTTOM w0.222: v2(75.98,60.02) 76.18,60.02 76.44,60.28 76.44,60.84 73.65,63.64 73.31,63.64 72.63,64.33 CON1701.157
M_CHB_DQ0: length 92.5
  TOP w0.159: CON1700.3 34.13,57.92 33.38,58.66 v2(33.35,58.66) ; v1(16.67,130.48) 17.28,130.48 v2(17.42,130.34)
  IN4 w0.108: v2(17.42,130.34) 16.71,130.34 14.03,127.66 14.03,125.14 13.75,124.86 13.75,93.78 21.98,85.55 21.98,85.01 27.61,79.38 27.61,70.93 29.61,68.93 29.61,64.84 32.1,62.35 33.08,62.35 33.75,61.68 33.75,60.64 32.66,59.55 32.66,58.92 32.92,58.66 v2(33.35,58.66)
  BOTTOM w0.076: 18.93,130.58 19.72,130.58 20.56,131.43 21.48,131.43 U0300.BT11
  BOTTOM w0.159: v2(33.35,58.66) 33.38,58.64 CON1701.8 ; 18.93,130.58 18.52,130.18 17.59,130.18 v2(17.42,130.34)
M_CHB_DQ1: length 94
  TOP w0.159: v2(33.35,59.3) 33.74,59.3 35.13,57.92 CON1700.7
  IN4 w0.108: v2(33.35,59.3) 34.1,60.05 34.1,61.81 33.22,62.69 32.24,62.69 29.94,64.98 29.94,69.07 27.95,71.07 27.95,79.51 22.41,85.05 22.41,85.6 14.09,93.92 14.09,119.8 14.23,119.94 14.23,127.22 v2(16.89,129.89)
  BOTTOM w0.076: 18.41,129.71 19.11,130.41 19.77,130.41 20.61,131.24 21.22,131.24 21.24,131.22 21.92,131.22 U0300.BR11
  BOTTOM w0.159: v2(33.35,59.3) 32.82,59.3 32.19,58.67 32.19,58.36 32.38,58.18 CON1701.4 ; v1(16.89,129.25) v2(16.89,129.89) 17.07,129.71 18.41,129.71
M_CHB_DQ2: length 95.1
  TOP w0.159: v2(36.46,60.83) 37.39,59.9 37.39,59.22 38.04,58.56 38.3,58.56 38.63,58.24 CON1700.21
  IN4 w0.108: v7(18.49,129.2) 18.49,128.49 16.53,126.53 16.53,120.77 16,120.24 16,95.49 29.86,81.63 29.86,77.72 33.75,73.82 33.75,72.18 33.39,71.81 33.08,71.51 33.08,71.25 32.44,70.61 32.44,69.95 32.55,69.84 32.69,69.84 32.79,69.73 32.79,69.46 32.69,69.35 32.55,69.35 32.44,69.25 32.44,68.97 32.55,68.86 32.69,68.86 32.79,68.76 32.79,66.81 32.79,65.7 32.79,65.7 32.79,65.22 34.71,63.31 34.71,62.95 35.34,62.32 35.34,61.62 35.6,61.37 35.6,59.83 35.66,59.76 35.89,59.76 35.96,59.82 35.96,60.33 v2(36.46,60.83)
  BOTTOM w0.076: v7(18.49,129.2) 19.17,129.2 19.4,129.43 20.26,129.43 20.57,129.73 U0300.BT8
  BOTTOM w0.159: v2(36.46,60.83) 36.05,60.83 35.86,60.64 35.86,58.99 35.61,58.74 35.1,58.74 34.98,58.62 34.98,58.41 35.08,58.31 35.31,58.31 35.38,58.24 CON1701.16
M_CHB_DQ3: length 93.6
  TOP w0.159: CON1700.17 37.63,58.43 37.11,58.95 37,59.06 37,59.58 v2(36.46,60.13)
  IN4 w0.076: 18.28,128.01 18.94,128.67 v6(18.94,129.68)
  IN4 w0.108: v2(36.46,60.13) 36.29,59.96 36.29,59.3 36.42,59.17 36.98,59.17 37.11,59.3 37.11,60.83 36.7,61.24 36.2,61.24 35.68,61.76 35.68,62.46 35.05,63.09 35.05,63.45 33.13,65.36 33.13,65.84 33.13,70.31 33.42,70.6 33.42,71.37 34.09,72.04 34.09,73.96 30.2,77.86 30.2,81.77 16.34,95.63 16.34,120.3 16.73,120.69 16.73,126.45 18.28,128.01
  BOTTOM w0.076: v6(18.94,129.68) 19.04,129.59 20.19,129.59 20.57,129.96 20.78,129.96 20.88,130.06 21.76,130.06 21.86,129.96 U0300.BR8
  BOTTOM w0.159: CON1701.20 36.38,58.05 36.22,58.21 36.04,58.21 35.94,58.31 35.94,58.52 36.29,58.88 36.29,60.03 36.39,60.13 v2(36.46,60.13)
M_CHB_DQ4: length 94.9
  TOP w0.159: CON1700.4 34.38,64.46 34.12,64.21 32.65,64.21 v2(32.28,63.85)
  IN4 w0.108: v6(19.9,131.42) 19.62,131.71 19.02,131.71 18.89,131.58 18.89,131.39 19.06,131.21 19.06,131.06 18.95,130.95 18.79,130.95 18.5,131.24 18.35,131.24 18.16,131.04 18.16,130.89 18.45,130.6 18.45,130.45 15.75,127.75 15.75,122.95 14.73,121.93 14.73,120.29 14.76,120.26 14.76,94.44 26.22,82.97 26.22,82.83 25.97,82.58 25.97,82.44 26.07,82.35 26.21,82.35 26.46,82.6 26.6,82.6 26.7,82.5 26.7,82.36 26.45,82.11 26.45,81.97 26.55,81.87 26.69,81.87 26.94,82.12 27.08,82.12 27.17,82.02 27.17,81.88 26.92,81.63 26.92,81.49 27.02,81.39 27.16,81.39 27.41,81.64 27.55,81.64 27.65,81.55 27.65,81.41 27.4,81.16 27.4,81.02 27.5,80.92 27.64,80.92 27.89,81.17 28.03,81.17 28.62,80.57 28.62,72.23 30.94,69.91 30.94,68.73 30.84,68.63 30.73,68.63 30.63,68.54 30.63,68.4 30.73,68.3 30.84,68.3 30.94,68.2 30.94,68.06 30.84,67.96 30.73,67.96 30.63,67.86 30.63,67.72 30.73,67.62 30.84,67.62 30.94,67.53 30.94,65.19 v2(32.28,63.85)
  BOTTOM w0.076: v6(19.9,131.42) 20.31,131.42 20.49,131.6 21.1,131.6 21.34,131.84 22.38,131.84 22.69,131.54 U0300.BP11
  BOTTOM w0.159: CON1701.7 33.13,64.27 33.5,63.9 33.5,63.72 33.28,63.49 33.1,63.49 32.75,63.85 v2(32.28,63.85) ; v1(18.26,130.65) 18.54,130.93 19.41,130.93 v6(19.9,131.42)
