# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D62: length 42.2
  IN1 w0.095: v6(121.66,160.01) 122.3,160.65 122.3,160.97 122.91,161.58 123.46,161.58 124.2,162.32 125.91,162.32 126.27,162.68 127.62,162.68 129.37,164.43 129.37,164.93 133.19,168.75 133.19,171.63 137.49,175.93 138.29,175.93 139.03,176.67 148.87,176.67 149.25,177.05 149.25,177.71 149.77,178.22 150.38,178.22 v6(151.56,179.41)
  BOTTOM w0.133: U7000.L48 121.21,160.01 v6(121.66,160.01) ; U7701.M2 v6(151.56,179.41)
FBB_D63: length 42.9
  IN1 w0.095: v6(121.66,160.61) 122.92,161.88 123.49,161.88 124.19,162.57 125.81,162.57 126.2,162.97 127.5,162.97 129.09,164.55 129.09,165.05 132.91,168.87 132.91,171.75 137.37,176.21 138.18,176.21 139.64,177.68 140.73,177.68 141.01,177.41 141.84,177.41 142.64,178.22 148.76,178.22 149.43,178.88 149.43,179.39 149.82,179.79 151.98,179.79 v6(152.35,179.42)
  BOTTOM w0.133: v6(121.66,160.61) 121.01,160.61 U7000.L49 ; U7701.N2 v6(152.35,179.42)
FBB_DEBUG0: length 8
  BOTTOM w0.102: R7110.1 132.49,146.06 132.19,145.77 132.19,145.21 v1(131.83,144.85) 131.55,144.85 131.05,144.34 130.48,143.78 128.17,143.78 128.04,143.91 126.7,143.91 U7000.D29
FBB_DEBUG1: length 3.8
  TOP w0.089: v6(128.29,154.26) 128.29,153.59 v1(128.82,153.06) 129.11,153.35 R7111.1
  BOTTOM w0.102: U7000.C41 127.46,154.26 v6(128.29,154.26)
FBB_DQM0: length 34.8
  IN1 w0.095: v6(152.43,155.59) 150.39,153.55 148.33,153.55 147.84,153.06 145.89,153.06 145.42,153.53 140.33,153.53 130.7,143.9 v6(125.9,143.9)
  BOTTOM w0.133: U7700.D2 151.61,157.17 151.61,156.4 v6(152.43,155.59) ; U7000.E29 v6(125.9,143.9)
FBB_DQM1: length 37.5
  IN4 w0.095: v6(123.5,147.91) 123.88,148.29 123.88,148.88 124.61,149.62 127.59,149.62 128.31,150.33 129.63,150.33 135.87,156.57 135.87,157.66 140.61,162.4 142.37,162.4 142.88,162.91 144.25,162.91 144.65,163.31 145.49,163.31 146.92,164.74 147.78,164.74 148.87,165.83 148.87,166.18 149.07,166.39 150.55,166.39 v6(150.88,166.72)
  BOTTOM w0.133: U7000.G33 v6(123.5,147.91) ; v6(150.88,166.72) 151.24,166.35 U7700.D13
FBB_DQM2: length 30.7
  IN4 w0.095: v6(143.64,166.74) 143.12,167.25 141.17,167.25 140.84,167.59 140.48,167.59 140.23,167.84 139.17,167.84 135.61,164.28 135.61,163.47 129.19,157.04 126,157.04 123.11,154.15 123.11,152.56 122.7,152.15 v6(122.7,151.9)
  BOTTOM w0.133: U7700.P13 143.61,166.71 143.61,166.72 v6(143.64,166.74) ; v6(122.7,151.9) U7000.H38
FBB_DQM3: length 21.4
  IN2 w0.146: v6(127.39,150.62) 127.39,150.76 129.06,152.43 132.68,152.43 139.51,159.25 142.17,159.25 142.46,158.97 142.46,158.33 v6(142.86,157.93)
  BOTTOM w0.133: U7700.P2 v6(142.86,157.93) ; v6(127.39,150.62) 127.1,150.33 U7000.C36
FBB_DQM4: length 43.4
  IN2 w0.146: v6(117.91,154.3) 118.29,154.68 118.29,155.4 118.06,155.63 118.06,160.3 118.84,161.07 120.02,161.07 123.69,164.74 126.22,164.74 126.82,165.34 129.67,165.34 131.01,166.68 133.23,166.68 142.59,176.04 143.51,176.04 144.81,177.34 144.81,179.1 v6(145.14,179.43)
  BOTTOM w0.133: U7701.D2 v6(145.14,179.43) ; U7000.P41 v6(117.91,154.3)
FBB_DQM5: length 45.8
  IN1 w0.089: v6(118.69,159.89) 119.09,159.48 119.65,159.48 120.56,158.57 120.56,157.26 121.62,156.19 122.64,156.19 122.64,156.2
  IN1 w0.095: v6(144.38,170.62) 144.38,170.63 144.85,171.1 144.85,171.54 145.09,171.78 146.08,171.78 146.35,172.05 146.35,173.16 145.81,173.71 140.22,173.71 139.51,173 138.84,173 136.17,170.33 136.17,167.58 134.2,165.61 134.2,164.29 134.2,163.64 131.95,161.38 131.32,160.76 130.56,160.76 129.85,160.04 128.17,160.04 127.63,159.5 125.81,159.5 124.71,158.41 124.71,157.38 123.53,156.2 122.64,156.2
  BOTTOM w0.133: v6(144.38,170.62) 144.38,170.62 U7701.D13 ; U7000.P48 v6(118.69,159.89)
FBB_DQM6: length 34.7
  IN4 w0.095: v6(152.37,171.39) 151.82,170.83 150.83,170.83 149,169 141.07,169 140.51,169.56 138.83,169.56 129.95,160.67 127.47,160.67 126.27,159.48 125.48,159.48 125.25,159.25 124.5,159.25 v6(124.33,159.07)
  BOTTOM w0.133: v6(152.37,171.39) 152.38,171.39 U7701.P13 ; v6(124.33,159.07) 124.7,158.71 U7000.F47
FBB_DQM7: length 47.1
  IN1 w0.095: v6(121.13,158.33) 121.13,158.59 121.46,158.92 121.46,159.3 121.28,159.48 121.28,160.77 122.57,162.06 123.41,162.06 124.18,162.83 125.64,162.83 127.12,164.3 128.43,164.3 128.8,164.67 128.8,165.17 132.62,168.99 132.62,171.87 137.27,176.52 138.05,176.52 139.78,178.25 142.23,178.25 143,179.02 148.59,179.02 149.04,179.47 149.04,179.93 149.9,180.79 152.33,180.79 152.83,180.28 152.83,179.74 v6(153.16,179.41)
  BOTTOM w0.133: v6(121.13,158.33) U7000.L46 ; U7701.P2 v6(153.16,179.41)
FBB_DQS_WP0: length 37.1
  IN1 w0.095: v6(121.9,145.5) 122.28,145.12 127.66,145.12 127.89,145.35 127.89,145.62 128.39,146.12 130.43,146.12 139.55,155.24 147.35,155.24 147.93,155.82 149.98,155.82 150.46,156.31 150.46,157.31 151.11,157.95 v6(151.57,157.95)
  BOTTOM w0.133: U7000.J30 v6(121.9,145.5) ; U7700.C2 151.86,157.72 151.8,157.72 v6(151.57,157.95)
FBB_DQS_WP1: length 40.8
  IN4 w0.095: v6(122.68,147.92) 123.06,148.3 123.06,148.91 124.03,149.87 127.42,149.87 128.18,150.64 129.23,150.64 135.37,156.78 135.37,157.87 140.4,162.9 142.16,162.9 142.67,163.41 144.02,163.41 144.42,163.82 145.29,163.82 146.11,164.64 146.11,165.35 147.25,166.49 147.25,166.91 147.55,167.22 151.16,167.22 151.62,166.76 v6(151.62,165.92)
  BOTTOM w0.133: v6(122.68,147.92) 123.1,147.5 U7000.H33 ; v6(151.62,165.92) 151.62,165.92 U7700.C13
FBB_DQS_WP2: length 27.3
  IN4 w0.095: v6(142.03,166.75) 141.59,166.31 140.41,166.31 139.8,165.69 139.36,165.69 129.79,156.12 126.64,156.12 126.39,155.87 125.62,155.87 125.12,155.37 125.12,154.93 124.61,154.42 124.61,153.08 v6(124.31,152.78)
  BOTTOM w0.133: U7000.D39 125.86,152.74 124.92,152.74 124.89,152.78 v6(124.31,152.78) ; U7700.R13 142.44,166.34 v6(142.03,166.75)
FBB_DQS_WP3: length 25.3
  IN2 w0.089: v6(121.87,148.67) 122.6,149.4 124.73,149.4 125.01,149.68 128.28,149.68
  IN2 w0.146: v6(142.04,157.09) 141.6,157.53 140.29,157.53 140.02,157.26 139.59,157.26 133.27,150.93 130.42,150.93 129.67,150.19 128.78,150.19 128.28,149.68
  BOTTOM w0.133: v6(142.04,157.09) 142.24,157.29 142.24,157.34 U7700.R2 ; U7000.J35 v6(121.87,148.67)
FBB_DQS_WP4: length 41.9
  IN2 w0.146: v6(117.1,155.05) 117.57,155.51 117.57,160.56 118.62,161.61 119.16,161.61 123.88,166.33 129.26,166.33 130.6,167.67 132.42,167.67 141.61,176.86 141.91,176.86 142.51,177.46 142.51,178.33 143.22,179.03 143.97,179.03 v6(144.35,179.42)
  BOTTOM w0.133: U7000.R42 117.33,154.87 117.28,154.87 v6(117.1,155.05) ; U7701.C2 143.97,179.8 v6(144.35,179.42)
FBB_DQS_WP5: length 39.6
  IN1 w0.089: v6(119.33,158.92) 119.48,158.92 120.2,158.2 120.2,157.11 121.48,155.83 122.88,155.83
  IN1 w0.095: v6(144.33,171.4) 143.97,171.77 143.97,172.4 143.75,172.62 142.53,172.62 142.3,172.86 140.48,172.86 139.84,172.21 139.17,172.21 136.96,169.99 136.96,167.25 134.99,165.29 134.99,162.78 134.32,162.1 134.32,161.79 132.5,159.97 130.69,159.97 128.63,157.9 125.76,157.9 125.16,157.3 123.68,155.83 122.88,155.83
  BOTTOM w0.133: U7000.M48 119.61,159.21 119.61,159.2 v6(119.33,158.92) ; v6(144.33,171.4) 144.11,171.18 144.11,171.15 U7701.C13
FBB_DQS_WP6: length 37.2
  IN4 w0.095: v6(125.35,161.38) 125.76,160.97 126.41,160.97 127.94,162.5 128.31,162.5 131.49,165.68 132.87,165.68 138.48,171.29 139.5,171.29 142.23,174.02 148.06,174.02 148.55,174.52 150.77,174.52 152.79,172.49 152.79,171.79 v6(153.16,171.41)
  BOTTOM w0.133: U7701.R13 153.57,171.01 v6(153.16,171.41) ; v6(125.35,161.38) 125.35,161.12 124.7,160.48 U7000.F49
FBB_DQS_WP7: length 46.5
  IN1 w0.095: v6(123.48,159.88) 123.48,160.45 124.03,161 126.09,161 127.03,161.95 128.07,161.95 128.14,162.01 130.35,162.01 132.63,164.29 132.63,166.27 134.59,168.23 134.59,171.11 138.05,174.57 138.86,174.57 139.59,175.31 152.99,175.31 154.41,176.72 154.41,178.96 v6(153.95,179.42)
  BOTTOM w0.133: U7000.J47 122.69,159.09 122.69,159.67 122.9,159.88 v6(123.48,159.88) ; U7701.R2 v6(153.95,179.42)
FBB_MF1: length 3.6
  TOP w0.203: v1(146.92,153.58) 146.92,154.44 R7715.2 R7716.1 146.56,155.79 v6(146.99,156.22)
  BOTTOM w0.203: v6(146.99,156.22) 147.24,156.48 U7700.J1
FBB_MF2: length 5
  BOTTOM w0.102: v1(147.22,184.43) 147.16,184.36 147.16,182.8 R7718.1
  BOTTOM w0.305: R7718.1 R7717.2 148.51,180.86 U7701.J1
FBB_VREF_CA1: length 23
  TOP w0.381: v6(148.22,169.75) 148.05,169.75 147.71,169.41 C7705.1 ; v6(147.71,167.64) C7705.1 ; C7705.1 R7710.1 R7711.2 C7703.1 148.45,167.11 148.86,166.71 150.12,166.71 150.65,167.24 151.35,167.24 151.61,166.97 155.34,166.97 156.39,165.93 156.39,165.12 v1(156.82,164.69) 157.21,164.29 157.21,163.94 157.53,163.62 v2(157.53,160.88)
  BOTTOM w0.305: v6(148.22,169.75) 148.31,169.75 U7701.J14 ; v6(147.71,167.64) 147.71,167.62 147.24,167.15 U7700.J14
  BOTTOM w0.381: R7709.2 158.29,161.64 v2(157.53,160.88)
FBB_VREF_DQ1: length 53.7
  TOP w0.305: v2(156.18,174.26) 156.76,174.83 v1(156.76,175.17)
  TOP w0.381: v6(142.8,173.04) 144.15,174.4 147.09,174.4 147.23,174.53 147.23,174.53 148.11,175.41 156.51,175.41 v1(156.76,175.17)
  IN1 w0.381: v2(156.18,174.26) 156.18,167.96 154.25,166.03 v6(154.25,164) 154.25,163.56 152.49,161.79 145.85,161.79 144.2,163.44 142.09,163.44 141.24,164.28 v6(141.24,164.3)
  BOTTOM w0.203: v6(142.8,173.04) 142.73,173.04 U7701.A10
  BOTTOM w0.305: U7700.U10 140.88,163.94 v6(141.24,164.3) ; C7704.1 155.26,173.5 U7701.U10 ; U7700.A10 154.2,163.94 154.25,163.99
  BOTTOM w0.381: R7708.2 157.4,161.56 157.02,161.18 155.55,161.18 155.32,161.41 R7700.1 R7701.2 C7700.1 154.97,163.94 154.31,163.94 154.25,163.99 v6(154.25,164) ; C7704.1 156.72,173.73 v2(156.18,174.26)
FBB_WCK01: length 43.3
  IN1 w0.102: v7(125.09,147.09) 125.09,147.29 125.49,147.7 125.49,148.14 126.47,149.12 129.87,149.12 132,151.25 132.14,151.25 132.38,151.01 132.69,151.01 133,151.32 133,151.62 132.75,151.86 132.75,152 132.95,152.2 133.1,152.2 133.34,151.96 133.64,151.96 133.95,152.27 133.95,152.57 133.71,152.81 133.71,152.96 133.91,153.15 134.05,153.15 134.29,152.91 134.59,152.91 134.9,153.22 134.9,153.52 134.66,153.76 134.66,153.91 134.86,154.11 135,154.11 135.24,153.87 135.54,153.87 135.85,154.18 135.85,154.48 135.61,154.72 135.61,154.86 135.81,155.06 135.95,155.06 136.19,154.82 136.5,154.82 136.81,155.13 136.81,155.43 136.57,155.67 136.57,155.81 136.76,156.01 136.91,156.01 137.15,155.77 137.45,155.77 137.76,156.08 137.76,156.38 137.52,156.62 137.52,156.77 137.72,156.96 137.86,156.96 138.1,156.72 138.4,156.72 138.71,157.03 138.71,157.33 138.47,157.58 138.47,157.72 139.9,159.15 142.69,159.15 144.49,160.95 146.62,160.95 146.72,160.85 146.72,160.45 146.93,160.24 147.37,160.24 147.58,160.45 147.58,160.85 147.68,160.95 150.74,160.95 151.42,160.27 151.42,160.09 151.34,160 150.93,160 150.85,159.92 v6(150.85,159.53)
  BOTTOM w0.133: v6(150.85,159.53) 151.06,159.53 151.24,159.34 U7700.D4 ; v7(125.09,147.09) 125.09,146.83 125.12,146.8 125.12,146.57 125.02,146.48 124.93,146.48 U7000.F32
FBB_WCK01#: length 43.2
  IN1 w0.102: v6(124.28,147.08) 124.71,147.51 125.03,147.51 125.3,147.78 125.3,148.22 126.39,149.31 129.79,149.31 131.92,151.44 132.22,151.44 132.46,151.2 132.61,151.2 132.8,151.4 132.8,151.54 132.56,151.78 132.56,152.08 132.87,152.39 133.18,152.39 133.42,152.15 133.56,152.15 133.76,152.35 133.76,152.49 133.52,152.73 133.52,153.03 133.83,153.34 134.13,153.34 134.37,153.1 134.51,153.1 134.71,153.3 134.71,153.44 134.47,153.69 134.47,153.99 134.78,154.3 135.08,154.3 135.32,154.06 135.46,154.06 135.66,154.25 135.66,154.4 135.42,154.64 135.42,154.94 135.73,155.25 136.03,155.25 136.27,155.01 136.42,155.01 136.62,155.21 136.62,155.35 136.38,155.59 136.38,155.89 136.68,156.2 136.99,156.2 137.23,155.96 137.37,155.96 137.57,156.16 137.57,156.3 137.33,156.54 137.33,156.85 137.64,157.15 137.94,157.15 138.18,156.91 138.32,156.91 138.52,157.11 138.52,157.26 138.28,157.5 138.28,157.8 139.82,159.34 142.61,159.34 144.41,161.14 146.69,161.14 146.91,160.93 146.91,160.53 147.01,160.43 147.29,160.43 147.39,160.53 147.39,160.93 147.6,161.14 150.82,161.14 151.63,160.33 v7(151.63,159.57)
  BOTTOM w0.133: U7700.D5 151.4,159.78 151.42,159.78 151.63,159.57 v7(151.63,159.57) ; U7000.G32 v6(124.28,147.08)
FBB_WCK23: length 43.2
  IN1 w0.102: v6(142.67,160.7) 142.2,160.23 141.53,160.23 141.4,160.35 141.4,161.21 141.71,161.51 143.98,161.51 144.22,161.75 144.22,162.5 143.98,162.74 140.42,162.74 140.18,162.5 140.18,161.99 140.08,161.89 139.71,161.89 139.5,161.68 139.5,161.24 139.71,161.03 140.08,161.03 140.18,160.93 140.18,160.33 140.08,160.23 139.57,160.23 139.41,160.07 135.42,156.08 134.66,155.31 134.51,155.31 134.38,155.44 134.08,155.44 133.77,155.13 133.77,154.83 133.9,154.7 133.9,154.56 133.7,154.36 133.56,154.36 133.43,154.48 133.13,154.48 132.82,154.17 132.82,153.87 132.95,153.75 132.95,153.6 131.62,152.28 131.48,152.28 130.87,152.89 130.66,153.09 130.33,153.09 129.96,152.73 129.96,152.39 130.6,151.75 130.78,151.58 130.78,151.43 130.49,151.14 130.35,151.14 129.84,151.65 129.54,151.65 129.03,151.14 129.03,150.81 129.48,150.37 129.48,150.24 129.18,149.94 128.64,149.94 128.34,150.24 127.54,150.24 127.14,149.84 126.01,149.84 125.69,149.52 124.12,149.52 124,149.65 124,150 v7(124.3,150.3)
  BOTTOM w0.133: v6(142.67,160.7) 142.85,160.52 142.85,159.53 U7700.P4 ; U7000.G36 123.9,150.18 124.02,150.3 v7(124.3,150.3)
FBB_WCK23#: length 43
  IN1 w0.102: v6(123.5,150.3) 123.81,150 123.81,149.57 124.04,149.33 125.77,149.33 126.09,149.65 127.22,149.65 127.62,150.05 128.26,150.05 128.56,149.75 129.26,149.75 129.67,150.16 129.67,150.45 129.22,150.89 129.22,151.07 129.62,151.46 129.76,151.46 130.27,150.95 130.57,150.95 130.97,151.35 130.97,151.65 130.73,151.89 130.15,152.47 130.15,152.65 130.4,152.9 130.58,152.9 130.73,152.75 131.4,152.09 131.7,152.09 133.14,153.52 133.14,153.83 133.01,153.95 133.01,154.1 133.21,154.29 133.35,154.29 133.48,154.17 133.78,154.17 134.09,154.48 134.09,154.78 133.96,154.9 133.96,155.05 134.16,155.25 134.31,155.25 134.43,155.12 134.73,155.12 139.55,159.93 139.65,160.03 140.16,160.03 140.37,160.25 140.37,161.01 140.16,161.22 139.79,161.22 139.69,161.32 139.69,161.6 139.79,161.7 140.16,161.7 140.37,161.91 140.37,162.42 140.5,162.55 143.9,162.55 144.03,162.42 144.03,161.83 143.9,161.7 141.63,161.7 141.21,161.29 141.21,160.27 141.45,160.03 142.28,160.03 142.56,160.31 142.87,160.31 v6(143.24,160.69)
  BOTTOM w0.133: U7000.H36 v6(123.5,150.3) ; U7700.P5 v6(143.24,160.69)
FBB_WCK45: length 40.1
  IN4 w0.102: v6(120.29,155.05) 120.53,155.05 120.6,154.98 120.6,154.63 120.65,154.58 120.96,154.58 121.02,154.63 121.02,156.43 120.3,157.15 120.3,160.23 124.38,164.32 125.9,164.32 131.34,169.76 133.27,169.76 137.38,173.88 138.6,173.88 141.15,176.43 143.57,176.43 144.58,177.44 144.58,177.59 v7(144.37,177.79)
  BOTTOM w0.133: U7000.M42 120.15,154.7 120.29,154.84 v6(120.29,155.05) ; v7(144.37,177.79) 144.38,177.79 144.62,178.03 144.62,178.05 U7701.D4
FBB_WCK45#: length 40.1
  IN4 w0.102: v6(145.22,177.81) 143.65,176.24 141.23,176.24 138.68,173.68 137.46,173.68 133.35,169.57 131.42,169.57 125.97,164.13 124.46,164.13 120.49,160.16 120.49,157.23 121.21,156.51 121.21,154.55 121.04,154.39 120.43,154.39 v6(120.3,154.26)
  BOTTOM w0.133: v6(120.3,154.26) 120.12,154.08 120.08,154.08 U7000.M41 ; v6(145.22,177.81) 145.01,177.6 144.96,177.6 U7701.D5
FBB_WCK67: length 43.1
  IN4 w0.102: v7(122.71,157.49) 122.24,157.95 122.24,158.5 122.52,158.78 122.52,159.51 122.29,159.74 122.29,160.97 123.59,162.27 125.19,162.27 131.58,168.66 134.02,168.66 138.17,172.81 138.84,172.81 141.51,175.48 147.6,175.48 148.03,175.9 150.8,175.9 152.23,177.33 152.64,177.33 v6(153.13,177.83)
  BOTTOM w0.133: U7000.H45 122.83,157.1 122.71,157.22 v7(122.71,157.49) ; v6(153.13,177.83) 152.94,177.83 152.77,178.01 U7701.P4
FBB_WCK67#: length 43.2
  IN4 w0.102: v6(122.72,156.68) 122.28,157.13 122.28,157.65 122.05,157.87 122.05,158.58 122.11,158.64 122.33,158.86 122.33,159.43 122.1,159.66 122.1,161.05 123.51,162.46 125.11,162.46 131.5,168.85 133.94,168.85 138.09,173 138.77,173 141.44,175.67 147.52,175.67 147.95,176.1 150.72,176.1 152.17,177.54 152.17,177.57 v7(152.4,177.8)
  BOTTOM w0.133: U7000.H44 v6(122.72,156.68) ; v7(152.4,177.8) 152.58,177.62 152.58,177.59 U7701.P5
FBB_ZQ0: length 4.2
  TOP w0.102: v1(144.84,168.03) 145.71,168.03 145.85,168.17 146.66,168.17 R7712.2
  TOP w0.305: R7712.2 147.13,167.04 v6(146.86,166.77)
  BOTTOM w0.305: v6(146.86,166.77) 147.24,166.38 U7700.J13
FBB_ZQ1: length 2.8
  TOP w0.254: R7713.2 149.91,169.64 v1(150.24,169.31)
  TOP w0.305: v6(149.11,170.61) R7713.2
  BOTTOM w0.305: U7701.J13 149.11,170.66 v6(149.11,170.61)
FBC_CLK0: length 38.5
  TOP w0.133: v6(147.6,126.53) 147.75,126.38 148.3,126.38 R7803.1
  IN1 w0.102: v7(125.1,133.5) 125.49,133.89 126.22,133.89 127.45,132.66 130.11,132.66 131.69,131.08 134.64,131.08 135.16,130.56 135.16,130.46 135.29,130.33 135.64,130.33 135.77,130.46 135.77,130.56 135.98,130.77 136.65,130.77 136.86,130.56 136.86,129.43 136.99,129.3 137.35,129.3 137.47,129.43 137.47,130.56 137.69,130.77 138.35,130.77 138.57,130.56 138.57,129.55 138.69,129.43 139.05,129.43 139.17,129.55 139.17,130.56 139.39,130.77 140.31,130.77 140.52,130.56 140.52,129.58 140.65,129.45 141,129.45 141.13,129.58 141.13,130.56 141.34,130.77 141.91,130.77 142.12,130.56 142.12,129.43 142.25,129.3 142.6,129.3 142.73,129.43 142.73,130.56 142.94,130.77 143.55,130.77 146.84,127.49 146.84,126.88 147.18,126.53 v6(147.6,126.53)
  BOTTOM w0.133: U7000.F15 124.7,133.1 125.1,133.5 v7(125.1,133.5) ; U7800.J12 147.6,126.52 v6(147.6,126.53)
FBC_CLK0#: length 38.7
  TOP w0.133: R7803.2 148.4,126.13 148,126.13 v7(147.66,125.79)
  IN1 w0.102: v7(147.66,125.79) 147.42,126.03 147.42,126.15 147.25,126.32 147.12,126.32 146.65,126.8 146.65,127.41 143.47,130.58 143.02,130.58 142.92,130.48 142.92,129.35 142.68,129.11 142.17,129.11 141.93,129.35 141.93,130.48 141.83,130.58 141.42,130.58 141.32,130.48 141.32,129.5 141.08,129.26 140.57,129.26 140.33,129.5 140.33,130.48 140.23,130.58 139.47,130.58 139.37,130.48 139.37,129.48 139.13,129.24 138.61,129.24 138.37,129.48 138.37,130.48 138.27,130.58 137.77,130.58 137.66,130.48 137.66,129.35 137.43,129.11 136.91,129.11 136.67,129.35 136.67,130.48 136.57,130.58 136.06,130.58 135.96,130.48 135.96,130.38 135.72,130.14 135.21,130.14 134.97,130.38 134.97,130.48 134.56,130.89 131.61,130.89 130.03,132.47 127.37,132.47 126.22,133.62 126.02,133.62 125.9,133.5 v6(125.9,133.5)
  BOTTOM w0.133: v6(125.9,133.5) 125.9,132.98 125.81,132.9 125.71,132.9 U7000.E15 ; v7(147.66,125.79) 147.66,125.47 147.55,125.37 U7800.J11
FBC_CLK1: length 39.4
  TOP w0.133: R7802.1 147.37,145.86 147.37,145.43 v7(147.63,145.18)
  IN1 w0.102: v7(147.63,145.18) 147.32,144.87 147.32,144.67 147.01,144.35 145.16,144.35 144.23,145.28 140.29,145.28 135.53,140.52 135.23,140.52 134.63,141.12 134.48,141.12 134.2,140.83 134.2,140.69 134.8,140.09 134.8,139.78 134.21,139.2 133.91,139.2 133.61,139.49 133.43,139.49 133.18,139.24 133.18,139.06 133.48,138.77 133.48,138.47 133.01,137.99 132.7,137.99 132.41,138.29 132.23,138.29 132.05,138.11 132.05,137.93 132.34,137.63 132.34,137.33 131.83,136.82 130.66,136.82 130.45,137.03 130.45,137.81 130.32,137.94 130.07,137.94 129.94,137.81 129.94,137.03 129.62,136.71 128.2,136.71 127.82,136.33 124.74,136.33 124.28,136.8 122.72,136.8 122.34,136.41 122.34,136.05 122.48,135.9 v6(122.73,135.9)
  BOTTOM w0.133: v7(147.63,145.18) 147.43,144.98 147.43,144.93 U7801.J12 ; v6(122.73,135.9) 122.49,135.66 122.46,135.66 U7000.J18
FBC_CLK1#: length 39.2
  TOP w0.133: R7802.2 147.07,145.91 147.07,145.38 v6(146.84,145.15)
  IN1 w0.102: v6(121.84,135.93) 122.15,136.23 122.15,136.49 122.64,136.99 124.36,136.99 124.82,136.52 127.74,136.52 128.12,136.9 129.54,136.9 129.75,137.11 129.75,137.89 129.99,138.13 130.4,138.13 130.64,137.89 130.64,137.11 130.74,137.01 131.75,137.01 132.15,137.41 132.15,137.55 131.86,137.85 131.86,138.19 132.15,138.48 132.49,138.48 132.78,138.18 132.93,138.18 133.29,138.54 133.29,138.69 132.99,138.98 132.99,139.32 133.35,139.68 133.69,139.68 133.99,139.39 134.13,139.39 134.61,139.86 134.61,140.01 134,140.61 134,140.91 134.4,141.31 134.71,141.31 135.31,140.71 135.45,140.71 140.21,145.47 144.31,145.47 145.24,144.54 146.93,144.54 147.13,144.75 147.13,144.86 v6(146.84,145.15)
  BOTTOM w0.133: v6(146.84,145.15) 147.1,145.41 147.1,145.41 U7801.J11 ; U7000.K18 121.64,135.64 121.64,135.72 v6(121.84,135.93)
FBC_CMD0: length 25.7
  TOP w0.133: v2(133.8,124.77) 134.6,124.77 v1(134.93,124.45) 136.85,124.45 137.36,123.94 145.09,123.94 148.03,121 148.03,119.9 148.45,119.49 v6(148.45,118.58)
  BOTTOM w0.133: v2(133.8,124.77) 132.47,123.45 130.65,123.45 130.21,123.89 128.29,123.89 U7000.B3 ; v6(148.45,118.58) 148.71,118.84 148.72,118.84 U7800.G3
FBC_CMD1: length 24.5
  TOP w0.133: v2(131.55,123.87) 131.55,123.45 R7112.1 132.44,122.16 132.95,121.65 134.56,121.65 v1(135.16,122.25) 136.78,122.25 137.66,123.12 144.71,123.12 147.22,120.61 147.22,118.94 v6(146.84,118.57)
  BOTTOM w0.133: U7800.J3 v6(146.84,118.57) ; U7000.A4 130.34,124.3 130.77,123.87 v2(131.55,123.87)
FBC_CMD2: length 25
  TOP w0.133: v6(147.65,118.56) 147.98,118.9 147.98,119.37 147.63,119.73 147.63,120.82 144.91,123.53 v1(136.75,123.53) 134.17,123.53 134.14,123.49 132.43,123.49 132.28,123.64 R7117.2 131.95,124.08 131.62,124.4 131.62,124.53 v2(131.34,124.81)
  BOTTOM w0.133: U7000.B4 128.32,124.72 130.11,124.72 130.19,124.81 v2(131.34,124.81) ; v6(147.65,118.56) 147.4,118.32 147.39,118.32 U7800.J2
FBC_CMD3: length 23.7
  TOP w0.133: v6(145.25,119.37) 145.64,119.76 145.64,120.44 144.17,121.91 141.35,121.91 v1(140.92,121.48) 139.01,121.48 137.97,120.44 132.36,120.44 129.77,123.03 v6(129.77,125.54)
  BOTTOM w0.133: v6(129.77,125.54) 129.33,125.1 U7000.A5 ; v6(145.25,119.37) 145.47,119.15 145.47,119.15 U7800.L3
FBC_CMD4: length 24.3
  TOP w0.133: v6(146.05,120.13) 146.05,120.65 144.38,122.32 139.09,122.32 v1(138.94,122.17) 137.61,120.84 132.56,120.84 130.25,123.15 130.25,126.12 v6(130.44,126.3)
  BOTTOM w0.133: U7000.A6 129.1,126.3 v6(130.44,126.3) ; U7800.K5 146.28,120.4 146.28,120.36 v6(146.05,120.13)
FBC_CMD5: length 27
  TOP w0.133: v6(146.82,119.37) 146.82,120.45 144.54,122.72 138.15,122.72 v1(137.02,121.6) 136.67,121.25 132.74,121.25 130.58,123.41 130.58,125.82 v2(131.02,126.26)
  BOTTOM w0.133: U7000.B6 128.26,125.54 129.03,125.54 129.46,125.97 129.96,125.97 130.05,125.88 130.64,125.88 v2(131.02,126.26) ; U7800.K4 146.62,119.59 146.62,119.57 v6(146.82,119.37)
FBC_CMD6: length 24.7
  BOTTOM w0.133: U7000.B11 128.32,129.48 129.51,129.48 130.55,128.44 131.22,128.44 135.53,124.12 v1(135.53,123.61) 135.53,122.04 136.17,121.4 140.23,121.4 140.56,121.73 146.08,121.73 U7800.J5
FBC_CMD7: length 24.1
  BOTTOM w0.133: U7000.A11 128.87,129.73 130.66,129.73 135.39,125 135.75,125 138.82,121.93 v1(138.91,121.93) 140.11,121.93 140.35,122.17 146.29,122.17 147.64,120.82 147.64,120.17 U7800.J4
FBC_CMD8: length 25.4
  BOTTOM w0.133: U7800.H5 148.04,120.98 146.47,122.56 138.76,122.56 v1(134.24,127.07) 131.17,130.15 129.17,130.15 129.03,130.29 127.51,130.29 U7000.C12
FBC_CMD9: length 25.3
  TOP w0.133: v6(129.49,130.7) 130.24,129.95 131.92,129.95 v1(134.21,127.65) 137.52,124.35 145.29,124.35 148.43,121.2 v6(148.43,120.13)
  BOTTOM w0.133: v6(129.49,130.7) U7000.A12 ; U7800.H4 148.18,119.9 148.2,119.9 v6(148.43,120.13)
FBC_CMD10: length 25.4
  TOP w0.133: v6(130.53,130.65) 132.31,130.65 v1(136.07,126.89) 136.68,126.28 140.24,126.28 140.47,126.51 141.47,126.51 142.61,125.37 143.55,125.37 143.55,125.37 145.43,125.37 145.84,124.96 148.59,124.96 149.24,125.61 v6(149.24,125.77)
  BOTTOM w0.133: U7000.B12 128.46,131.26 129.64,131.26 130.25,130.65 v6(130.53,130.65) ; U7800.G12 v6(149.24,125.77)
FBC_CMD11: length 27.2
  BOTTOM w0.133: U7800.H10 148.26,124.57 148.51,124.31 148.51,123.46 148.05,123 139.05,123 v1(131.35,130.7) 129.37,132.68 127.52,132.68 U7000.C15
FBC_CMD12: length 25.9
  BOTTOM w0.133: U7000.A15 131.41,133.1 136.86,127.65 v1(136.86,127.14) 136.86,126.03 139.47,123.41 147.46,123.41 147.67,123.63 147.67,125 U7800.H11
FBC_CMD13: length 27.7
  BOTTOM w0.133: U7000.B15 128.36,133.56 132.5,133.56 v1(132.69,133.37) 132.99,133.06 133.55,133.06 133.73,133.24 133.73,133.43 133.86,133.56 134.43,133.56 135.33,132.66 135.33,130.98 137.69,128.62 137.69,126.53 138.68,125.54 138.68,124.86 139.73,123.81 146.39,123.81 146.82,124.24 146.82,124.99 U7800.K11
FBC_CMD14: length 25.7
  BOTTOM w0.133: U7000.B17 128.51,134.09 134.66,134.09 135.79,132.96 135.79,131.56 v1(138.1,129.25) 138.1,126.76 139.17,125.69 139.17,125.04 140.01,124.21 146.08,124.21 U7800.K10
FBC_CMD15: length 24.8
  BOTTOM w0.133: U7800.L12 146.1,126.62 146.1,128.47 145.67,128.89 144.7,128.89 v1(143.42,130.17) 143.31,130.28 137.99,130.28 137.85,130.43 137.85,134.49 137.63,134.7 128.7,134.7 U7000.A17
FBC_CMD16: length 26.9
  TOP w0.133: v6(148.49,152.31) 146.9,152.31 146.57,151.98 141.89,151.98 141.26,151.35 140.62,151.35 139.93,150.66 v1(136.83,150.66) 135.76,150.66 130.35,145.25 129.26,145.25 127.5,143.49 v6(127.5,142.31)
  BOTTOM w0.133: U7000.C27 v6(127.5,142.31) ; v6(148.49,152.31) 148.69,152.11 148.69,152.1 U7801.L3
FBC_CMD17: length 27.8
  BOTTOM w0.133: U7000.B27 128.1,142.7 128.46,142.34 130.44,142.34 130.98,142.88 131.56,142.88 131.93,143.25 R7113.1 132.78,143.25 132.78,143.6 133.36,144.19 134.3,144.19 134.67,144.56 134.67,145.13 136.58,147.04 136.58,148.74 138.81,150.97 v1(138.81,151.12) 139.17,151.48 139.17,152.39 140.7,153.93 145.75,153.93 146.1,153.59 146.1,152.61 146.37,152.33 146.86,152.33 U7801.J3
FBC_CMD18: length 26.4
  BOTTOM w0.133: U7000.A27 130.23,142.7 130.81,143.28 131.05,143.28 131.8,144.03 132.08,144.03 R7114.2 133.26,145.21 134.19,145.21 136.13,147.16 136.13,149.23 v1(137.13,150.23) 138.01,151.11 138.01,151.8 140.67,154.46 146.61,154.46 146.86,154.21 146.86,153.13 U7801.J2
FBC_CMD19: length 24.6
  TOP w0.133: v6(146.02,151.57) 144.81,150.35 140.83,150.35 v1(140.7,150.22) 140.52,150.04 135.8,150.04 130.5,144.74 129.71,144.74 128.25,143.28 128.25,142.19 v6(127.53,141.47)
  BOTTOM w0.133: U7801.G3 v6(146.02,151.57) ; U7000.C26 127.26,141.9 127.53,141.62 v6(127.53,141.47)
FBC_CMD20: length 23.8
  TOP w0.133: v6(129.51,141.4) 130.2,142.08 130.2,143.17 135.29,148.26 v1(136.07,148.26) 139.2,148.26 139.92,148.98 145.79,148.98 146.81,150 v6(146.81,150.74)
  BOTTOM w0.133: v6(129.51,141.4) 129.01,141.9 U7000.A26 ; v6(146.81,150.74) 146.66,150.59 146.66,150.57 U7801.H5
FBC_CMD21: length 23.9
  TOP w0.133: v6(146.05,150.74) 146.05,150 145.42,149.38 v1(138.78,149.38) 135.75,149.38 130.58,144.21 129.8,144.21 128.73,143.13 128.73,141.9 v6(128.34,141.51)
  BOTTOM w0.133: v6(128.34,141.51) 128.3,141.56 128.3,141.56 128.15,141.72 128.09,141.72 U7000.B26 ; v6(146.05,150.74) 146.3,150.99 146.3,151.01 U7801.H4
FBC_CMD22: length 25.6
  BOTTOM w0.133: U7801.J5 146.37,149.48 140.96,149.48 140.51,149.93 138.79,149.93 136.98,148.12 136.98,146.14 136.75,145.92 v1(136.75,145.41) 136.75,144.19 135.2,142.64 135.2,142.64 134.15,141.6 132.66,141.6 132.36,141.3 131.53,141.3 129.65,139.42 129.19,139.42 129.11,139.5 U7000.A23
FBC_CMD23: length 27.9
  BOTTOM w0.133: U7000.B23 128.26,139.14 129.94,139.14 131.7,140.9 v1(133.48,140.9) 134.03,140.9 137.38,144.25 137.38,147.84 139.01,149.47 140.13,149.47 140.43,149.17 146.65,149.17 147.59,150.11 147.59,150.8 U7801.J4
FBC_CMD24: length 27.6
  TOP w0.133: v6(147.95,149.73) 147.3,149.73 146.15,148.58 140.09,148.58 138.52,147 v1(137.84,147) 135.13,147 131.35,143.22 v2(131.35,139.89)
  BOTTOM w0.133: U7000.B21 128.13,137.9 128.47,138.24 128.58,138.24 129.03,138.69 130.08,138.69 130.98,139.59 131.05,139.59 v2(131.35,139.89) ; U7801.K5 148.04,150.08 147.95,149.99 v6(147.95,149.73)
FBC_CMD25: length 28.6
  BOTTOM w0.133: U7000.A21 129.02,138.22 130.45,138.22 131.78,139.54 v1(132,139.54) 133.24,139.54 137.78,144.08 137.78,147.59 138.96,148.77 148,148.77 148.5,149.27 148.5,150.7 U7801.K4
FBC_CMD26: length 33.3
  TOP w0.133: v2(127.49,138.29) 128.02,138.29 128.07,138.24 130.51,138.24 131.93,139.66 131.93,143.14 135.15,146.37 v1(135.43,146.37) 138.45,146.37 140.25,148.18 146.39,148.18 147.18,148.96 148.31,148.96 148.77,148.51 148.77,144.9 148.46,144.59 v6(148.46,144.37)
  BOTTOM w0.133: U7000.C21 v2(127.49,138.29) ; v6(148.46,144.37) U7801.L12
FBC_CMD27: length 26.9
  BOTTOM w0.133: U7801.K10 148.04,146.63 148.11,146.69 148.11,147.19 147.33,147.96 139.69,147.96 v1(138.87,147.15) 138.58,146.85 138.58,143.72 132.12,137.25 129.62,137.25 129.46,137.1 U7000.A20
FBC_CMD28: length 29.8
  BOTTOM w0.133: U7801.K11 148.5,146 148.5,147.41 147.57,148.34 139.1,148.34 138.18,147.42 138.18,143.89 132.06,137.76 v1(131.88,137.76) 129.58,137.76 129.36,137.54 128.34,137.54 U7000.B20
FBC_CMD29: length 27.7
  BOTTOM w0.133: U7000.C20 127.48,136.72 132.36,136.72 v1(138.61,142.97) 138.98,143.34 138.98,146.49 140.06,147.56 145.72,147.56 146.79,146.49 146.79,145.9 U7801.H11
FBC_CMD30: length 26.7
  BOTTOM w0.133: U7000.C18 127.48,135.88 129.08,135.88 129.32,136.11 v1(132.77,136.11) 139.5,142.84 139.5,146.58 140.13,147.21 145.58,147.21 U7801.H10
FBC_CMD31: length 27.4
  BOTTOM w0.133: U7000.B18 128.14,135.5 128.55,135.09 129.16,135.09 129.31,135.25 135.84,135.25 136.09,135.5 136.09,135.7 136.22,135.83 136.91,135.83 137.03,135.7 137.03,135.3 137.16,135.17 137.8,135.17 137.92,135.3 137.92,139.72 138.05,139.84 138.79,139.84 138.91,139.72 138.91,139.21 139.04,139.08 139.65,139.08 139.78,139.21 139.78,139.59 139.98,139.8 v1(140.79,139.8) 142.14,139.8 145.24,142.89 145.24,144.34 U7801.G12
FBC_D0: length 30.2
  TOP w0.133: v6(129.59,127.01) 130.03,127.45 v1(130.38,127.45)
  IN4 w0.095: v6(129.59,127.01) 137.48,127.01 140.41,124.08 146.59,124.08 147.32,123.35 151.13,123.35 152.52,121.97 152.89,121.97 153.67,121.19 v6(153.67,121.09)
  BOTTOM w0.133: v6(153.67,121.09) 153.99,120.77 153.99,120.12 U7800.A4 ; U7000.A8 129.1,127.5 v6(129.59,127.01)
FBC_D1: length 32.2
  TOP w0.133: v1(126.29,126.64) 126.29,126.69 v6(126.7,127.1)
  IN4 w0.095: v6(152.43,118.58) 152.05,118.97 152.05,120.51 151.64,120.92 151.64,121.2 150.34,122.49 146.96,122.49 146.24,123.22 140.05,123.22 137.98,125.29 130.45,125.29 130.33,125.16 129.55,125.16 128.86,125.84 128.38,125.84 127.84,126.38 127.42,126.38 v6(126.7,127.1)
  BOTTOM w0.133: U7000.D8 v6(126.7,127.1) ; U7800.B2 v6(152.43,118.58)
FBC_D2: length 30.8
  TOP w0.133: v6(128.3,127.1) 128.3,126.61 v1(128.73,126.18)
  IN4 w0.095: v6(153.22,120.13) 153.22,121.23 152.78,121.68 152.4,121.68 151.01,123.06 147.2,123.06 146.47,123.79 140.29,123.79 137.36,126.72 129.95,126.72 129.78,126.54 128.86,126.54 v6(128.3,127.1)
  BOTTOM w0.133: U7800.B4 153.05,119.98 153.07,119.98 v6(153.22,120.13) ; U7000.B8 v6(128.3,127.1)
FBC_D3: length 33.1
  TOP w0.133: v6(127.5,127.1) 128.23,127.83 v1(128.42,127.83)
  IN4 w0.095: v6(127.5,127.1) 128.32,126.28 129.9,126.28 130.35,125.82 131.27,125.82 131.75,126.3 137.37,126.3 140.17,123.51 146.35,123.51 147.08,122.78 150.9,122.78 152.42,121.25 152.42,120.03 152.83,119.62 152.83,119.04 v6(153.29,118.58)
  BOTTOM w0.133: U7000.C8 v6(127.5,127.1) ; v6(153.29,118.58) 153.49,118.38 153.49,118.32 U7800.A2
FBC_D4: length 25.4
  TOP w0.133: v6(149.22,120.13) 149.58,120.5 v1(149.58,120.67)
  IN4 w0.095: v6(149.22,120.13) 149.05,120.13 148.27,120.91 146.16,120.91 145.42,121.65 139.33,121.65 138.88,122.1 130.39,122.1 127.78,124.7 v6(127.5,124.7)
  BOTTOM w0.133: U7800.F4 149.54,119.88 149.47,119.88 v6(149.22,120.13) ; U7000.C5 v6(127.5,124.7)
FBC_D5: length 27.4
  TOP w0.133: v6(127.51,125.49) 128.12,124.88 v1(128.12,124.54)
  IN4 w0.095: v6(150.08,120.13) 150.08,120.67 149.27,121.49 146.55,121.49 145.82,122.22 139.63,122.22 138.42,123.43 130.32,123.43 128.74,125.01 128.19,125.01 127.71,125.49 v6(127.51,125.49)
  BOTTOM w0.133: U7000.B5 v6(127.51,125.49) ; v6(150.08,120.13) U7800.E4
FBC_D6: length 28.3
  TOP w0.133: v1(150.06,118.42) v6(150.06,117.78)
  IN4 w0.095: v6(126.7,124.7) 127.11,124.29 127.78,124.29 130.26,121.81 138.37,121.81 138.86,121.33 140.64,121.33 141.27,120.7 142.52,120.7 142.6,120.62 147.41,120.62 148.28,119.75 148.63,119.75 148.86,119.52 148.86,119.16 150.06,117.96 v6(150.06,117.78)
  BOTTOM w0.133: U7000.D5 v6(126.7,124.7) ; U7800.E2 v6(150.06,117.78)
FBC_D7: length 27.1
  TOP w0.133: v1(128.02,122.76) 128.02,123.38 v6(127.52,123.88)
  IN4 w0.095: v6(127.52,123.88) 127.75,123.88 130.1,121.53 137.96,121.53 139.73,119.75 143,119.75 143.02,119.73 144.26,119.73 144.28,119.75 147.51,119.75 148.29,118.98 148.63,118.98 149.25,118.36 v6(149.25,117.78)
  BOTTOM w0.133: U7800.F2 v6(149.25,117.78) ; U7000.C4 127.27,124.13 127.27,124.13 v6(127.52,123.88)
FBC_D8: length 26.6
  TOP w0.133: v1(127.74,129.61) 127.74,129.31 v6(127.34,128.91)
  IN1 w0.095: v6(149.26,124.98) 148.68,124.41 145.8,124.41 145.75,124.46 137.9,124.46 133.08,129.28 130.19,129.28 130.12,129.35 127.78,129.35 v6(127.34,128.91)
  BOTTOM w0.133: U7000.B9 127.49,128.72 127.49,128.77 v6(127.34,128.91) ; U7800.F11 v6(149.26,124.98)
FBC_D9: length 30.1
  TOP w0.133: v1(149.68,127.1) 149.68,126.93 v6(150.03,126.58)
  IN1 w0.095: v6(125.1,129.49) 125.49,129.88 130.25,129.88 130.56,129.58 133.42,129.58 137.63,125.38 145.4,125.38 146.09,124.69 148.43,124.69 149.12,125.38 149.38,125.38 149.63,125.63 149.63,126.18 v6(150.03,126.58)
  BOTTOM w0.133: U7800.F13 v6(150.03,126.58) ; U7000.E11 v6(125.1,129.49)
FBC_D10: length 30.8
  TOP w0.133: v1(127.18,128.22) v6(126.7,128.7)
  IN1 w0.095: v6(151.7,124.98) 151.44,124.98 149.42,122.96 146.13,122.96 145.24,123.85 137.7,123.85 133.11,128.43 126.97,128.43 v6(126.7,128.7)
  BOTTOM w0.133: U7000.D9 126.3,128.3 v6(126.7,128.7) ; U7800.B11 152.45,124.98 v6(151.7,124.98)
FBC_D11: length 27.3
  TOP w0.133: v1(129.34,129.13) 128.64,129.13 v6(128.43,128.92)
  IN1 w0.095: v6(150.09,124.98) 149.5,124.4 149.5,123.86 148.89,123.25 146.25,123.25 145.35,124.14 137.81,124.14 133.04,128.92 v6(128.43,128.92)
  BOTTOM w0.133: U7800.E11 150.44,125.37 150.34,125.27 150.34,125.23 v6(150.09,124.98) ; v6(128.43,128.92) 128.7,128.65 U7000.A9
FBC_D12: length 38.7
  TOP w0.133: v6(123.5,129.51) 122.85,128.86 v1(122.85,128.86)
  IN1 w0.095: v6(123.5,129.51) 123.7,129.51 124.71,128.5 125.29,128.5 125.51,128.27 126.05,128.27 126.46,127.87 130.14,127.87 130.77,127.23 132.88,127.23 137.25,122.86 145.01,122.86 145.77,122.1 150.75,122.1 152.65,124.01 152.65,126.78 v6(153.24,127.37)
  BOTTOM w0.133: v6(153.24,127.37) 153.06,127.18 U7800.B13 ; U7000.H11 v6(123.5,129.51)
FBC_D13: length 36.2
  TOP w0.133: v1(151.25,127.92) 151.25,126.98 150.86,126.59 v6(150.86,126.57)
  IN1 w0.095: v6(150.86,126.57) 151.23,126.2 151.76,126.2 152.08,125.89 152.08,124.83 151.76,124.51 151.44,124.51 149.61,122.67 146.01,122.67 145.15,123.54 137.6,123.54 133.1,128.05 130.78,128.05 130.59,128.24 126.63,128.24 126.27,128.59 126.27,128.85 126.05,129.07 125.68,129.07 125.49,128.89 v6(124.93,128.89)
  BOTTOM w0.133: v6(150.86,126.57) 150.71,126.73 150.69,126.73 U7800.E13 ; U7000.F9 124.7,128.3 124.93,128.52 v6(124.93,128.89)
FBC_D14: length 40.6
  TOP w0.133: v1(154.16,126.54) 153.26,126.54 v6(153.24,126.56)
  IN1 w0.095: v6(153.24,126.56) 153.64,126.16 153.64,125.59 153.23,125.17 153.23,123.39 152.84,123 152.84,122.62 152.48,122.27 151.79,122.27 151.05,121.53 145.53,121.53 144.77,122.29 137.01,122.29 132.64,126.66 130.56,126.66 129.74,127.48 125.78,127.48 125.47,127.78 125.47,128.03 125.2,128.31 124.57,128.31 124.37,128.5 123.63,128.5 122.7,129.44 v6(122.7,129.5)
  BOTTOM w0.133: U7800.A13 v6(153.24,126.56) ; U7000.J11 v6(122.7,129.5)
FBC_D15: length 34.6
  TOP w0.133: v6(153.27,125.75) 153.27,125.05 v1(153.51,124.81)
  IN1 w0.095: v6(125.9,127.9) 126.13,127.66 129.91,127.66 130.63,126.95 132.76,126.95 137.13,122.58 144.89,122.58 145.65,121.81 150.87,121.81 152.94,123.89 152.94,125.42 v6(153.27,125.75)
  BOTTOM w0.133: v6(125.9,127.9) 125.5,127.5 U7000.E8 ; v6(153.27,125.75) U7800.A11
FBC_D16: length 30.2
  TOP w0.133: v6(121.06,134.25) 121.72,134.91 v1(121.72,135.07)
  IN4 w0.095: v6(121.06,134.25) 120.7,133.9 120.7,133.24 121.46,132.48 121.46,131.8 122.13,131.13 122.95,131.13 123.92,130.16 127,130.16 127.81,129.35 128.6,129.35 130.16,127.79 137.8,127.79 140.21,125.39 143.2,125.39 v6(143.64,124.96)
  BOTTOM w0.133: v6(143.64,124.96) 143.64,124.96 U7800.N11 ; U7000.K17 121.06,134.26 v6(121.06,134.25)
FBC_D17: length 27.3
  TOP w0.133: v6(123.5,134.3) 124.04,134.84 124.28,134.84 v1(124.79,135.35)
  IN4 w0.095: v6(123.5,134.3) 123.71,134.1 123.71,134.06 124.02,133.75 124.02,133.2 124.36,132.86 130.53,132.86 132.77,130.62 141.65,130.62 143.64,128.64 143.64,128.18 v6(144.45,127.37)
  BOTTOM w0.133: v6(144.45,127.37) 144.4,127.33 144.4,127.33 U7800.N13 ; U7000.G17 v6(123.5,134.3)
FBC_D18: length 25.9
  TOP w0.133: v1(140.59,127.63) 140.98,127.63 v6(141.24,127.36)
  IN4 w0.095: v6(141.24,127.36) 140.54,127.36 140.03,127.88 139,127.88 138.16,128.72 130.73,128.72 129.54,129.92 129.31,129.92 128.8,130.42 128.01,130.42 127.71,130.72 124.15,130.72 123.89,130.97 123.89,132.08 123.86,132.11 123.86,132.11 123.47,132.5 122.34,132.5 121.5,133.34 121.5,133.9 v6(121.9,134.3)
  BOTTOM w0.133: U7800.U13 v6(141.24,127.36) ; U7000.J17 v6(121.9,134.3)
FBC_D19: length 25.9
  TOP w0.089: v6(145.21,127.34) 145.69,126.86 v1(146.01,126.86)
  IN4 w0.095: v6(124.4,133.55) 124.89,133.06 130.73,133.06 132.89,130.91 142.11,130.91 144.63,128.39 144.63,127.92 v6(145.21,127.34)
  BOTTOM w0.133: v6(124.4,133.55) 124.17,133.32 124.12,133.32 U7000.G15 ; U7800.M13 v6(145.21,127.34)
FBC_D20: length 24.9
  TOP w0.133: v1(121.36,132.81) 121.36,132.96 v6(121.89,133.49)
  IN4 w0.095: v6(121.89,133.49) 122.47,132.92 123.3,132.92 123.95,132.27 124.45,132.27 124.69,132.03 124.69,131.7 124.91,131.49 128.12,131.49 129.4,130.21 129.88,130.21 130.9,129.19 138.22,129.19 139.09,128.32 140.09,128.32 140.62,127.79 141.59,127.79 v6(142.03,127.35)
  BOTTOM w0.133: U7000.K15 v6(121.89,133.49) ; U7800.T13 v6(142.03,127.35)
FBC_D21: length 29.1
  TOP w0.133: v1(143.74,125.9) 144.31,125.9 v6(144.44,125.77)
  IN4 w0.095: v6(144.44,125.77) 144.02,125.35 144.02,124.81 143.79,124.58 140.61,124.58 137.69,127.51 129.3,127.51 126.83,129.98 123.79,129.98 122.95,130.83 122.14,130.83 v6(121.08,131.88)
  BOTTOM w0.133: U7800.M11 v6(144.44,125.77) ; U7000.K14 v6(121.08,131.88)
FBC_D22: length 23.6
  TOP w0.089: v1(140.41,125.11) 140.64,125.11 v6(141.3,125.77)
  IN4 w0.095: v6(122.7,131.9) 124.07,130.54 127.41,130.54 127.95,129.99 128.88,129.99 130.48,128.39 138.02,128.39 138.97,127.43 140.01,127.43 141.3,126.15 v6(141.3,125.77)
  BOTTOM w0.133: U7000.H14 v6(122.7,131.9) ; U7800.T11 141.55,125.46 141.55,125.52 v6(141.3,125.77)
FBC_D23: length 24.3
  TOP w0.133: v1(123.24,131.18) 122.95,131.47 122.33,131.47 v6(121.9,131.9)
  IN4 w0.095: v6(140.44,125.77) 140.44,126.58 139.87,127.15 138.85,127.15 137.92,128.08 130.36,128.08 128.78,129.66 127.89,129.66 127.2,130.35 123.99,130.35 122.9,131.44 122.36,131.44 v6(121.9,131.9)
  BOTTOM w0.133: v6(140.44,125.77) U7800.U11 ; U7000.J14 v6(121.9,131.9)
FBC_D24: length 25.3
  TOP w0.133: v1(141.27,119.32) v6(141.27,120.13)
  IN2 w0.089: 129.72,132.28 125.48,132.28 v6(125.1,131.9)
  IN2 w0.146: v6(141.27,120.13) 138.86,122.54 138.86,124.2 137.69,125.36 137.69,127.12 132.62,132.19 129.81,132.19 129.72,132.28
  BOTTOM w0.133: U7000.E14 125.1,131.9 v6(125.1,131.9) ; v6(141.27,120.13) 141.47,119.93 141.48,119.93 U7800.T4
FBC_D25: length 30.1
  TOP w0.133: v6(124.29,131.89) 123.99,132.2 v1(123.99,132.42)
  IN2 w0.089: 143.57,120.65 143.71,120.65 144.07,120.3 144.07,119.73 144.43,119.37 v6(144.43,119.37)
  IN2 w0.146: 143.57,120.65 141.37,120.65 139.32,122.7 139.32,124.37 138.15,125.54 138.15,127.29 132.82,132.63 125.03,132.63 v6(124.29,131.89)
  BOTTOM w0.133: U7800.N4 144.25,119.56 144.25,119.55 v6(144.43,119.37) ; v6(124.29,131.89) U7000.F14
FBC_D26: length 20.4
  TOP w0.133: v1(139.57,120.36) 140.25,120.36 v6(140.48,120.13)
  IN2 w0.146: v6(140.48,120.13) 138.35,122.26 138.35,124.04 137.24,125.16 137.24,126.94 132.57,131.61 130.44,131.61 130.28,131.76 v6(129.67,131.76)
  BOTTOM w0.133: v6(140.48,120.13) 140.84,119.77 U7800.U4 ; U7000.A14 129.13,132.3 v6(129.67,131.76)
FBC_D27: length 22.3
  TOP w0.133: v6(140.33,119.32) 139.93,118.93 v1(139.93,118.64)
  IN2 w0.146: v6(128.3,131.9) 128.84,131.36 130.35,131.36 130.56,131.16 130.59,131.16 130.73,131.02 132.52,131.02 136.78,126.76 136.78,124.98 137.85,123.92 137.85,122.15 140.33,119.66 v6(140.33,119.32)
  BOTTOM w0.133: v6(140.33,119.32) 140.33,118.69 140.45,118.57 140.45,118.57 U7800.U2 ; U7000.B14 v6(128.3,131.9)
FBC_D28: length 25.5
  TOP w0.133: v6(141.22,117.74) 140.84,117.36 v1(140.84,117.06)
  IN2 w0.089: 127.15,131.29 126.95,131.49 126.29,131.49 v6(125.9,131.1)
  IN2 w0.146: v6(141.22,117.74) 140.77,118.2 139.89,118.2 136.58,121.51 136.58,123.59 135.66,124.5 135.66,126.3 132.27,129.69 129.91,129.69 129.24,130.36 128.93,130.36 128.62,130.66 127.77,130.66 127.15,131.29
  BOTTOM w0.133: v6(141.22,117.74) 141.64,118.16 U7800.T2 ; v6(125.9,131.1) 125.51,130.71 U7000.E12
FBC_D29: length 30.2
  TOP w0.133: v1(125.85,130.37) v6(125.11,131.11)
  IN2 w0.146: v6(144.39,117.74) 143.47,116.82 139.75,116.82 135.56,121.01 135.56,123.33 134.75,124.14 134.75,125.95 131.96,128.73 129.82,128.73 128.94,129.61 127.96,129.61 127.15,130.42 125.8,130.42 v6(125.11,131.11)
  BOTTOM w0.133: U7800.N2 144.15,118.06 144.15,117.98 v6(144.39,117.74) ; U7000.F12 124.7,130.7 v6(125.11,131.11)
FBC_D30: length 33.1
  TOP w0.133: v1(145.06,117.98) 144.77,118.27 144.74,118.27 v6(144.45,118.56)
  IN2 w0.146: v6(124.32,131.12) 125.49,129.95 127.14,129.95 127.76,129.33 128.64,129.33 129.71,128.26 131.8,128.26 134.29,125.77 134.29,123.97 135.05,123.2 135.05,120.89 139.57,116.37 143.41,116.37 143.42,116.38 143.65,116.38 143.83,116.55 144.58,116.55 144.83,116.81 144.83,117.95 144.45,118.33 v6(144.45,118.56)
  BOTTOM w0.133: U7800.M2 144.84,118.17 v6(144.45,118.56) ; v6(124.32,131.12) U7000.G12
FBC_D31: length 30.5
  TOP w0.133: v6(144.48,120.13) 144.62,119.99 v1(145.13,119.99)
  IN2 w0.146: v6(123.51,131.91) 124.57,132.97 130.44,132.97 130.56,133.09 132.99,133.09 138.61,127.47 138.61,125.75 139.76,124.6 139.76,123.37 141.42,121.71 143.24,121.71 144.48,120.46 v6(144.48,120.13)
  BOTTOM w0.133: v6(123.51,131.91) U7000.G14 ; U7800.M4 v6(144.48,120.13)
FBC_D32: length 24.2
  TOP w0.133: v1(124.1,142.26) 124.1,141.7 v6(124.29,141.51)
  IN4 w0.095: v6(142.02,150.78) 141.59,150.34 140.89,150.34 136.57,146.03 135.79,146.03 134.67,144.91 134.67,144.52 134.17,144.01 133.24,144.01 131.47,142.24 128.21,142.24 127.64,142.81 127.15,142.81 126.54,142.2 124.98,142.2 v6(124.29,141.51)
  BOTTOM w0.133: U7801.B4 141.99,150.8 141.99,150.8 142.01,150.78 v6(142.02,150.78) ; v6(124.29,141.51) U7000.G26
FBC_D33: length 29.3
  TOP w0.133: v6(121.92,141.52) 122.28,141.16 122.28,140.46 v1(121.77,139.95)
  IN4 w0.095: v6(121.92,141.52) 122.56,142.15 123.37,142.15 123.9,142.69 126.18,142.69 126.8,143.31 128.39,143.31 128.88,142.81 130.5,142.81 130.51,142.83 130.52,142.83 130.53,142.83 131.22,142.83 134.99,146.6 136.34,146.6 140.91,151.17 142.93,151.17 143.31,151.55 v6(143.64,151.55)
  BOTTOM w0.133: U7801.E4 143.87,151.32 143.87,151.32 v6(143.64,151.55) ; U7000.J26 v6(121.92,141.52)
FBC_D34: length 26
  TOP w0.133: v1(125.4,142.46) 125.1,142.16 v6(125.1,141.51)
  IN4 w0.095: v6(144.43,150.77) 144.02,151.17 143.37,151.17 142.53,150.34 142.53,149.88 142.17,149.52 140.75,149.52 134.83,143.59 133.39,143.59 131.73,141.93 125.52,141.93 v6(125.1,141.51)
  BOTTOM w0.133: v6(144.43,150.77) 144.7,151.04 144.73,151.04 144.84,151.15 U7801.F4 ; v6(125.1,141.51) U7000.F26
FBC_D35: length 25
  TOP w0.133: v1(124.52,140.1) 124.32,140.3 124.17,140.3 123.94,140.53 123.94,141.12 v6(123.55,141.51)
  IN4 w0.095: v6(123.55,141.51) 124.47,142.42 126.3,142.42 126.9,143.02 128.05,143.02 128.54,142.53 131.35,142.53 135.13,146.31 136.45,146.31 140.91,150.77 v6(141.26,150.77)
  BOTTOM w0.133: U7801.A4 141.03,150.96 141.07,150.96 v6(141.26,150.77) ; v6(123.55,141.51) 123.36,141.69 123.31,141.69 U7000.H26
FBC_D36: length 23.6
  IN4 w0.095: v6(123.5,143.1) 124.04,143.64 124.04,144.07 124.51,144.54 127.89,144.54 128.3,144.13 130.71,144.13 139.3,152.73 140.93,152.73 v6(141.25,152.41)
  BOTTOM w0.133: v6(141.25,152.41) 141.44,152.61 141.5,152.61 U7801.B2 ; U7000.G27 123.9,142.7 v6(123.5,143.1)
FBC_D37: length 21.9
  IN4 w0.095: v6(140.53,152.35) 139.33,152.35 130.81,143.83 128.17,143.83 127.64,144.36 125.77,144.36 125.5,144.08 125.5,143.63 125.37,143.5 124.7,143.5 v6(124.3,143.1)
  BOTTOM w0.133: U7801.A2 140.71,152.62 140.71,152.54 v6(140.53,152.35) ; U7000.F27 v6(124.3,143.1)
FBC_D38: length 29.8
  TOP w0.133: v6(144.48,153.12) 143.95,153.65 v1(143.94,153.65)
  IN4 w0.095: v6(144.48,153.12) 144.48,153.22 143.62,154.08 139.31,154.08 130.33,145.09 123.65,145.09 122.82,144.26 122.45,144.26 122.25,144.06 122.25,143.45 v6(121.9,143.1)
  BOTTOM w0.133: v6(121.9,143.1) 122.1,142.9 U7000.J27 ; U7801.F2 v6(144.48,153.12)
FBC_D39: length 29.4
  TOP w0.133: v6(144.45,152.43) 144.53,152.52 v1(145.19,152.52)
  IN4 w0.095: v6(144.45,152.43) 144.07,152.81 144.07,153.23 143.51,153.79 139.47,153.79 130.39,144.71 128.54,144.71 128.33,144.91 123.83,144.91 123.07,144.14 123.07,143.65 122.7,143.29 v6(122.7,143.1)
  BOTTOM w0.133: v6(144.45,152.43) 144.24,152.64 144.16,152.64 U7801.E2 ; U7000.H27 123.1,142.7 v6(122.7,143.1)
FBC_D40: length 22.3
  TOP w0.133: v1(142.24,145.32) 141.88,145.32 v6(141.26,145.94)
  IN2 w0.146: v6(125.12,139.08) 126.47,140.43 127.54,140.43 127.94,140.83 127.94,141.76 128.45,142.27 135.48,142.27 139.65,146.44 140.76,146.44 v6(141.26,145.94)
  BOTTOM w0.133: U7801.B11 v6(141.26,145.94) ; U7000.E23 125.29,139.29 125.29,139.25 v6(125.12,139.08)
FBC_D41: length 19
  TOP w0.133: v1(141.2,144.19) 141.2,143.52 v6(141.24,143.48)
  IN2 w0.089: 128.8,138.26 128.22,138.26 127.75,138.74 127.14,138.74 v6(126.7,138.3)
  IN2 w0.146: v6(141.24,143.48) 140.77,143.01 140.41,143.01 136.09,138.69 129.23,138.69 128.8,138.26
  BOTTOM w0.133: U7000.D21 126.3,137.9 v6(126.7,138.3) ; v6(141.24,143.48) 141.45,143.69 141.45,143.76 U7801.B13
FBC_D42: length 19.4
  TOP w0.133: v1(140.08,145.2) 140.46,145.59 v6(140.46,145.91)
  IN2 w0.146: v6(140.46,145.91) 139.74,145.91 135.66,141.84 130.55,141.84 130.3,141.58 130.3,141.54 129.73,140.97 129.05,140.97 128.18,140.1 126.9,140.1 v6(125.9,139.1)
  BOTTOM w0.133: U7801.A11 140.71,145.69 140.69,145.69 v6(140.46,145.91) ; U7000.D23 v6(125.9,139.1)
FBC_D43: length 22.9
  TOP w0.133: v6(144.45,144.34) 144.52,144.42 v1(145.36,144.42)
  IN2 w0.146: v6(144.45,144.34) 143.42,145.38 139.83,145.38 135.85,141.4 130.55,141.4 129.66,140.5 129.29,140.5 128.64,139.85 127.35,139.85 126.7,139.2 v6(126.7,139.1)
  BOTTOM w0.133: U7801.F13 v6(144.45,144.34) ; U7000.C23 v6(126.7,139.1)
FBC_D44: length 20.3
  TOP w0.133: v1(145.01,142.66) 145.01,142.98 v6(144.46,143.53)
  IN2 w0.146: v6(129.38,139.82) 129.62,139.82 130.76,140.96 136.11,140.96 139.98,144.83 143.16,144.83 v6(144.46,143.53)
  BOTTOM w0.133: v6(129.38,139.82) 129.19,139.82 U7000.A24 ; v6(144.46,143.53) 144.46,143.54 U7801.E13
FBC_D45: length 17.4
  TOP w0.133: v1(139.47,143.38) 140.09,143.38 v6(140.15,143.44)
  IN2 w0.146: v6(127.51,139.13) 135.84,139.13 v6(140.15,143.44)
  BOTTOM w0.133: U7801.A13 140.33,143.44 v6(140.15,143.44) ; U7000.B24 127.51,139.91 v6(127.51,139.13)
FBC_D46: length 26.2
  TOP w0.133: v6(145.23,145.97) 145.67,146.41 v1(145.67,146.68)
  IN2 w0.146: v6(145.23,145.97) 143.49,147.71 139.68,147.71 135.57,143.6 127.25,143.6 125.5,141.85 125.5,141.16 125.07,140.73 v6(125.07,140.73)
  BOTTOM w0.133: v6(125.07,140.73) U7000.E24 ; v6(145.23,145.97) 145.02,145.76 145.02,145.73 U7801.F11
FBC_D47: length 24.1
  TOP w0.133: v6(144.45,145.96) 143.87,146.54 v1(143.87,146.7)
  IN2 w0.146: v6(144.45,145.96) 143.14,147.27 139.86,147.27 135.3,142.71 127.33,142.71 127.08,142.46 127.08,142.01 127.13,141.96 127.13,141.01 v6(126.95,140.84)
  BOTTOM w0.133: U7000.D24 126.52,140.52 126.63,140.52 v6(126.95,140.84) ; U7801.E11 v6(144.45,145.96)
FBC_D48: length 37.5
  TOP w0.133: v1(154.64,146.25) 154.34,146.25 v6(154.05,145.96)
  IN4 w0.095: v6(154.05,145.96) 153.71,145.62 153.71,144.75 154.48,143.98 154.48,142.43 150.16,138.1 140.05,138.1 135.82,133.88 127.09,133.88 v6(126.95,133.74)
  BOTTOM w0.133: U7000.D15 126.3,133.39 126.65,133.74 v6(126.95,133.74) ; U7801.U11 v6(154.05,145.96)
FBC_D49: length 32.8
  TOP w0.133: v1(154.61,143.63) 154.07,143.63 v6(153.99,143.55)
  IN4 w0.095: v6(153.99,143.55) 153.7,143.25 153.7,142.04 150.04,138.39 139.76,138.39 135.69,134.32 v6(127.55,134.32)
  BOTTOM w0.133: v6(153.99,143.55) 153.82,143.72 153.82,143.77 U7801.U13 ; v6(127.55,134.32) 127.38,134.49 127.32,134.49 U7000.C17
FBC_D50: length 36.2
  TOP w0.133: v6(126.7,134.3) 126.92,134.52 v1(126.92,134.94)
  IN4 w0.095: v6(153.26,145.96) 153.45,145.77 153.43,145.74 153.43,145.5 153.39,145.53 153.08,145.53 152.86,145.31 152.86,144.99 153.16,144.7 153.16,143.12 152.94,142.89 152.94,141.69 149.92,138.67 139.55,138.67 135.64,134.76 127.45,134.76 126.99,134.3 v6(126.7,134.3)
  BOTTOM w0.133: U7000.D17 v6(126.7,134.3) ; U7801.T11 v6(153.26,145.96)
FBC_D51: length 35.3
  TOP w0.133: v1(153.09,144.54) 152.62,144.54 v6(152.44,144.36)
  IN4 w0.095: v6(125.1,134.3) 125.59,134.79 127.18,134.79 127.44,135.05 135.51,135.05 139.42,138.96 149.8,138.96 152.65,141.81 152.65,143.01 152.83,143.19 152.83,143.97 v6(152.44,144.36)
  BOTTOM w0.133: U7000.E17 v6(125.1,134.3) ; v6(152.44,144.36) 152.73,144.07 152.73,144.06 U7801.T13
FBC_D52: length 34.8
  TOP w0.133: v6(150.01,145.98) 150.01,146.58 v1(150.04,146.6)
  IN4 w0.095: v6(124.3,135.9) 124.68,135.52 126.89,135.52 127.46,136.09 128,136.09 128.65,136.74 135.23,136.74 139.83,141.34 146.55,141.34 147.35,142.13 150.12,142.13 150.61,142.62 150.61,145.39 v6(150.01,145.98)
  BOTTOM w0.133: U7000.F18 v6(124.3,135.9) ; U7801.N11 v6(150.01,145.98)
FBC_D53: length 30.3
  TOP w0.133: v1(150.62,143.15) 150.53,143.15 v6(150.08,143.59)
  IN4 w0.095: v6(125.1,135.9) 125.1,135.9 125.57,136.37 127.85,136.37 128.65,137.17 135.17,137.17 139.62,141.62 146.37,141.62 147.16,142.42 149.44,142.42 149.72,142.69 149.72,142.91 150.08,143.28 v6(150.08,143.59)
  BOTTOM w0.133: U7000.E18 v6(125.1,135.9) ; v6(150.08,143.59) U7801.N13
FBC_D54: length 27.8
  TOP w0.133: v6(149.28,143.58) 148.59,142.89 v1(148.49,142.89)
  IN4 w0.095: v6(149.28,143.58) 149.07,143.58 148.59,143.1 145.62,143.1 144.72,142.19 139.01,142.19 134.7,137.89 128.53,137.89 127.51,136.86 127.3,136.86 v6(126.68,137.48)
  BOTTOM w0.133: v6(149.28,143.58) 149.28,143.58 U7801.M13 ; v6(126.68,137.48) 126.31,137.1 U7000.D20
