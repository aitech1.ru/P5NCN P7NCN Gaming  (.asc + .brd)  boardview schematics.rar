# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Nets (continued)
+3VS_EDP: C4515.1 C4516.1 C4532.1 C4542.1 CON4500.17 CON4500.18 CON4500.19 R4523.1 R4525.1 T4504.1 U4502.6
+3VS_GSENSOR: R5808.2 U5800.3
+3VS_HDMI: C1301.2 C1302.1 R1302.1 R1303.2 R1304.1 R1306.1 R1308.1 R1314.1 R1316.1 R1317.1 R1320.1 U1301.1 U1301.6 U1301.12 U1301.25 U1301.32 U1301.36
+3VS_PWR: CON402.18 PC700.1 PCON702.2
+3VS_S0: C1155.1 C1156.1 C1157.1 C1158.1 C1188.1 L1106.2 R1109.2 R1110.2 R1111.2 R1130.2 R1134.2 R1143.2 R1144.2 R1159.2 R1164.2 U1101.A2 U1101.A3 U1101.B3 U1101.H9
+3VS_S0_TBT: C1187.1 C1191.1 C1192.1 L1106.1 U1101.R13
+3VS_SSD: C5116.1 C5117.1 C5118.2 C5119.1 C5125.1 C5126.1 C5127.1 C5128.1 C5138.1 C5139.1 C5162.1 C5168.1 CON5103.2 CON5103.4 CON5103.70 CON5103.72 CON5103.74 R5130.2
+3VS_SSD_PCIE: C5120.1 C5133.1 C5134.1 C5135.1 C5136.1 C5137.1 C5161.1 CON5102.2 CON5102.4 CON5102.12 CON5102.14 CON5102.16 CON5102.18 CON5102.70 CON5102.72 CON5102.74 R5115.1 R5129.2
+3VS_TP: C3104.1 Q2301.1 R2310.1 R2312.1 R2313.1 R3072.1 R3073.1 R3163.1 R3166.2 R3169.2 R3170.1
+3VS_TPM: C6202.1 C6203.1 C6204.1 C6205.1 C6206.1 R6202.2 U6200.10 U6200.19 U6200.24
+3VS_TYPEC: C1203.1 C1204.1 R1227.2 R1228.2 R1230.2 R1231.2 R1232.2 R1237.2 R1238.2 U1201.B1 U1201.H1
+3VS_VGA: C4612.1 C4636.2 F4601.1 Q4601.3 R4601.1 R4603.2 R4607.1 R4621.1 R4623.1 R4625.1 R4627.1 R4631.1 U4601.1 U4601.6 U4601.12 U4601.25 U4601.32 U4601.36
+3VSUS: C0702.1 C0703.2 C2404.2 C2405.2 C2611.1 C2612.1 C2616.1 C2617.1 C2621.1 C8126.1 C8127.1 JP8102.1 JP8108.1 JP8109.1 Q5300.2 R1160.1 R1237.1 R2100.1 R2102.1 R2103.1 R2104.1 R2105.1 R2107.1 R2108.1 R2113.1 R2114.1 R2115.1 R2116.1 R2117.1 R2118.1 R2119.1 R2120.1 R2122.1 R2123.1 R2124.1 R2125.1 R2157.1 R2164.1 R2243.1 R2248.1 R2259.1 R2302.1 R2303.1 R2304.1 R2305.1 R2309.1 R2314.1 R2315.1 R2316.1 R2317.1 R2318.1 R2319.1 R2327.1 R2328.1 R2329.1 R2330.1 R2331.1 R2332.1 R2333.1 R2334.1 R2335.1 R2357.1 R2358.1 R2363.1 R2369.1 R2370.1 R2371.1 R2372.1 R2378.1 R2381.1 R2400.1 R2401.1 R2402.1 R2406.1 R2407.1 R2408.1 R2409.1 R2410.1 R2411.1 R2412.1 R2414.1 R2415.1 R2416.1 R2417.1 R2418.1 R2420.1 R2421.1 R2422.1 R2423.1 R2428.1 R2429.1 R2430.1 R2431.1 R2432.1 R2433.1 R2434.1 R2435.1 R2436.1 R2437.1 R2442.1 R2444.1 R2445.1 R2446.1 R2447.1 R2463.1 R2464.1 R2465.1 R2466.1 R2467.1 R2469.1 R2470.1 R2471.1 R2472.1 R2473.1 R2603.1 R2605.1 R2608.1 R2615.2 R2616.2 R2617.2 R3162.2 R3165.2 R3167.1 R3309.1 R3621.1 R4411.1 R5208.1 R6201.1 R9202.1 SP2601.2 T8112.1 T8113.1 U0702.5 U0703.5 U2000.BA20 U2402.5 U2403.5 U2404.5 U9200.5 U9201.5
+3VSUS_LAN: C3309.1 C3310.1 C3311.1 C3312.1 C3322.1 C3323.1 R3301.2 R3307.1 R3309.2 U3300.1 U3300.16
+3VSUS_LC: C1185.1 R1112.1 R1113.1 R1114.1 R1115.1 U1101.R6
+3VSUS_PGPPA: C2630.1 R2236.1 R2237.1 R2238.1 R2239.1 R2240.1 R2241.1 R2242.1 R2250.1 SP2601.1 U2000.BA31
+3VSUS_SPI: C3100.1 C3101.1 C4404.2 CON4402.1 CON4402.3 D3104.3 R3116.1 R3124.1 U3101.8
+3VSUS_SX: C1186.1 R1131.2 R1132.2 R1135.2 R1138.2 R1140.2 R1141.2 R1145.2 R1146.2 R1160.2 R1161.1 R1164.1 U1101.F8
+3VSUS_TPM: C6200.1 C6201.1 R6201.2 U6200.5
+5V: C9126.1 C9131.1 T9112.1 U9103.8 U9103.9 U9103.13 U9103.14
+5V_FAN0: C5003.1 CON5000.4 U5001.3
+5V_FAN1: C5001.1 CON5001.4 U5002.3
+5V_LED: CON1.6 LR800.2
+5V_LED_RLED1_Q2: LLED802.2 LQ803.3
+5V_LED_RLED2: LLED802.1 LR802.1
+5V_RLED1: LLED800.1 LR800.1
+5V_RLED1_Q: LLED800.2 LQ800.3
+5V_RYLED_R: LLED801.2 LQ801.3
+5V_RYLED_R1: LLED801.1 LR803.1
+5V_RYLED_Y: LLED803.2 LQ802.3
+5V_RYLED_Y1: LLED803.1 LR801.1
+5V_USB: C5501.1 C5505.1 CE5503.1 CON5501.1 D5506.1 U5501.1
+5VA: CON5602.27 JP8100.2 R5302.2 T8114.1
+5VA_LED: CON1.7 LR801.2 LR803.2
+5VA_PWR: CON402.27 PCON700.2
+5VAO: C8100.1 JP8100.1 T8100.1 U8100.13
+5VO: C8109.1 C8130.1 C8131.1 C8830.1 C9105.1 C9114.1 C9121.1 C9130.1 C9132.1 CE8100.1 CE8102.1 JP8101.1 JP8103.1 JP8104.1 JP8110.1 JP8111.1 L8100.1 R8400.1 R8820.2 SR8104.2 SR8302.1 T8108.1 T8109.1 U8801.5 U9100.4 U9101.4 U9102.4 U9102.7 U9103.1 U9103.2 U9103.4 U9103.6 U9103.7
+5VO_1_1: C8120.1 D8102.3
+5VO_1_2: C8119.1 D8102.1 SR8104.1
+5VO_2_2: C8122.2 D8103.3
+5VS: C3633.1 C4543.1 C5175.1 C8065.2 C8066.2 C8067.2 C8068.2 C8069.2 C8070.2 C9125.1 C80019.2 C80025.2 C80064.2 C80066.2 C80082.2 CON3104.2 CON3110.1 CON3110.2 CON5602.26 D5000.3 D5002.3 L3606.2 L3607.1 Q4804.2 Q5101.3 R3714.2 R4313.1 R4314.2 R4503.1 R5137.2 R8006.1 R8007.1 R8008.1 R8032.1 R8034.1 R8076.2 R8091.1 R8714.2 R8728.2 R8729.2 R8905.1 R80103.1 SP5101.1 SR8000.2 T9106.1 U4502.3 U5001.2 U5002.2 U5103.2 U8001.3 U8001.29 U8002.3 U8002.29 U8003.3 U8003.29 U8004.3 U8004.29 U8005.6 U8006.3 U8006.29 U9102.8
+5VS_3DCAM: CON4301.9 CON4301.10 R4313.2
+5VS_AVDD: C3605.1 C3606.1 L3606.1 U3600.26
+5VS_FAN2: D5101.1 U5103.3
+5VS_HDD: C5106.1 C5107.1 C5147.1 C5160.1 C5167.1 CON5100.7 CON5100.8 CON5100.9 SP5101.2
+5VS_HDMI: C4806.1 CON4800.18 D4800.3 F4800.2
+5VS_LED: CON1.8 LR802.2 LR804.1
+5VS_LGF: C4538.1 CON4500.37 R4503.2 T4509.1
+5VS_ODD_FAN: C5144.2 C5145.1 C5169.1 CON5101.P2 CON5101.P3 D5101.2 Q5101.2
+5VS_PWR: CON402.26 PCON700.1
+5VS_TS: CON4301.16 CON4301.17 R4314.1
+5VSUS: C3608.1 C3609.1 C3711.1 C5200.2 C5507.1 C6700.1 CE6703.1 CON5602.19 CON6701.3 CON6701.4 CON6701.5 JP8101.2 JP8110.2 JP8111.2 L3601.1 R3713.2 R5207.1 R5209.1 SP1202.1 T8117.1 T8118.1 U4501.5 U5200.1 U5501.5
+5VSUS_CHARGING: C5201.1 C5202.1 C5502.1 C5503.1 C5506.1 CE5502.1 CON5500.1 D5505.1 U5200.12
+5VSUS_PVDD: C3700.1 C3701.1 R3707.2 R3708.2 R3713.1 R3714.1 U3700.3 U3700.4
+5VSUS_PWR: CON402.19 PCON700.3 PCON702.1 PR701.2 PR703.2
+5VSUS_TYPEC: C1209.1 C1210.1 C1211.1 C1212.1 SP1202.2 U1201.A11 U1201.B11 U1201.C11 U1201.D11 U1201.H10
+10VO: C8121.1 D8102.2 D8103.1 T8120.1
+12V: Q9103.4 R9108.1 T9110.1
+12VO: C8123.1 D8103.2 JP8107.1 T8126.1
+12VS: Q4804.1 Q9102.4 R4629.1 R5136.1 R9107.1 T9107.1
+12VSUS: JP8107.2 Q9101.3 Q9102.3 Q9103.3 Q9104.3 T8127.1
+AVDDH: C3317.1 C3318.1 C3319.1 U3300.9 U3300.22
+AVDDL: C3308.2 C3315.1 C3316.1 C3320.1 C3321.1 L3301.2 L3302.1 U3300.6 U3300.13 U3300.19 U3300.31
+AVDDVCO: C3303.1 C3304.1 C3305.1 L3301.1 U3300.34
+DVDDIO_AUDIO_W10MIL: C2629.1 R2608.2 U2000.BA15
+DVDDL: C3300.1 C3301.1 C3302.1 C3306.2 C3307.2 L3300.1 L3302.2 U3300.37
+V1P0A_VCCAMPHYPLL_W25MIL: C2613.1 C2614.1 C2615.1 R2606.2 U2000.A43 U2000.B43 U2000.C44 U2000.C45
+V1P0A_VCCAPLL_W15MIL: C2618.1 C2619.1 R2607.2 U2000.AJ5 U2000.AL5 U2000.AN19
+V1P0A_VCCF24_W15MIL: C2605.1 C2606.1 C2607.1 R2604.2 U2000.K2 U2000.K3
+VBUS1: C1217.2 C1218.1 C1219.1 C1220.1 C1222.1 C1225.1 C1226.1 C1227.1 C1228.1 CE1225.1 CON1201.A4 CON1201.A9 CON1201.B4 CON1201.B9 D1209.2 U1201.A10 U1201.B10 U1201.H11 U1201.J10 U1201.J11 U1201.K11
+VCC_RTC: C2826.1 D2801.3 R2448.1 R2609.1 R2810.1 R2812.1 R6006.1
+VCC_SYS_HV: T1205.1 T1206.1 U1201.A6 U1201.A7 U1201.A8 U1201.B7
+VCCGT: C0963.1 C0964.1 C0965.1 C0966.1 C0967.1 C0968.1 C0969.1 C0970.1 C0971.1 C0972.1 C0973.1 C0974.1 C0975.1 C0976.1 C0977.1 C0978.1 C0979.1 C0980.1 C0981.1 C0982.1 C0983.1 C0984.1 C0985.1 C0986.1 C0987.1 C0988.1 C0989.1 C0990.1 C0991.1 C0992.1 C0993.1 C0994.1 C0995.1 C0996.1 C0997.1 C0998.1 C0999.1 C09100.1 C09101.1 C09102.1 C09103.1 C09104.1 C09105.1 C09106.1 C09107.1 C09108.1 C09109.1 C09110.1 C09111.1 C09112.1 C09113.1 C09114.1 C09115.1 C09116.1 C09117.1 C09118.1 C09119.1 C09120.1 C09121.1 C09122.1 C09123.1 C09124.1 C09125.1 C09126.1 C09127.1 C09128.1 C09129.1 C09130.1 C80004.2 C80008.2 C80009.2 C80010.2 C80012.2 C80013.2 C80017.2 C80022.2 C80023.2 C80024.2 C80032.2 C80039.2 C80040.2 C80057.2 C80062.2 C80068.2 C80069.2 C80077.2 C80095.2 C80098.2 C80102.2 C80112.2 C80113.2 C80114.2 C80115.2 C80116.2 C80117.2 C80118.2 C80119.2 C80121.2 C80124.1 C80125.1 CE8004.1 CE8007.1 JP8057.2 JP8060.2 L8003.2 L8004.2 R8019.1 U0300.AJ29 U0300.AJ30 U0300.AJ31 U0300.AJ32 U0300.AJ33 U0300.AJ34 U0300.AJ35 U0300.AJ36 U0300.AK31 U0300.AK32 U0300.AK33 U0300.AK34 U0300.AK35 U0300.AK36 U0300.AK37 U0300.AK38 U0300.AL13 U0300.AL29 U0300.AL30 U0300.AL31 U0300.AL32 U0300.AL35 U0300.AL36 U0300.AL37 U0300.AL38 U0300.AM13 U0300.AM14 U0300.AM29 U0300.AM30 U0300.AM31 U0300.AM32 U0300.AM33 U0300.AM34 U0300.AM35 U0300.AM36 U0300.AN13 U0300.AN14 U0300.AN31 U0300.AN32 U0300.AN33 U0300.AN34 U0300.AN35 U0300.AN36 U0300.AN37 U0300.AN38 U0300.AP13 U0300.AP14 U0300.AP29 U0300.AP30 U0300.AP31 U0300.AP32 U0300.AP35 U0300.AP36 U0300.AP37 U0300.AP38 U0300.AR29 U0300.AR30 U0300.AR31 U0300.AR32 U0300.AR33 U0300.AR34 U0300.AR35 U0300.AR36 U0300.AT14 U0300.AT31 U0300.AT32 U0300.AT33 U0300.AT34 U0300.AT35 U0300.AT36 U0300.AT37 U0300.AT38 U0300.AU14 U0300.AU29 U0300.AU30 U0300.AU31 U0300.AU32 U0300.AU35 U0300.AU36 U0300.AU37 U0300.AU38 U0300.AV29 U0300.AV30 U0300.AV31 U0300.AV32 U0300.AV33 U0300.AV34 U0300.AV35 U0300.AV36 U0300.AW14 U0300.AW31 U0300.AW32 U0300.AW33 U0300.AW34 U0300.AW35 U0300.AW36 U0300.AW37 U0300.AW38 U0300.AY29 U0300.AY30 U0300.AY31 U0300.AY32 U0300.AY35 U0300.AY36 U0300.AY37 U0300.AY38 U0300.BA13 U0300.BA14 U0300.BA29 U0300.BA30 U0300.BA31 U0300.BA32 U0300.BA33 U0300.BA34 U0300.BA35 U0300.BA36 U0300.BB13 U0300.BB14 U0300.BB31 U0300.BB32 U0300.BB33 U0300.BB34 U0300.BB35 U0300.BB36 U0300.BB37 U0300.BB38 U0300.BC29 U0300.BC30 U0300.BC31 U0300.BC32 U0300.BC35 U0300.BC36 U0300.BC37 U0300.BC38 U0300.BD13 U0300.BD14 U0300.BD29 U0300.BD30 U0300.BD31 U0300.BD32 U0300.BD33 U0300.BD34 U0300.BD35 U0300.BD36 U0300.BE31 U0300.BE32 U0300.BE33 U0300.BE34 U0300.BE35 U0300.BE36 U0300.BE37 U0300.BE38 U0300.BF13 U0300.BF14 U0300.BF29 U0300.BF30 U0300.BF31 U0300.BF32 U0300.BF35 U0300.BF36 U0300.BF37 U0300.BF38 U0300.BG29 U0300.BG30 U0300.BG31 U0300.BG32 U0300.BG33 U0300.BG34 U0300.BG35 U0300.BG36 U0300.BH33 U0300.BH34 U0300.BH35 U0300.BH36 U0300.BH37 U0300.BH38 U0300.BJ37 U0300.BJ38 U0300.BL36 U0300.BL37 U0300.BM36 U0300.BM37 U0300.BN36 U0300.BN37 U0300.BN38 U0300.BP37 U0300.BP38 U0300.BR37 U0300.BT37
+VCCIO: C9414.1 C9415.1 JP9400.1 R0300.1 R0600.1 R0700.1 R0744.1 R0745.1 R4409.1 T9401.1 T9402.1 U0300.AG12 U0300.G15 U0300.G17 U0300.G19 U0300.G21 U0300.H15 U0300.H16 U0300.H17 U0300.H19 U0300.H20 U0300.H21 U0300.H26 U0300.H27 U0300.J15 U0300.J16 U0300.J17 U0300.J19 U0300.J20 U0300.J21 U0300.J26 U0300.J27
+VCCIO_PWRGD: R9212.1 T9209.1 U9400.12
+VCCPFUSE_W20MIL: C2610.1 R2605.2 U2000.AN5 U2000.BD3 U2000.BE3 U2000.BE4
+VCCPGPPCD_W15MIL: R2603.2 U2000.BA45 U2000.BB45 U2000.BC44 U2000.BC45
+VCCPLL_OC: C1001.1 C1002.1 R1018.2 U0300.BH13 U0300.G11
+VCCRTC_W8MIL: C2624.1 C2625.1 R2609.2 U2000.BA22
+VCCSA: C80029.2 C80031.2 C80044.2 C80049.2 C80059.2 C80126.1 C80127.1 C80128.2 C80129.2 C80130.2 C80131.2 C80132.2 JP8061.2 L8005.2 R8075.2 U0300.J30 U0300.K29 U0300.K30 U0300.K31 U0300.K32 U0300.K33 U0300.K34 U0300.K35 U0300.L31 U0300.L32 U0300.L35 U0300.L36 U0300.L37 U0300.L38 U0300.M29 U0300.M30 U0300.M31 U0300.M32 U0300.M33 U0300.M34 U0300.M35 U0300.M36
AGND: C3600.2 C3601.2 C3605.2 C3606.2 C3607.2 C3612.2 C3613.2 C3645.2 C3646.2 C3647.2 C3709.2 C6704.2 C6705.2 CON6700.16 CON6700.23 D3600.2 R3600.2 R3629.2 R3630.2 R3631.2 R3709.1 R3710.1 R3711.2 R3712.2 U3600.25 U3600.38
