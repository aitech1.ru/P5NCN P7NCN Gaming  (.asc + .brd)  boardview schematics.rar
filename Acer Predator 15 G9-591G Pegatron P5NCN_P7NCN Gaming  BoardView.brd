# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
VX_BGA_337P_421X421
  round 0.254 smd: A1(5.06,-5.06) A23(-5.06,-5.06) AA2(4.6,4.14) AA22(-4.6,4.14) AB2(4.6,4.6) AB3(4.14,4.6) AB4(3.68,4.6) AB5(3.22,4.6) AB6(2.76,4.6) AB7(2.3,4.6) AB8(1.84,4.6) AB9(1.38,4.6) AB10(0.92,4.6) AB11(0.46,4.6) AB12(0,4.6) AB13(-0.46,4.6) AB14(-0.92,4.6) AB15(-1.38,4.6) AB16(-1.84,4.6) AB17(-2.3,4.6) AB18(-2.76,4.6) AB19(-3.22,4.6) AB20(-3.68,4.6) AB21(-4.14,4.6) AB22(-4.6,4.6) AC1(5.06,5.06) AC23(-5.06,5.06) B2(4.6,-4.6) B3(4.14,-4.6) B4(3.68,-4.6) B5(3.22,-4.6) B6(2.76,-4.6) B7(2.3,-4.6) B8(1.84,-4.6) B9(1.38,-4.6) B10(0.92,-4.6) B11(0.46,-4.6) B12(0,-4.6) B13(-0.46,-4.6) B14(-0.92,-4.6) B15(-1.38,-4.6) B16(-1.84,-4.6) B17(-2.3,-4.6) B18(-2.76,-4.6) B19(-3.22,-4.6) B20(-3.68,-4.6) B21(-4.14,-4.6) B22(-4.6,-4.6) C2(4.6,-4.14) C22(-4.6,-4.14) D2(4.6,-3.68) D4(3.9,-3.9) D5(3.25,-3.9) D6(2.6,-3.9) D8(1.95,-3.9) D9(1.3,-3.9) D11(0.65,-3.9) D12(0,-3.9) D13(-0.65,-3.9) D15(-1.3,-3.9) D16(-1.95,-3.9) D18(-2.6,-3.9) D19(-3.25,-3.9) D20(-3.9,-3.9) D22(-4.6,-3.68) E2(4.6,-3.22) E4(3.9,-3.25) E5(3.25,-3.25) E6(2.6,-3.25) E8(1.95,-3.25) E9(1.3,-3.25) E11(0.65,-3.25) E12(0,-3.25) E13(-0.65,-3.25) E15(-1.3,-3.25) E16(-1.95,-3.25) E18(-2.6,-3.25) E19(-3.25,-3.25) E20(-3.9,-3.25) E22(-4.6,-3.22) F2(4.6,-2.76) F4(3.9,-2.6) F5(3.25,-2.6) F6(2.6,-2.6) F8(1.95,-2.6) F9(1.3,-2.6) F11(0.65,-2.6) F12(0,-2.6) F13(-0.65,-2.6) F15(-1.3,-2.6) F16(-1.95,-2.6) F18(-2.6,-2.6) F19(-3.25,-2.6) F20(-3.9,-2.6) F22(-4.6,-2.76) G2(4.6,-2.3) G22(-4.6,-2.3) H2(4.6,-1.84) H4(3.9,-1.95) H5(3.25,-1.95) H6(2.6,-1.95) H8(1.95,-1.95) H9(1.3,-1.95) H11(0.65,-1.95) H12(0,-1.95) H13(-0.65,-1.95) H15(-1.3,-1.95) H16(-1.95,-1.95) H18(-2.6,-1.95) H19(-3.25,-1.95) H20(-3.9,-1.95) H22(-4.6,-1.84) J2(4.6,-1.38) J4(3.9,-1.3) J5(3.25,-1.3) J6(2.6,-1.3) J8(1.95,-1.3) J9(1.3,-1.3) J11(0.65,-1.3) J12(0,-1.3) J13(-0.65,-1.3) J15(-1.3,-1.3) J16(-1.95,-1.3) J18(-2.6,-1.3) J19(-3.25,-1.3) J20(-3.9,-1.3) J22(-4.6,-1.38) K2(4.6,-0.92) K22(-4.6,-0.92) L2(4.6,-0.46) L4(3.9,-0.65) L5(3.25,-0.65) L6(2.6,-0.65) L8(1.95,-0.65) L9(1.3,-0.65) L11(0.65,-0.65) L12(0,-0.65) L13(-0.65,-0.65) L15(-1.3,-0.65) L16(-1.95,-0.65) L18(-2.6,-0.65) L19(-3.25,-0.65) L20(-3.9,-0.65) L22(-4.6,-0.46) M2(4.6,0) M4(3.9,0) M5(3.25,0) M6(2.6,0) M8(1.95,0) M9(1.3,0) M11(0.65,0) M12(0,0) M13(-0.65,0) M15(-1.3,0) M16(-1.95,0) M18(-2.6,0) M19(-3.25,0) M20(-3.9,0) M22(-4.6,0) N2(4.6,0.46) N4(3.9,0.65) N5(3.25,0.65) N6(2.6,0.65) N8(1.95,0.65) N9(1.3,0.65) N11(0.65,0.65) N12(0,0.65) N13(-0.65,0.65) N15(-1.3,0.65) N16(-1.95,0.65) N18(-2.6,0.65) N19(-3.25,0.65) N20(-3.9,0.65) N22(-4.6,0.46) P2(4.6,0.92) P22(-4.6,0.92) R2(4.6,1.38) R4(3.9,1.3) R5(3.25,1.3) R6(2.6,1.3) R8(1.95,1.3) R9(1.3,1.3) R11(0.65,1.3) R12(0,1.3) R13(-0.65,1.3) R15(-1.3,1.3) R16(-1.95,1.3) R18(-2.6,1.3) R19(-3.25,1.3) R20(-3.9,1.3) R22(-4.6,1.38) T2(4.6,1.84) T4(3.9,1.95) T5(3.25,1.95) T6(2.6,1.95) T8(1.95,1.95) T9(1.3,1.95) T11(0.65,1.95) T12(0,1.95) T13(-0.65,1.95) T15(-1.3,1.95) T16(-1.95,1.95) T18(-2.6,1.95) T19(-3.25,1.95) T20(-3.9,1.95) T22(-4.6,1.84) U2(4.6,2.3) U22(-4.6,2.3) V2(4.6,2.76) V4(3.9,2.6) V5(3.25,2.6) V6(2.6,2.6) V8(1.95,2.6) V9(1.3,2.6) V11(0.65,2.6) V12(0,2.6) V13(-0.65,2.6) V15(-1.3,2.6) V16(-1.95,2.6) V18(-2.6,2.6) V19(-3.25,2.6) V20(-3.9,2.6) V22(-4.6,2.76) W2(4.6,3.22) W4(3.9,3.25) W5(3.25,3.25) W6(2.6,3.25) W8(1.95,3.25) W9(1.3,3.25) W11(0.65,3.25) W12(0,3.25) W13(-0.65,3.25) W15(-1.3,3.25) W16(-1.95,3.25) W18(-2.6,3.25) W19(-3.25,3.25) W20(-3.9,3.25) W22(-4.6,3.22) Y2(4.6,3.68) Y4(3.9,3.9) Y5(3.25,3.9) Y6(2.6,3.9) Y8(1.95,3.9) Y9(1.3,3.9) Y11(0.65,3.9) Y12(0,3.9) Y13(-0.65,3.9) Y15(-1.3,3.9) Y16(-1.95,3.9) Y18(-2.6,3.9) Y19(-3.25,3.9) Y20(-3.9,3.9) Y22(-4.6,3.68)
  oval 0.178x0.33 smd: A2(4.6,-5.06) A3(4.14,-5.06) A4(3.68,-5.06) A5(3.22,-5.06) A6(2.76,-5.06) A7(2.3,-5.06) A8(1.84,-5.06) A9(1.38,-5.06) A10(0.92,-5.06) A11(0.46,-5.06) A12(0,-5.06) A13(-0.46,-5.06) A14(-0.92,-5.06) A15(-1.38,-5.06) A16(-1.84,-5.06) A17(-2.3,-5.06) A18(-2.76,-5.06) A19(-3.22,-5.06) A20(-3.68,-5.06) A21(-4.14,-5.06) A22(-4.6,-5.06) AC2(4.6,5.06) AC3(4.14,5.06) AC4(3.68,5.06) AC5(3.22,5.06) AC6(2.76,5.06) AC7(2.3,5.06) AC8(1.84,5.06) AC9(1.38,5.06) AC10(0.92,5.06) AC11(0.46,5.06) AC12(0,5.06) AC13(-0.46,5.06) AC14(-0.92,5.06) AC15(-1.38,5.06) AC16(-1.84,5.06) AC17(-2.3,5.06) AC18(-2.76,5.06) AC19(-3.22,5.06) AC20(-3.68,5.06) AC21(-4.14,5.06) AC22(-4.6,5.06)
  oval 0.33x0.178 smd: AA1(5.06,4.14) AA23(-5.06,4.14) AB1(5.06,4.6) AB23(-5.06,4.6) B1(5.06,-4.6) B23(-5.06,-4.6) C1(5.06,-4.14) C23(-5.06,-4.14) D1(5.06,-3.68) D23(-5.06,-3.68) E1(5.06,-3.22) E23(-5.06,-3.22) F1(5.06,-2.76) F23(-5.06,-2.76) G1(5.06,-2.3) G23(-5.06,-2.3) H1(5.06,-1.84) H23(-5.06,-1.84) J1(5.06,-1.38) J23(-5.06,-1.38) K1(5.06,-0.92) K23(-5.06,-0.92) L1(5.06,-0.46) L23(-5.06,-0.46) M1(5.06,0) M23(-5.06,0) N1(5.06,0.46) N23(-5.06,0.46) P1(5.06,0.92) P23(-5.06,0.92) R1(5.06,1.38) R23(-5.06,1.38) T1(5.06,1.84) T23(-5.06,1.84) U1(5.06,2.3) U23(-5.06,2.3) V1(5.06,2.76) V23(-5.06,2.76) W1(5.06,3.22) W23(-5.06,3.22) Y1(5.06,3.68) Y23(-5.06,3.68)
VX_BGA_837P_906X906_INT
  round 0.305 smd: A2(10.814,10.46) A3(10.814,9.959) A4(10.814,9.459) A42(10.814,-9.459) A43(10.814,-9.959) A44(10.814,-10.46) AA17(0.775,3.099) AA18(0.775,2.324) AA20(0.775,1.549) AA21(0.775,0.775) AA23(0.775,0) AA25(0.775,-0.775) AA26(0.775,-1.549) AA28(0.775,-2.324) AA29(0.775,-3.099) AB7(0.667,8.175) AB8(0.667,7.413) AB10(0.667,6.651) AB11(0.667,5.889) AB13(0.667,5.127) AB14(0.667,4.365) AB15(0.667,3.807) AB31(0.667,-3.807) AB32(0.667,-4.365) AB33(0.667,-5.127) AB35(0.667,-5.889) AB36(0.667,-6.651) AB38(0.667,-7.413) AB39(0.667,-8.175) AC17(0,3.099) AC18(0,2.324) AC20(0,1.549) AC21(0,0.775) AC23(0,0) AC25(0,-0.775) AC26(0,-1.549) AC28(0,-2.324) AC29(0,-3.099) AD7(-0.667,8.175) AD8(-0.667,7.413) AD10(-0.667,6.651) AD11(-0.667,5.889) AD13(-0.667,5.127) AD14(-0.667,4.365) AD15(-0.667,3.807) AD31(-0.667,-3.807) AD32(-0.667,-4.365) AD33(-0.667,-5.127) AD35(-0.667,-5.889) AD36(-0.667,-6.651) AD38(-0.667,-7.413) AD39(-0.667,-8.175) AE17(-0.775,3.099) AE18(-0.775,2.324) AE20(-0.775,1.549) AE21(-0.775,0.775) AE23(-0.775,0) AE25(-0.775,-0.775) AE26(-0.775,-1.549) AE28(-0.775,-2.324) AE29(-0.775,-3.099) AF17(-1.549,3.099) AF18(-1.549,2.324) AF20(-1.549,1.549) AF21(-1.549,0.775) AF23(-1.549,0) AF25(-1.549,-0.775) AF26(-1.549,-1.549) AF28(-1.549,-2.324) AF29(-1.549,-3.099) AG7(-1.772,8.175) AG8(-1.772,7.413) AG10(-1.772,6.651) AG11(-1.772,5.889) AG13(-1.772,5.127) AG14(-1.772,4.365) AG15(-1.772,3.807) AG31(-1.772,-3.807) AG32(-1.772,-4.365) AG33(-1.772,-5.127) AG35(-1.772,-5.889) AG36(-1.772,-6.651) AG38(-1.772,-7.413) AG39(-1.772,-8.175) AH17(-2.324,3.099) AH18(-2.324,2.324) AH20(-2.324,1.549) AH21(-2.324,0.775) AH23(-2.324,0) AH25(-2.324,-0.775) AH26(-2.324,-1.549) AH28(-2.324,-2.324) AH29(-2.324,-3.099) AJ7(-2.953,8.074) AJ8(-2.953,7.312) AJ10(-2.953,6.55) AJ11(-2.953,5.788) AJ13(-2.953,5.026) AJ14(-2.953,4.315) AJ15(-2.953,3.807) AJ17(-3.099,3.099) AJ18(-3.099,2.324) AJ20(-3.099,1.549) AJ21(-3.099,0.775) AJ23(-3.099,0) AJ25(-3.099,-0.775) AJ26(-3.099,-1.549) AJ28(-3.099,-2.324) AJ29(-3.099,-3.099) AJ31(-2.953,-3.807) AJ32(-2.953,-4.365) AJ33(-2.953,-5.127) AJ35(-2.953,-5.889) AJ36(-2.953,-6.651) AJ38(-2.953,-7.413) AJ39(-2.953,-8.175) AL7(-4.071,8.074) AL8(-4.071,7.312) AL10(-4.071,6.55) AL11(-4.071,5.788) AL13(-4.071,5.026) AL17(-3.807,2.953) AL19(-3.807,1.772) AL22(-3.807,0.667) AL24(-3.807,-0.667) AL27(-3.807,-1.772) AL29(-3.807,-2.953) AL32(-4.096,-4.34) AL33(-4.096,-5.102) AL35(-4.096,-5.864) AL36(-4.096,-6.626) AL38(-4.096,-7.388) AL39(-4.096,-8.15) AM15(-4.34,4.096) AM17(-4.365,2.953) AM19(-4.365,1.772) AM22(-4.365,0.667) AM24(-4.365,-0.667) AM27(-4.365,-1.772) AM29(-4.315,-2.953) AN7(-5.036,8.023) AN8(-4.985,7.261) AN10(-4.985,6.499) AN11(-5.026,5.753) AN15(-5.102,4.096) AN17(-5.127,2.953) AN19(-5.127,1.772) AN22(-5.127,0.667) AN24(-5.127,-0.667) AN27(-5.127,-1.772) AN29(-5.026,-2.953) AN31(-5.026,-4.071) AN36(-5.087,-6.47) AN38(-5.087,-7.232) AN39(-5.087,-7.994) AP11(-5.551,6.04) AR7(-6.037,7.999) AR9(-6.077,7.084) AR15(-5.864,4.096) AR17(-5.889,2.953) AR19(-5.889,1.772) AR22(-5.889,0.667) AR24(-5.889,-0.667) AR27(-5.889,-1.772) AR29(-5.788,-2.953) AR31(-5.788,-4.071) AR33(-5.753,-5.026) AR34(-6.04,-5.551) AR38(-6.068,-7.396) AR39(-6.068,-8.158) AT9(-6.713,6.938) AT10(-6.663,6.311) AT13(-6.47,5.087) AT15(-6.626,4.096) AT17(-6.651,2.953) AT19(-6.651,1.772) AT22(-6.651,0.667) AT24(-6.651,-0.667) AT27(-6.651,-1.772) AT29(-6.55,-2.953) AT31(-6.55,-4.071) AT33(-6.499,-4.985) AT36(-6.311,-6.663) AU7(-6.994,7.936) AU35(-7.084,-6.077) AU36(-6.938,-6.713) AU39(-7.141,-7.991) AV6(-7.645,8.237) AV11(-7.396,6.068) AV13(-7.232,5.087) AV15(-7.388,4.096) AV17(-7.413,2.953) AV19(-7.413,1.772) AV22(-7.413,0.667) AV24(-7.413,-0.667) AV27(-7.413,-1.772) AV29(-7.312,-2.953) AV31(-7.312,-4.071) AV33(-7.261,-4.985) AW9(-7.991,7.141) AW11(-8.158,6.068) AW13(-7.994,5.087) AW15(-8.15,4.096) AW17(-8.175,2.953) AW19(-8.175,1.772) AW22(-8.175,0.667) AW24(-8.175,-0.667) AW27(-8.175,-1.772) AW29(-8.074,-2.953) AW31(-8.074,-4.071) AW33(-8.023,-5.036) AW35(-7.999,-6.037) AW37(-7.936,-6.994) AY5(-8.585,8.764) AY38(-8.237,-7.645) B1(10.46,10.814) B2(10.33,10.33) B3(10.326,9.824) B43(10.304,-9.8) B44(10.33,-10.33) B45(10.46,-10.814) BA40(-8.764,-8.585) BB1(-9.459,10.814) BB45(-9.459,-10.814) BC1(-9.959,10.814) BC2(-9.824,10.326) BC44(-9.8,-10.304) BC45(-9.959,-10.814) BD1(-10.46,10.814) BD2(-10.33,10.33) BD3(-10.304,9.8) BD43(-10.326,-9.824) BD44(-10.33,-10.33) BD45(-10.46,-10.814) BE2(-10.814,10.46) BE3(-10.814,9.959) BE4(-10.814,9.459) BE42(-10.814,-9.459) BE43(-10.814,-9.959) BE44(-10.814,-10.46) C1(9.959,10.814) C2(9.8,10.304) C42(9.86,-9.288) C44(9.824,-10.326) C45(9.959,-10.814) D1(9.459,10.814) D45(9.459,-10.814) F8(8.237,7.645) G9(7.936,6.994) G11(7.999,6.037) G13(8.023,5.036) G15(8.074,4.071) G17(8.074,2.953) G19(8.175,1.772) G22(8.175,0.667) G24(8.175,-0.667) G27(8.175,-1.772) G29(8.175,-2.953) G31(8.15,-4.096) G33(7.994,-5.087) G35(8.158,-6.068) G37(7.991,-7.141) H13(7.261,4.985) H15(7.312,4.071) H17(7.312,2.953) H19(7.413,1.772) H22(7.413,0.667) H24(7.413,-0.667) H27(7.413,-1.772) H29(7.413,-2.953) H31(7.388,-4.096) H33(7.232,-5.087) H35(7.396,-6.068) J7(7.141,7.991) J10(6.938,6.713) J11(7.084,6.077) J39(6.994,-7.936) K10(6.311,6.663) K13(6.499,4.985) K15(6.55,4.071) K17(6.55,2.953) K19(6.651,1.772) K22(6.651,0.667) K24(6.651,-0.667) K27(6.651,-1.772) K29(6.651,-2.953) K31(6.626,-4.096) K33(6.47,-5.087) K36(6.663,-6.311) K37(6.713,-6.938) L7(6.068,8.158) L8(6.068,7.396) L12(6.04,5.551) L13(5.753,5.026) L15(5.788,4.071) L17(5.788,2.953) L19(5.889,1.772) L22(5.889,0.667) L24(5.889,-0.667) L27(5.889,-1.772) L29(5.889,-2.953) L31(5.864,-4.096) L37(6.077,-7.084) L39(6.037,-7.999) M35(5.551,-6.04) N7(5.087,7.994) N8(5.087,7.232) N10(5.087,6.47) N15(5.026,4.071) N17(5.026,2.953) N19(5.127,1.772) N22(5.127,0.667) N24(5.127,-0.667) N27(5.127,-1.772) N29(5.127,-2.953) N31(5.102,-4.096) N35(5.026,-5.753) N36(4.985,-6.499) N38(4.985,-7.261) N39(5.036,-8.023) P17(4.315,2.953) P19(4.365,1.772) P22(4.365,0.667) P24(4.365,-0.667) P27(4.365,-1.772) P29(4.365,-2.953) P31(4.34,-4.096) R7(4.096,8.15) R8(4.096,7.388) R10(4.096,6.626) R11(4.096,5.864) R13(4.096,5.102) R14(4.096,4.34) R17(3.807,2.953) R19(3.807,1.772) R22(3.807,0.667) R24(3.807,-0.667) R27(3.807,-1.772) R29(3.807,-2.953) R33(4.071,-5.026) R35(4.071,-5.788) R36(4.071,-6.55) R38(4.071,-7.312) R39(4.071,-8.074) U7(2.953,8.175) U8(2.953,7.413) U10(2.953,6.651) U11(2.953,5.889) U13(2.953,5.127) U14(2.953,4.365) U15(2.953,3.807) U17(3.099,3.099) U18(3.099,2.324) U20(3.099,1.549) U21(3.099,0.775) U23(3.099,0) U25(3.099,-0.775) U26(3.099,-1.549) U28(3.099,-2.324) U29(3.099,-3.099) U31(2.953,-3.807) U32(2.953,-4.315) U33(2.953,-5.026) U35(2.953,-5.788) U36(2.953,-6.55) U38(2.953,-7.312) U39(2.953,-8.074) V17(2.324,3.099) V18(2.324,2.324) V20(2.324,1.549) V21(2.324,0.775) V23(2.324,0) V25(2.324,-0.775) V26(2.324,-1.549) V28(2.324,-2.324) V29(2.324,-3.099) W7(1.772,8.175) W8(1.772,7.413) W10(1.772,6.651) W11(1.772,5.889) W13(1.772,5.127) W14(1.772,4.365) W15(1.772,3.807) W31(1.772,-3.807) W32(1.772,-4.365) W33(1.772,-5.127) W35(1.772,-5.889) W36(1.772,-6.651) W38(1.772,-7.413) W39(1.772,-8.175) Y17(1.549,3.099) Y18(1.549,2.324) Y20(1.549,1.549) Y21(1.549,0.775) Y23(1.549,0) Y25(1.549,-0.775) Y26(1.549,-1.549) Y28(1.549,-2.324) Y29(1.549,-3.099)
  round 0.279 smd: A5(10.814,8.959) A41(10.814,-8.959) BA1(-8.959,10.814) BA45(-8.959,-10.814) BE5(-10.814,8.959) BE41(-10.814,-8.959) E1(8.959,10.814) E45(8.959,-10.814)
  round 0.254 smd: A6(10.814,8.458) A25(10.814,-1.225) A40(10.814,-8.458) AB3(0.609,9.888) AB4(0.482,9.403) AB5(0.667,8.937) AB41(0.667,-8.937) AB42(0.509,-9.421) AC3(0.096,9.727) AD3(-0.484,9.929) AD4(-0.509,9.421) AD5(-0.667,8.937) AD41(-0.667,-8.937) AD42(-0.482,-9.403) AF3(-1.664,9.888) AF5(-1.721,8.885) AF41(-1.721,-8.887) AG3(-2.178,9.727) AG4(-1.791,9.403) AG42(-1.764,-9.421) AJ4(-2.783,9.421) AJ5(-2.953,8.836) AJ41(-2.953,-8.937) AJ42(-2.756,-9.403) AL3(-3.937,9.888) AL4(-4.064,9.403) AL5(-4.071,8.836) AL41(-4.096,-8.887) AL42(-4.037,-9.421) AM3(-4.451,9.727) AN3(-5.03,9.929) AN4(-5.056,9.421) AN5(-5.163,8.785) AN41(-5.087,-8.756) AN42(-5.029,-9.403) AR5(-6.182,8.886) AR41(-6.068,-8.92) AT4(-6.338,9.403) AT42(-6.311,-9.421) AU41(-7.09,-9.038) AU43(-6.915,-9.727) AV3(-7.355,9.929) AV4(-7.321,9.229) AV43(-7.391,-9.888) AW4(-8.204,9.434) AW42(-7.816,-9.24) AY1(-8.458,10.814) AY45(-8.458,-10.814) B6(10.296,8.45) B10(10.235,6.724) B25(10.306,-1.225) B40(10.355,-8.701) BA4(-9.12,9.602) BA5(-9.095,8.767) BA9(-9.038,7.09) BA11(-8.92,6.068) BA13(-8.756,5.087) BA15(-8.887,4.096) BA17(-8.937,2.953) BA20(-8.887,1.721) BA22(-8.937,0.667) BA24(-8.937,-0.667) BA26(-8.885,-1.721) BA29(-8.836,-2.953) BA31(-8.836,-4.071) BA33(-8.785,-5.163) BA35(-8.886,-6.182) BA41(-8.767,-9.095) BB3(-9.344,10.162) BB7(-9.24,7.816) BB10(-9.421,6.311) BB13(-9.403,5.029) BB15(-9.421,4.037) BB17(-9.403,2.756) BB19(-9.421,1.764) BB22(-9.403,0.482) BB24(-9.421,-0.509) BB27(-9.403,-1.791) BB29(-9.421,-2.783) BB31(-9.403,-4.064) BB33(-9.421,-5.056) BB36(-9.403,-6.338) BB38(-9.229,-7.321) BB39(-9.434,-8.204) BB41(-9.602,-9.12) BB43(-9.288,-9.86) BC4(-9.86,9.288) BC9(-9.727,6.915) BC42(-10.162,-9.344) BE6(-10.814,8.458) BE40(-10.814,-8.458) C8(9.929,7.355) C10(9.727,6.724) C11(9.888,6.211) C14(9.727,4.451) C15(9.888,3.937) C17(9.929,2.757) C19(9.727,2.178) C20(9.888,1.664) C23(9.727,-0.096) C24(9.888,-0.609) C27(9.929,-1.789) C28(9.727,-2.369) C29(9.888,-2.883) C31(9.929,-4.063) C32(9.727,-4.642) C33(9.888,-5.156) C36(9.929,-6.336) C37(9.727,-6.915) C38(9.888,-7.391) D3(9.288,9.86) D5(9.602,9.12) D7(9.434,8.204) D8(9.229,7.321) D10(9.403,6.338) D13(9.421,5.056) D15(9.403,4.064) D17(9.421,2.783) D19(9.403,1.791) D22(9.421,0.509) D24(9.403,-0.482) D27(9.421,-1.764) D29(9.403,-2.756) D31(9.421,-4.037) D33(9.403,-5.029) D36(9.421,-6.311) D39(9.24,-7.816) D43(9.344,-10.162) E5(8.767,9.095) E6(8.764,8.585) E11(8.886,6.182) E13(8.785,5.163) E15(8.836,4.071) E17(8.836,2.953) E20(8.885,1.721) E22(8.937,0.667) E24(8.937,-0.667) E26(8.887,-1.721) E29(8.937,-2.953) E31(8.887,-4.096) E33(8.756,-5.087) E35(8.92,-6.068) E37(9.038,-7.09) E41(9.095,-8.767) E42(9.12,-9.602) F1(8.458,10.814) F41(8.585,-8.764) F44(8.45,-10.296) F45(8.458,-10.814) G4(7.816,9.24) G42(8.204,-9.434) H2(7.391,10.396) H3(7.391,9.888) H40(7.645,-8.237) H42(7.321,-9.229) H43(7.355,-9.929) J2(6.915,10.235) J3(6.915,9.727) J5(7.09,9.038) K2(6.432,10.428) K3(6.336,9.929) K4(6.311,9.421) K42(6.338,-9.403) K43(6.724,-9.727) L5(6.068,8.92) L41(6.182,-8.886) L43(6.211,-9.888) N3(5.156,9.888) N4(5.029,9.403) N5(5.087,8.756) N41(5.163,-8.785) N42(5.056,-9.421) P3(4.642,9.727) R4(4.037,9.421) R5(4.096,8.887) R41(4.071,-8.836) R42(4.064,-9.403) U3(2.883,9.888) U4(2.756,9.403) U5(2.953,8.937) U41(2.953,-8.836) U42(2.783,-9.421) V3(2.369,9.727) W3(1.789,9.929) W4(1.764,9.421) W42(1.791,-9.403) Y5(1.721,8.887) Y41(1.721,-8.885)
  custom 0.051x0.051 smd: A7(10.814,7.893) A9(10.814,6.852) A12(10.814,5.595) A14(10.814,4.553) A16(10.814,3.321) A18(10.814,2.28) A21(10.814,1.048) A23(10.814,0.007) A28(10.814,-2.267) A30(10.814,-3.499) A32(10.814,-4.54) A35(10.814,-5.772) A37(10.814,-6.839) A39(10.814,-7.893) AA1(1.225,10.814) AA2(1.225,10.306) AA44(1.048,-10.306) AA45(1.048,-10.814) AB2(0.609,10.396) AB43(0.484,-9.929) AB44(0.388,-10.428) AC1(-0.007,10.814) AC2(0.096,10.235) AC44(-0.096,-10.235) AC45(0.007,-10.814) AD2(-0.388,10.428) AD43(-0.609,-9.888) AD44(-0.609,-10.396) AE1(-1.048,10.814) AE2(-1.048,10.306) AE44(-1.225,-10.306) AE45(-1.225,-10.814) AF2(-1.664,10.396) AG2(-2.178,10.235) AG43(-1.789,-9.929) AG44(-1.886,-10.428) AH1(-2.28,10.814) AH2(-2.661,10.428) AH44(-2.369,-10.235) AH45(-2.267,-10.814) AJ3(-2.757,9.929) AJ43(-2.883,-9.888) AJ44(-2.883,-10.396) AK1(-3.321,10.814) AK2(-3.321,10.306) AK44(-3.499,-10.306) AK45(-3.499,-10.814) AL2(-3.937,10.396) AL43(-4.063,-9.929) AL44(-4.159,-10.428) AM1(-4.553,10.814) AM2(-4.451,10.235) AM44(-4.642,-10.235) AM45(-4.54,-10.814) AN2(-4.934,10.428) AN43(-5.156,-9.888) AN44(-5.156,-10.396) AP1(-5.595,10.814) AP2(-5.595,10.306) AR2(-6.211,10.396) AR3(-6.211,9.888) AR44(-5.772,-10.306) AR45(-5.772,-10.814) AT2(-6.724,10.235) AT43(-6.336,-9.929) AT44(-6.432,-10.428) AU1(-6.852,10.814) AU44(-6.915,-10.235) AU45(-6.839,-10.814) AV2(-7.258,10.428) AV44(-7.391,-10.396) AW1(-7.893,10.814) AW2(-7.944,10.306) AW44(-7.944,-10.306) AW45(-7.893,-10.814) AY44(-8.701,-10.355) B7(10.306,7.944) B8(10.428,7.258) B11(10.396,6.211) B12(10.306,5.595) B13(10.428,4.934) B14(10.235,4.451) B15(10.396,3.937) B16(10.306,3.321) B18(10.428,2.661) B19(10.235,2.178) B20(10.396,1.664) B21(10.306,1.048) B22(10.428,0.388) B23(10.235,-0.096) B24(10.396,-0.609) B27(10.428,-1.886) B29(10.396,-2.883) B30(10.306,-3.499) B31(10.428,-4.159) B32(10.235,-4.642) B33(10.396,-5.156) B35(10.306,-5.772) B36(10.428,-6.432) B37(10.235,-6.915) B38(10.396,-7.391) B39(10.306,-7.944) BC8(-9.888,7.391) BC10(-9.929,6.336) BC13(-9.888,5.156) BC15(-9.929,4.063) BC17(-9.888,2.883) BC19(-9.929,1.789) BC22(-9.888,0.609) BC24(-9.929,-0.484) BC26(-9.888,-1.664) BC29(-9.929,-2.757) BC31(-9.888,-3.937) BC33(-9.929,-5.03) BC35(-9.888,-6.211) BC38(-9.929,-7.355) BD6(-10.355,8.701) BD7(-10.306,7.944) BD8(-10.396,7.391) BD9(-10.235,6.915) BD10(-10.428,6.432) BD11(-10.306,5.772) BD13(-10.396,5.156) BD14(-10.235,4.642) BD15(-10.428,4.159) BD16(-10.306,3.499) BD17(-10.396,2.883) BD18(-10.235,2.369) BD19(-10.428,1.886) BD21(-10.306,1.225) BD22(-10.396,0.609) BD23(-10.235,0.096) BD24(-10.428,-0.388) BD25(-10.306,-1.048) BD26(-10.396,-1.664) BD27(-10.235,-2.178) BD28(-10.428,-2.661) BD30(-10.306,-3.321) BD31(-10.396,-3.937) BD32(-10.235,-4.451) BD33(-10.428,-4.934) BD34(-10.306,-5.595) BD35(-10.396,-6.211) BD36(-10.235,-6.724) BD38(-10.428,-7.258) BD39(-10.306,-7.944) BE7(-10.814,7.893) BE9(-10.814,6.839) BE11(-10.814,5.772) BE14(-10.814,4.54) BE16(-10.814,3.499) BE18(-10.814,2.267) BE21(-10.814,1.225) BE23(-10.814,-0.007) BE25(-10.814,-1.048) BE28(-10.814,-2.28) BE30(-10.814,-3.321) BE32(-10.814,-4.553) BE34(-10.814,-5.595) BE37(-10.814,-6.852) BE39(-10.814,-7.893) C13(9.929,5.03) C22(9.929,0.484) F2(8.701,10.355) G1(7.893,10.814) G2(7.944,10.306) G44(7.944,-10.306) G45(7.893,-10.814) H44(7.258,-10.428) J1(6.839,10.814) J45(6.852,-10.814) K44(6.724,-10.235) L1(5.772,10.814) L2(5.772,10.306) L44(6.211,-10.396) M44(5.595,-10.306) M45(5.595,-10.814) N2(5.156,10.396) N43(5.03,-9.929) N44(4.934,-10.428) P1(4.54,10.814) P2(4.642,10.235) P44(4.451,-10.235) P45(4.553,-10.814) R2(4.159,10.428) R3(4.063,9.929) R43(3.937,-9.888) R44(3.937,-10.396) T1(3.499,10.814) T2(3.499,10.306) T44(3.321,-10.306) T45(3.321,-10.814) U2(2.883,10.396) U43(2.757,-9.929) V1(2.267,10.814) V2(2.369,10.235) V44(2.661,-10.428) V45(2.28,-10.814) W2(1.886,10.428) W44(2.178,-10.235) Y43(1.664,-9.888) Y44(1.664,-10.396)
  round 0.368 smd: AA4(1.225,9.326) AA42(1.048,-9.324) AE4(-1.048,9.324) AE42(-1.225,-9.326) AK4(-3.321,9.324) AK42(-3.499,-9.326) AP4(-5.595,9.324) AR42(-5.772,-9.326) AY2(-8.45,10.296) BB11(-9.326,5.772) BB16(-9.326,3.499) BB21(-9.326,1.225) BB25(-9.324,-1.048) BB30(-9.324,-3.321) BB34(-9.324,-5.595) BD40(-10.296,-8.45) C4(10.162,9.344) D12(9.324,5.595) D16(9.324,3.321) D21(9.324,1.048) D25(9.326,-1.225) D30(9.326,-3.499) D35(9.326,-5.772) L4(5.772,9.326) M42(5.595,-9.324) T4(3.499,9.326) T42(3.321,-9.324)
  custom 0.057x0.057 smd: AC43(-0.096,-9.727) AH43(-2.369,-9.727) AM43(-4.642,-9.727) AT3(-6.724,9.727) B28(10.235,-2.369) BC14(-9.727,4.642) BC18(-9.727,2.369) BC23(-9.727,0.096) BC27(-9.727,-2.178) BC32(-9.727,-4.451) BC36(-9.727,-6.724) P43(4.451,-9.727) W43(2.178,-9.727)
VX_BGA_1745P_1575X1575_N
  oval 0.406x0.508 smd: A2(-18.4,19.2) A3(-17.6,19.2) A47(17.6,19.2) A48(18.4,19.2) BJ2(-18.4,-19.2) BJ3(-17.6,-19.2) BJ47(17.6,-19.2) BJ48(18.4,-19.2)
  oval 0.381x0.483 smd: A4(-16.8,19.2) A5(-16,19.2) A6(-15.2,19.2) A8(-13.6,19.2) A9(-12.8,19.2) A11(-11.2,19.2) A12(-10.4,19.2) A14(-8.8,19.2) A15(-8,19.2) A17(-6.4,19.2) A18(-5.6,19.2) A20(-4,19.2) A21(-3.2,19.2) A23(-1.6,19.2) A24(-0.8,19.2) A26(0.8,19.2) A27(1.6,19.2) A29(3.2,19.2) A30(4,19.2) A32(5.6,19.2) A33(6.4,19.2) A35(8,19.2) A36(8.8,19.2) A38(10.4,19.2) A39(11.2,19.2) A41(12.8,19.2) A42(13.6,19.2) A44(15.2,19.2) A45(16,19.2) A46(16.8,19.2) BJ4(-16.8,-19.2) BJ5(-16,-19.2) BJ6(-15.2,-19.2) BJ8(-13.6,-19.2) BJ9(-12.8,-19.2) BJ11(-11.2,-19.2) BJ12(-10.4,-19.2) BJ14(-8.8,-19.2) BJ15(-8,-19.2) BJ17(-6.4,-19.2) BJ18(-5.6,-19.2) BJ20(-4,-19.2) BJ21(-3.2,-19.2) BJ23(-1.6,-19.2) BJ24(-0.8,-19.2) BJ26(0.8,-19.2) BJ27(1.6,-19.2) BJ29(3.2,-19.2) BJ30(4,-19.2) BJ32(5.6,-19.2) BJ33(6.4,-19.2) BJ35(8,-19.2) BJ36(8.8,-19.2) BJ38(10.4,-19.2) BJ39(11.2,-19.2) BJ41(12.8,-19.2) BJ42(13.6,-19.2) BJ44(15.2,-19.2) BJ45(16,-19.2) BJ46(16.8,-19.2)
  oval 0.483x0.381 smd: AA1(-19.2,3.2) AA49(19.2,3.2) AC1(-19.2,1.6) AC49(19.2,1.6) AD1(-19.2,0.8) AD49(19.2,0.8) AF1(-19.2,-0.8) AF49(19.2,-0.8) AG1(-19.2,-1.6) AG49(19.2,-1.6) AJ1(-19.2,-3.2) AJ49(19.2,-3.2) AK1(-19.2,-4) AK49(19.2,-4) AM1(-19.2,-5.6) AM49(19.2,-5.6) AN1(-19.2,-6.4) AN49(19.2,-6.4) AR1(-19.2,-8) AR49(19.2,-8) AT1(-19.2,-8.8) AT49(19.2,-8.8) AV1(-19.2,-10.4) AV49(19.2,-10.4) AW1(-19.2,-11.2) AW49(19.2,-11.2) BA1(-19.2,-12.8) BA49(19.2,-12.8) BB1(-19.2,-13.6) BB49(19.2,-13.6) BD1(-19.2,-15.2) BD49(19.2,-15.2) BE1(-19.2,-16) BE49(19.2,-16) BF1(-19.2,-16.8) BF49(19.2,-16.8) D1(-19.2,16.8) D49(19.2,16.8) E1(-19.2,16) E49(19.2,16) F1(-19.2,15.2) F49(19.2,15.2) H1(-19.2,13.6) H49(19.2,13.6) J1(-19.2,12.8) J49(19.2,12.8) L1(-19.2,11.2) L49(19.2,11.2) M1(-19.2,10.4) M49(19.2,10.4) P1(-19.2,8.8) P49(19.2,8.8) R1(-19.2,8) R49(19.2,8) U1(-19.2,6.4) U49(19.2,6.4) V1(-19.2,5.6) V49(19.2,5.6) Y1(-19.2,4) Y49(19.2,4)
  round 0.381 smd: AA2(-18.4,3.2) AA3(-17.6,3.2) AA4(-16.8,3.2) AA5(-16,3.2) AA6(-15.2,3.2) AA7(-14.4,3.2) AA8(-13.6,3.2) AA9(-12.8,3.2) AA10(-12,3.2) AA11(-11,3.2) AA39(11,3.2) AA40(12,3.2) AA41(12.8,3.2) AA42(13.6,3.2) AA43(14.4,3.2) AA44(15.2,3.2) AA45(16,3.2) AA46(16.8,3.2) AA47(17.6,3.2) AA48(18.4,3.2) AB2(-18.4,2.4) AB4(-16.8,2.4) AB5(-16,2.4) AB8(-13.6,2.4) AB9(-12.8,2.4) AB11(-11,2.4) AB39(11,2.4) AB41(12.8,2.4) AB42(13.6,2.4) AB45(16,2.4) AB46(16.8,2.4) AB48(18.4,2.4) AC2(-18.4,1.6) AC3(-17.6,1.6) AC4(-16.8,1.6) AC5(-16,1.6) AC6(-15.2,1.6) AC7(-14.4,1.6) AC8(-13.6,1.6) AC9(-12.8,1.6) AC10(-12,1.6) AC11(-11,1.6) AC39(11,1.6) AC40(12,1.6) AC41(12.8,1.6) AC42(13.6,1.6) AC43(14.4,1.6) AC44(15.2,1.6) AC45(16,1.6) AC46(16.8,1.6) AC47(17.6,1.6) AC48(18.4,1.6) AD2(-18.4,0.8) AD3(-17.6,0.8) AD4(-16.8,0.8) AD5(-16,0.8) AD6(-15.2,0.8) AD7(-14.4,0.8) AD8(-13.6,0.8) AD9(-12.8,0.8) AD10(-12,0.8) AD11(-11,0.8) AD39(11,0.8) AD40(12,0.8) AD41(12.8,0.8) AD42(13.6,0.8) AD43(14.4,0.8) AD44(15.2,0.8) AD45(16,0.8) AD46(16.8,0.8) AD47(17.6,0.8) AD48(18.4,0.8) AE2(-18.4,0) AE4(-16.8,0) AE5(-16,0) AE8(-13.6,0) AE9(-12.8,0) AE11(-11,0) AE39(11,0) AE41(12.8,0) AE42(13.6,0) AE45(16,0) AE46(16.8,0) AE48(18.4,0) AF2(-18.4,-0.8) AF3(-17.6,-0.8) AF4(-16.8,-0.8) AF5(-16,-0.8) AF6(-15.2,-0.8) AF7(-14.4,-0.8) AF8(-13.6,-0.8) AF9(-12.8,-0.8) AF10(-12,-0.8) AF11(-11,-0.8) AF39(11,-0.8) AF40(12,-0.8) AF41(12.8,-0.8) AF42(13.6,-0.8) AF43(14.4,-0.8) AF44(15.2,-0.8) AF45(16,-0.8) AF46(16.8,-0.8) AF47(17.6,-0.8) AF48(18.4,-0.8) AG2(-18.4,-1.6) AG3(-17.6,-1.6) AG4(-16.8,-1.6) AG5(-16,-1.6) AG6(-15.2,-1.6) AG7(-14.4,-1.6) AG8(-13.6,-1.6) AG9(-12.8,-1.6) AG10(-12,-1.6) AG11(-11,-1.6) AG39(11,-1.6) AG40(12,-1.6) AG41(12.8,-1.6) AG42(13.6,-1.6) AG43(14.4,-1.6) AG44(15.2,-1.6) AG45(16,-1.6) AG46(16.8,-1.6) AG47(17.6,-1.6) AG48(18.4,-1.6) AH2(-18.4,-2.4) AH4(-16.8,-2.4) AH5(-16,-2.4) AH8(-13.6,-2.4) AH9(-12.8,-2.4) AH11(-11,-2.4) AH39(11,-2.4) AH41(12.8,-2.4) AH42(13.6,-2.4) AH45(16,-2.4) AH46(16.8,-2.4) AH48(18.4,-2.4) AJ2(-18.4,-3.2) AJ3(-17.6,-3.2) AJ4(-16.8,-3.2) AJ5(-16,-3.2) AJ6(-15.2,-3.2) AJ7(-14.4,-3.2) AJ8(-13.6,-3.2) AJ9(-12.8,-3.2) AJ10(-12,-3.2) AJ11(-11,-3.2) AJ39(11,-3.2) AJ40(12,-3.2) AJ41(12.8,-3.2) AJ42(13.6,-3.2) AJ43(14.4,-3.2) AJ44(15.2,-3.2) AJ45(16,-3.2) AJ46(16.8,-3.2) AJ47(17.6,-3.2) AJ48(18.4,-3.2) AK2(-18.4,-4) AK3(-17.6,-4) AK4(-16.8,-4) AK5(-16,-4) AK6(-15.2,-4) AK7(-14.4,-4) AK8(-13.6,-4) AK9(-12.8,-4) AK10(-12,-4) AK11(-11,-4) AK39(11,-4) AK40(12,-4) AK41(12.8,-4) AK42(13.6,-4) AK43(14.4,-4) AK44(15.2,-4) AK45(16,-4) AK46(16.8,-4) AK47(17.6,-4) AK48(18.4,-4) AL2(-18.4,-4.8) AL4(-16.8,-4.8) AL5(-16,-4.8) AL8(-13.6,-4.8) AL9(-12.8,-4.8) AL11(-11,-4.8) AL39(11,-4.8) AL41(12.8,-4.8) AL42(13.6,-4.8) AL45(16,-4.8) AL46(16.8,-4.8) AL48(18.4,-4.8) AM2(-18.4,-5.6) AM3(-17.6,-5.6) AM4(-16.8,-5.6) AM5(-16,-5.6) AM6(-15.2,-5.6) AM7(-14.4,-5.6) AM8(-13.6,-5.6) AM9(-12.8,-5.6) AM10(-12,-5.6) AM11(-11,-5.6) AM39(11,-5.6) AM40(12,-5.6) AM41(12.8,-5.6) AM42(13.6,-5.6) AM43(14.4,-5.6) AM44(15.2,-5.6) AM45(16,-5.6) AM46(16.8,-5.6) AM47(17.6,-5.6) AM48(18.4,-5.6) AN2(-18.4,-6.4) AN3(-17.6,-6.4) AN4(-16.8,-6.4) AN5(-16,-6.4) AN6(-15.2,-6.4) AN7(-14.4,-6.4) AN8(-13.6,-6.4) AN9(-12.8,-6.4) AN10(-12,-6.4) AN11(-11,-6.4) AN39(11,-6.4) AN40(12,-6.4) AN41(12.8,-6.4) AN42(13.6,-6.4) AN43(14.4,-6.4) AN44(15.2,-6.4) AN45(16,-6.4) AN46(16.8,-6.4) AN47(17.6,-6.4) AN48(18.4,-6.4) AP2(-18.4,-7.2) AP4(-16.8,-7.2) AP5(-16,-7.2) AP8(-13.6,-7.2) AP9(-12.8,-7.2) AP11(-11,-7.2) AP39(11,-7.2) AP41(12.8,-7.2) AP42(13.6,-7.2) AP45(16,-7.2) AP46(16.8,-7.2) AP48(18.4,-7.2) AR2(-18.4,-8) AR3(-17.6,-8) AR4(-16.8,-8) AR5(-16,-8) AR6(-15.2,-8) AR7(-14.4,-8) AR8(-13.6,-8) AR9(-12.8,-8) AR10(-12,-8) AR11(-11,-8) AR39(11,-8) AR40(12,-8) AR41(12.8,-8) AR42(13.6,-8) AR43(14.4,-8) AR44(15.2,-8) AR45(16,-8) AR46(16.8,-8) AR47(17.6,-8) AR48(18.4,-8) AT2(-18.4,-8.8) AT3(-17.6,-8.8) AT4(-16.8,-8.8) AT5(-16,-8.8) AT6(-15.2,-8.8) AT7(-14.4,-8.8) AT8(-13.6,-8.8) AT9(-12.8,-8.8) AT10(-12,-8.8) AT11(-11,-8.8) AT39(11,-8.8) AT40(12,-8.8) AT41(12.8,-8.8) AT42(13.6,-8.8) AT43(14.4,-8.8) AT44(15.2,-8.8) AT45(16,-8.8) AT46(16.8,-8.8) AT47(17.6,-8.8) AT48(18.4,-8.8) AU2(-18.4,-9.6) AU4(-16.8,-9.6) AU5(-16,-9.6) AU8(-13.6,-9.6) AU9(-12.8,-9.6) AU11(-11,-9.6) AU39(11,-9.6) AU41(12.8,-9.6) AU42(13.6,-9.6) AU45(16,-9.6) AU46(16.8,-9.6) AU48(18.4,-9.6) AV2(-18.4,-10.4) AV3(-17.6,-10.4) AV4(-16.8,-10.4) AV5(-16,-10.4) AV6(-15.2,-10.4) AV7(-14.4,-10.4) AV8(-13.6,-10.4) AV9(-12.8,-10.4) AV41(12.8,-10.4) AV42(13.6,-10.4) AV43(14.4,-10.4) AV44(15.2,-10.4) AV45(16,-10.4) AV46(16.8,-10.4) AV47(17.6,-10.4) AV48(18.4,-10.4) AW2(-18.4,-11.2) AW3(-17.6,-11.2) AW4(-16.8,-11.2) AW5(-16,-11.2) AW6(-15.2,-11.2) AW7(-14.4,-11.2) AW8(-13.6,-11.2) AW9(-12.8,-11.2) AW13(-9.6,-11) AW14(-8.8,-11) AW15(-8,-11) AW16(-7.2,-11) AW17(-6.4,-11) AW18(-5.6,-11) AW19(-4.8,-11) AW20(-4,-11) AW21(-3.2,-11) AW22(-2.4,-11) AW23(-1.6,-11) AW24(-0.8,-11) AW25(0,-11) AW26(0.8,-11) AW27(1.6,-11) AW28(2.4,-11) AW29(3.2,-11) AW30(4,-11) AW31(4.8,-11) AW32(5.6,-11) AW33(6.4,-11) AW34(7.2,-11) AW35(8,-11) AW36(8.8,-11) AW37(9.6,-11) AW41(12.8,-11.2) AW42(13.6,-11.2) AW43(14.4,-11.2) AW44(15.2,-11.2) AW45(16,-11.2) AW46(16.8,-11.2) AW47(17.6,-11.2) AW48(18.4,-11.2) AY2(-18.4,-12) AY4(-16.8,-12) AY5(-16,-12) AY8(-13.6,-12) AY14(-8.8,-12) AY15(-8,-12) AY17(-6.4,-12) AY18(-5.6,-12) AY20(-4,-12) AY21(-3.2,-12) AY23(-1.6,-12) AY24(-0.8,-12) AY26(0.8,-12) AY27(1.6,-12) AY29(3.2,-12) AY30(4,-12) AY32(5.6,-12) AY33(6.4,-12) AY35(8,-12) AY36(8.8,-12) AY42(13.6,-12) AY45(16,-12) AY46(16.8,-12) AY48(18.4,-12) B3(-17.6,18.4) B4(-16.8,18.4) B5(-16,18.4) B6(-15.2,18.4) B7(-14.4,18.4) B8(-13.6,18.4) B9(-12.8,18.4) B10(-12,18.4) B11(-11.2,18.4) B12(-10.4,18.4) B13(-9.6,18.4) B14(-8.8,18.4) B15(-8,18.4) B16(-7.2,18.4) B17(-6.4,18.4) B18(-5.6,18.4) B19(-4.8,18.4) B20(-4,18.4) B21(-3.2,18.4) B22(-2.4,18.4) B23(-1.6,18.4) B24(-0.8,18.4) B25(0,18.4) B26(0.8,18.4) B27(1.6,18.4) B28(2.4,18.4) B29(3.2,18.4) B30(4,18.4) B31(4.8,18.4) B32(5.6,18.4) B33(6.4,18.4) B34(7.2,18.4) B35(8,18.4) B36(8.8,18.4) B37(9.6,18.4) B38(10.4,18.4) B39(11.2,18.4) B40(12,18.4) B41(12.8,18.4) B42(13.6,18.4) B43(14.4,18.4) B44(15.2,18.4) B45(16,18.4) B46(16.8,18.4) B47(17.6,18.4) BA2(-18.4,-12.8) BA3(-17.6,-12.8) BA4(-16.8,-12.8) BA5(-16,-12.8) BA6(-15.2,-12.8) BA7(-14.4,-12.8) BA8(-13.6,-12.8) BA11(-11.2,-12.8) BA12(-10.4,-12.8) BA13(-9.6,-12.8) BA14(-8.8,-12.8) BA15(-8,-12.8) BA16(-7.2,-12.8) BA17(-6.4,-12.8) BA18(-5.6,-12.8) BA19(-4.8,-12.8) BA20(-4,-12.8) BA21(-3.2,-12.8) BA22(-2.4,-12.8) BA23(-1.6,-12.8) BA24(-0.8,-12.8) BA25(0,-12.8) BA26(0.8,-12.8) BA27(1.6,-12.8) BA28(2.4,-12.8) BA29(3.2,-12.8) BA30(4,-12.8) BA31(4.8,-12.8) BA32(5.6,-12.8) BA33(6.4,-12.8) BA34(7.2,-12.8) BA35(8,-12.8) BA36(8.8,-12.8) BA37(9.6,-12.8) BA38(10.4,-12.8) BA39(11.2,-12.8) BA42(13.6,-12.8) BA43(14.4,-12.8) BA44(15.2,-12.8) BA45(16,-12.8) BA46(16.8,-12.8) BA47(17.6,-12.8) BA48(18.4,-12.8) BB2(-18.4,-13.6) BB3(-17.6,-13.6) BB4(-16.8,-13.6) BB5(-16,-13.6) BB6(-15.2,-13.6) BB7(-14.4,-13.6) BB8(-13.6,-13.6) BB9(-12.8,-13.6) BB10(-12,-13.6) BB11(-11.2,-13.6) BB12(-10.4,-13.6) BB13(-9.6,-13.6) BB14(-8.8,-13.6) BB15(-8,-13.6) BB16(-7.2,-13.6) BB17(-6.4,-13.6) BB18(-5.6,-13.6) BB19(-4.8,-13.6) BB20(-4,-13.6) BB21(-3.2,-13.6) BB22(-2.4,-13.6) BB23(-1.6,-13.6) BB24(-0.8,-13.6) BB25(0,-13.6) BB26(0.8,-13.6) BB27(1.6,-13.6) BB28(2.4,-13.6) BB29(3.2,-13.6) BB30(4,-13.6) BB31(4.8,-13.6) BB32(5.6,-13.6) BB33(6.4,-13.6) BB34(7.2,-13.6) BB35(8,-13.6) BB36(8.8,-13.6) BB37(9.6,-13.6) BB38(10.4,-13.6) BB39(11.2,-13.6) BB40(12,-13.6) BB41(12.8,-13.6) BB42(13.6,-13.6) BB43(14.4,-13.6) BB44(15.2,-13.6) BB45(16,-13.6) BB46(16.8,-13.6) BB47(17.6,-13.6) BB48(18.4,-13.6) BC2(-18.4,-14.4) BC4(-16.8,-14.4) BC5(-16,-14.4) BC8(-13.6,-14.4) BC9(-12.8,-14.4) BC11(-11.2,-14.4) BC12(-10.4,-14.4) BC14(-8.8,-14.4) BC15(-8,-14.4) BC17(-6.4,-14.4) BC18(-5.6,-14.4) BC20(-4,-14.4) BC21(-3.2,-14.4) BC23(-1.6,-14.4) BC24(-0.8,-14.4) BC26(0.8,-14.4) BC27(1.6,-14.4) BC29(3.2,-14.4) BC30(4,-14.4) BC32(5.6,-14.4) BC33(6.4,-14.4) BC35(8,-14.4) BC36(8.8,-14.4) BC38(10.4,-14.4) BC39(11.2,-14.4) BC41(12.8,-14.4) BC42(13.6,-14.4) BC45(16,-14.4) BC46(16.8,-14.4) BC48(18.4,-14.4) BD2(-18.4,-15.2) BD3(-17.6,-15.2) BD4(-16.8,-15.2) BD5(-16,-15.2) BD6(-15.2,-15.2) BD8(-13.6,-15.2) BD9(-12.8,-15.2) BD11(-11.2,-15.2) BD12(-10.4,-15.2) BD14(-8.8,-15.2) BD15(-8,-15.2) BD17(-6.4,-15.2) BD18(-5.6,-15.2) BD20(-4,-15.2) BD21(-3.2,-15.2) BD23(-1.6,-15.2) BD24(-0.8,-15.2) BD26(0.8,-15.2) BD27(1.6,-15.2) BD29(3.2,-15.2) BD30(4,-15.2) BD32(5.6,-15.2) BD33(6.4,-15.2) BD35(8,-15.2) BD36(8.8,-15.2) BD38(10.4,-15.2) BD39(11.2,-15.2) BD41(12.8,-15.2) BD42(13.6,-15.2) BD44(15.2,-15.2) BD45(16,-15.2) BD46(16.8,-15.2) BD47(17.6,-15.2) BD48(18.4,-15.2) BE2(-18.4,-16) BE3(-17.6,-16) BE4(-16.8,-16) BE5(-16,-16) BE6(-15.2,-16) BE7(-14.4,-16) BE8(-13.6,-16) BE9(-12.8,-16) BE10(-12,-16) BE11(-11.2,-16) BE12(-10.4,-16) BE13(-9.6,-16) BE14(-8.8,-16) BE15(-8,-16) BE16(-7.2,-16) BE17(-6.4,-16) BE18(-5.6,-16) BE19(-4.8,-16) BE20(-4,-16) BE21(-3.2,-16) BE22(-2.4,-16) BE23(-1.6,-16) BE24(-0.8,-16) BE25(0,-16) BE26(0.8,-16) BE27(1.6,-16) BE28(2.4,-16) BE29(3.2,-16) BE30(4,-16) BE31(4.8,-16) BE32(5.6,-16) BE33(6.4,-16) BE34(7.2,-16) BE35(8,-16) BE36(8.8,-16) BE37(9.6,-16) BE38(10.4,-16) BE39(11.2,-16) BE40(12,-16) BE41(12.8,-16) BE42(13.6,-16) BE43(14.4,-16) BE44(15.2,-16) BE45(16,-16) BE46(16.8,-16) BE47(17.6,-16) BE48(18.4,-16) BF2(-18.4,-16.8) BF3(-17.6,-16.8) BF4(-16.8,-16.8) BF5(-16,-16.8) BF6(-15.2,-16.8) BF7(-14.4,-16.8) BF8(-13.6,-16.8) BF9(-12.8,-16.8) BF10(-12,-16.8) BF11(-11.2,-16.8) BF12(-10.4,-16.8) BF13(-9.6,-16.8) BF14(-8.8,-16.8) BF15(-8,-16.8) BF16(-7.2,-16.8) BF17(-6.4,-16.8) BF18(-5.6,-16.8) BF19(-4.8,-16.8) BF20(-4,-16.8) BF21(-3.2,-16.8) BF22(-2.4,-16.8) BF23(-1.6,-16.8) BF24(-0.8,-16.8) BF25(0,-16.8) BF26(0.8,-16.8) BF27(1.6,-16.8) BF28(2.4,-16.8) BF29(3.2,-16.8) BF30(4,-16.8) BF31(4.8,-16.8) BF32(5.6,-16.8) BF33(6.4,-16.8) BF34(7.2,-16.8) BF35(8,-16.8) BF36(8.8,-16.8) BF37(9.6,-16.8) BF38(10.4,-16.8) BF39(11.2,-16.8) BF40(12,-16.8) BF41(12.8,-16.8) BF42(13.6,-16.8) BF43(14.4,-16.8) BF44(15.2,-16.8) BF45(16,-16.8) BF46(16.8,-16.8) BF47(17.6,-16.8) BF48(18.4,-16.8) BG2(-18.4,-17.6) BG3(-17.6,-17.6) BG4(-16.8,-17.6) BG5(-16,-17.6) BG6(-15.2,-17.6) BG8(-13.6,-17.6) BG9(-12.8,-17.6) BG11(-11.2,-17.6) BG12(-10.4,-17.6) BG14(-8.8,-17.6) BG15(-8,-17.6) BG17(-6.4,-17.6) BG18(-5.6,-17.6) BG20(-4,-17.6) BG21(-3.2,-17.6) BG23(-1.6,-17.6) BG24(-0.8,-17.6) BG26(0.8,-17.6) BG27(1.6,-17.6) BG29(3.2,-17.6) BG30(4,-17.6) BG32(5.6,-17.6) BG33(6.4,-17.6) BG35(8,-17.6) BG36(8.8,-17.6) BG38(10.4,-17.6) BG39(11.2,-17.6) BG41(12.8,-17.6) BG42(13.6,-17.6) BG44(15.2,-17.6) BG45(16,-17.6) BG46(16.8,-17.6) BG47(17.6,-17.6) BG48(18.4,-17.6) BH3(-17.6,-18.4) BH4(-16.8,-18.4) BH5(-16,-18.4) BH6(-15.2,-18.4) BH7(-14.4,-18.4) BH8(-13.6,-18.4) BH9(-12.8,-18.4) BH10(-12,-18.4) BH11(-11.2,-18.4) BH12(-10.4,-18.4) BH13(-9.6,-18.4) BH14(-8.8,-18.4) BH15(-8,-18.4) BH16(-7.2,-18.4) BH17(-6.4,-18.4) BH18(-5.6,-18.4) BH19(-4.8,-18.4) BH20(-4,-18.4) BH21(-3.2,-18.4) BH22(-2.4,-18.4) BH23(-1.6,-18.4) BH24(-0.8,-18.4) BH25(0,-18.4) BH26(0.8,-18.4) BH27(1.6,-18.4) BH28(2.4,-18.4) BH29(3.2,-18.4) BH30(4,-18.4) BH31(4.8,-18.4) BH32(5.6,-18.4) BH33(6.4,-18.4) BH34(7.2,-18.4) BH35(8,-18.4) BH36(8.8,-18.4) BH37(9.6,-18.4) BH38(10.4,-18.4) BH39(11.2,-18.4) BH40(12,-18.4) BH41(12.8,-18.4) BH42(13.6,-18.4) BH43(14.4,-18.4) BH44(15.2,-18.4) BH45(16,-18.4) BH46(16.8,-18.4) BH47(17.6,-18.4) C2(-18.4,17.6) C3(-17.6,17.6) C4(-16.8,17.6) C5(-16,17.6) C6(-15.2,17.6) C8(-13.6,17.6) C9(-12.8,17.6) C11(-11.2,17.6) C12(-10.4,17.6) C14(-8.8,17.6) C15(-8,17.6) C17(-6.4,17.6) C18(-5.6,17.6) C20(-4,17.6) C21(-3.2,17.6) C23(-1.6,17.6) C24(-0.8,17.6) C26(0.8,17.6) C27(1.6,17.6) C29(3.2,17.6) C30(4,17.6) C32(5.6,17.6) C33(6.4,17.6) C35(8,17.6) C36(8.8,17.6) C38(10.4,17.6) C39(11.2,17.6) C41(12.8,17.6) C42(13.6,17.6) C44(15.2,17.6) C45(16,17.6) C46(16.8,17.6) C47(17.6,17.6) C48(18.4,17.6) D2(-18.4,16.8) D3(-17.6,16.8) D4(-16.8,16.8) D5(-16,16.8) D6(-15.2,16.8) D7(-14.4,16.8) D8(-13.6,16.8) D9(-12.8,16.8) D10(-12,16.8) D11(-11.2,16.8) D12(-10.4,16.8) D13(-9.6,16.8) D14(-8.8,16.8) D15(-8,16.8) D16(-7.2,16.8) D17(-6.4,16.8) D18(-5.6,16.8) D19(-4.8,16.8) D20(-4,16.8) D21(-3.2,16.8) D22(-2.4,16.8) D23(-1.6,16.8) D24(-0.8,16.8) D25(0,16.8) D26(0.8,16.8) D27(1.6,16.8) D28(2.4,16.8) D29(3.2,16.8) D30(4,16.8) D31(4.8,16.8) D32(5.6,16.8) D33(6.4,16.8) D34(7.2,16.8) D35(8,16.8) D36(8.8,16.8) D37(9.6,16.8) D38(10.4,16.8) D39(11.2,16.8) D40(12,16.8) D41(12.8,16.8) D42(13.6,16.8) D43(14.4,16.8) D44(15.2,16.8) D45(16,16.8) D46(16.8,16.8) D47(17.6,16.8) D48(18.4,16.8) E2(-18.4,16) E3(-17.6,16) E4(-16.8,16) E5(-16,16) E6(-15.2,16) E7(-14.4,16) E8(-13.6,16) E9(-12.8,16) E10(-12,16) E11(-11.2,16) E12(-10.4,16) E13(-9.6,16) E14(-8.8,16) E15(-8,16) E16(-7.2,16) E17(-6.4,16) E18(-5.6,16) E19(-4.8,16) E20(-4,16) E21(-3.2,16) E22(-2.4,16) E23(-1.6,16) E24(-0.8,16) E25(0,16) E26(0.8,16) E27(1.6,16) E28(2.4,16) E29(3.2,16) E30(4,16) E31(4.8,16) E32(5.6,16) E33(6.4,16) E34(7.2,16) E35(8,16) E36(8.8,16) E37(9.6,16) E38(10.4,16) E39(11.2,16) E40(12,16) E41(12.8,16) E42(13.6,16) E43(14.4,16) E44(15.2,16) E45(16,16) E46(16.8,16) E47(17.6,16) E48(18.4,16) F2(-18.4,15.2) F3(-17.6,15.2) F4(-16.8,15.2) F5(-16,15.2) F6(-15.2,15.2) F8(-13.6,15.2) F9(-12.8,15.2) F11(-11.2,15.2) F12(-10.4,15.2) F14(-8.8,15.2) F15(-8,15.2) F17(-6.4,15.2) F18(-5.6,15.2) F20(-4,15.2) F21(-3.2,15.2) F23(-1.6,15.2) F24(-0.8,15.2) F26(0.8,15.2) F27(1.6,15.2) F29(3.2,15.2) F30(4,15.2) F32(5.6,15.2) F33(6.4,15.2) F35(8,15.2) F36(8.8,15.2) F38(10.4,15.2) F39(11.2,15.2) F41(12.8,15.2) F42(13.6,15.2) F44(15.2,15.2) F45(16,15.2) F46(16.8,15.2) F47(17.6,15.2) F48(18.4,15.2) G2(-18.4,14.4) G4(-16.8,14.4) G5(-16,14.4) G8(-13.6,14.4) G9(-12.8,14.4) G11(-11.2,14.4) G12(-10.4,14.4) G14(-8.8,14.4) G15(-8,14.4) G17(-6.4,14.4) G18(-5.6,14.4) G20(-4,14.4) G21(-3.2,14.4) G23(-1.6,14.4) G24(-0.8,14.4) G26(0.8,14.4) G27(1.6,14.4) G29(3.2,14.4) G30(4,14.4) G32(5.6,14.4) G33(6.4,14.4) G35(8,14.4) G36(8.8,14.4) G38(10.4,14.4) G39(11.2,14.4) G41(12.8,14.4) G42(13.6,14.4) G45(16,14.4) G46(16.8,14.4) G48(18.4,14.4) H2(-18.4,13.6) H3(-17.6,13.6) H4(-16.8,13.6) H5(-16,13.6) H6(-15.2,13.6) H7(-14.4,13.6) H8(-13.6,13.6) H9(-12.8,13.6) H10(-12,13.6) H11(-11.2,13.6) H12(-10.4,13.6) H13(-9.6,13.6) H14(-8.8,13.6) H15(-8,13.6) H16(-7.2,13.6) H17(-6.4,13.6) H18(-5.6,13.6) H19(-4.8,13.6) H20(-4,13.6) H21(-3.2,13.6) H22(-2.4,13.6) H23(-1.6,13.6) H24(-0.8,13.6) H25(0,13.6) H26(0.8,13.6) H27(1.6,13.6) H28(2.4,13.6) H29(3.2,13.6) H30(4,13.6) H31(4.8,13.6) H32(5.6,13.6) H33(6.4,13.6) H34(7.2,13.6) H35(8,13.6) H36(8.8,13.6) H37(9.6,13.6) H38(10.4,13.6) H39(11.2,13.6) H40(12,13.6) H41(12.8,13.6) H42(13.6,13.6) H43(14.4,13.6) H44(15.2,13.6) H45(16,13.6) H46(16.8,13.6) H47(17.6,13.6) H48(18.4,13.6) J2(-18.4,12.8) J3(-17.6,12.8) J4(-16.8,12.8) J5(-16,12.8) J6(-15.2,12.8) J7(-14.4,12.8) J8(-13.6,12.8) J11(-11.2,12.8) J12(-10.4,12.8) J13(-9.6,12.8) J14(-8.8,12.8) J15(-8,12.8) J16(-7.2,12.8) J17(-6.4,12.8) J18(-5.6,12.8) J19(-4.8,12.8) J20(-4,12.8) J21(-3.2,12.8) J22(-2.4,12.8) J23(-1.6,12.8) J24(-0.8,12.8) J25(0,12.8) J26(0.8,12.8) J27(1.6,12.8) J28(2.4,12.8) J29(3.2,12.8) J30(4,12.8) J31(4.8,12.8) J32(5.6,12.8) J33(6.4,12.8) J34(7.2,12.8) J35(8,12.8) J36(8.8,12.8) J37(9.6,12.8) J38(10.4,12.8) J39(11.2,12.8) J42(13.6,12.8) J43(14.4,12.8) J44(15.2,12.8) J45(16,12.8) J46(16.8,12.8) J47(17.6,12.8) J48(18.4,12.8) K2(-18.4,12) K4(-16.8,12) K5(-16,12) K8(-13.6,12) K14(-8.8,12) K15(-8,12) K17(-6.4,12) K18(-5.6,12) K20(-4,12) K21(-3.2,12) K23(-1.6,12) K24(-0.8,12) K26(0.8,12) K27(1.6,12) K29(3.2,12) K30(4,12) K32(5.6,12) K33(6.4,12) K35(8,12) K36(8.8,12) K42(13.6,12) K45(16,12) K46(16.8,12) K48(18.4,12) L2(-18.4,11.2) L3(-17.6,11.2) L4(-16.8,11.2) L5(-16,11.2) L6(-15.2,11.2) L7(-14.4,11.2) L8(-13.6,11.2) L9(-12.8,11.2) L13(-9.6,11) L14(-8.8,11) L15(-8,11) L16(-7.2,11) L17(-6.4,11) L18(-5.6,11) L19(-4.8,11) L20(-4,11) L21(-3.2,11) L22(-2.4,11) L23(-1.6,11) L24(-0.8,11) L25(0,11) L26(0.8,11) L27(1.6,11) L28(2.4,11) L29(3.2,11) L30(4,11) L31(4.8,11) L32(5.6,11) L33(6.4,11) L34(7.2,11) L35(8,11) L36(8.8,11) L37(9.6,11) L41(12.8,11.2) L42(13.6,11.2) L43(14.4,11.2) L44(15.2,11.2) L45(16,11.2) L46(16.8,11.2) L47(17.6,11.2) L48(18.4,11.2) M2(-18.4,10.4) M3(-17.6,10.4) M4(-16.8,10.4) M5(-16,10.4) M6(-15.2,10.4) M7(-14.4,10.4) M8(-13.6,10.4) M9(-12.8,10.4) M41(12.8,10.4) M42(13.6,10.4) M43(14.4,10.4) M44(15.2,10.4) M45(16,10.4) M46(16.8,10.4) M47(17.6,10.4) M48(18.4,10.4) N2(-18.4,9.6) N4(-16.8,9.6) N5(-16,9.6) N8(-13.6,9.6) N9(-12.8,9.6) N11(-11,9.6) N39(11,9.6) N41(12.8,9.6) N42(13.6,9.6) N45(16,9.6) N46(16.8,9.6) N48(18.4,9.6) P2(-18.4,8.8) P3(-17.6,8.8) P4(-16.8,8.8) P5(-16,8.8) P6(-15.2,8.8) P7(-14.4,8.8) P8(-13.6,8.8) P9(-12.8,8.8) P10(-12,8.8) P11(-11,8.8) P39(11,8.8) P40(12,8.8) P41(12.8,8.8) P42(13.6,8.8) P43(14.4,8.8) P44(15.2,8.8) P45(16,8.8) P46(16.8,8.8) P47(17.6,8.8) P48(18.4,8.8) R2(-18.4,8) R3(-17.6,8) R4(-16.8,8) R5(-16,8) R6(-15.2,8) R7(-14.4,8) R8(-13.6,8) R9(-12.8,8) R10(-12,8) R11(-11,8) R39(11,8) R40(12,8) R41(12.8,8) R42(13.6,8) R43(14.4,8) R44(15.2,8) R45(16,8) R46(16.8,8) R47(17.6,8) R48(18.4,8) T2(-18.4,7.2) T4(-16.8,7.2) T5(-16,7.2) T8(-13.6,7.2) T9(-12.8,7.2) T11(-11,7.2) T39(11,7.2) T41(12.8,7.2) T42(13.6,7.2) T45(16,7.2) T46(16.8,7.2) T48(18.4,7.2) U2(-18.4,6.4) U3(-17.6,6.4) U4(-16.8,6.4) U5(-16,6.4) U6(-15.2,6.4) U7(-14.4,6.4) U8(-13.6,6.4) U9(-12.8,6.4) U10(-12,6.4) U11(-11,6.4) U39(11,6.4) U40(12,6.4) U41(12.8,6.4) U42(13.6,6.4) U43(14.4,6.4) U44(15.2,6.4) U45(16,6.4) U46(16.8,6.4) U47(17.6,6.4) U48(18.4,6.4) V2(-18.4,5.6) V3(-17.6,5.6) V4(-16.8,5.6) V5(-16,5.6) V6(-15.2,5.6) V7(-14.4,5.6) V8(-13.6,5.6) V9(-12.8,5.6) V10(-12,5.6) V11(-11,5.6) V39(11,5.6) V40(12,5.6) V41(12.8,5.6) V42(13.6,5.6) V43(14.4,5.6) V44(15.2,5.6) V45(16,5.6) V46(16.8,5.6) V47(17.6,5.6) V48(18.4,5.6) W2(-18.4,4.8) W4(-16.8,4.8) W5(-16,4.8) W8(-13.6,4.8) W9(-12.8,4.8) W11(-11,4.8) W39(11,4.8) W41(12.8,4.8) W42(13.6,4.8) W45(16,4.8) W46(16.8,4.8) W48(18.4,4.8) Y2(-18.4,4) Y3(-17.6,4) Y4(-16.8,4) Y5(-16,4) Y6(-15.2,4) Y7(-14.4,4) Y8(-13.6,4) Y9(-12.8,4) Y10(-12,4) Y11(-11,4) Y39(11,4) Y40(12,4) Y41(12.8,4) Y42(13.6,4) Y43(14.4,4) Y44(15.2,4) Y45(16,4) Y46(16.8,4) Y47(17.6,4) Y48(18.4,4)
  round 0.45 smd: AA14(-9,2) AA15(-8,2) AA16(-7,2) AA17(-6,2) AA18(-5,2) AA19(-4,2) AA20(-3,2) AA21(-2,2) AA22(-1,2) AA23(0,2) AA24(1,2) AA25(2,2) AA26(3,2) AA27(4,2) AA28(5,2) AA29(6,2) AA30(7,2) AA31(8,2) AA32(9,2) AB14(-9,1) AB15(-8,1) AB16(-7,1) AB17(-6,1) AB18(-5,1) AB19(-4,1) AB20(-3,1) AB21(-2,1) AB22(-1,1) AB23(0,1) AB24(1,1) AB25(2,1) AB26(3,1) AB27(4,1) AB28(5,1) AB29(6,1) AB30(7,1) AB31(8,1) AB32(9,1) AC14(-9,0) AC15(-8,0) AC16(-7,0) AC17(-6,0) AC18(-5,0) AC19(-4,0) AC20(-3,0) AC21(-2,0) AC22(-1,0) AC23(0,0) AC24(1,0) AC25(2,0) AC26(3,0) AC27(4,0) AC28(5,0) AC29(6,0) AC30(7,0) AC31(8,0) AC32(9,0) AD14(-9,-1) AD15(-8,-1) AD16(-7,-1) AD17(-6,-1) AD18(-5,-1) AD19(-4,-1) AD20(-3,-1) AD21(-2,-1) AD22(-1,-1) AD23(0,-1) AD24(1,-1) AD25(2,-1) AD26(3,-1) AD27(4,-1) AD28(5,-1) AD29(6,-1) AD30(7,-1) AD31(8,-1) AD32(9,-1) AE14(-9,-2) AE15(-8,-2) AE16(-7,-2) AE17(-6,-2) AE18(-5,-2) AE19(-4,-2) AE20(-3,-2) AE21(-2,-2) AE22(-1,-2) AE23(0,-2) AE24(1,-2) AE25(2,-2) AE26(3,-2) AE27(4,-2) AE28(5,-2) AE29(6,-2) AE30(7,-2) AE31(8,-2) AE32(9,-2) AF14(-9,-3) AF15(-8,-3) AF16(-7,-3) AF17(-6,-3) AF18(-5,-3) AF19(-4,-3) AF20(-3,-3) AF21(-2,-3) AF22(-1,-3) AF23(0,-3) AF24(1,-3) AF25(2,-3) AF26(3,-3) AF27(4,-3) AF28(5,-3) AF29(6,-3) AF30(7,-3) AF31(8,-3) AF32(9,-3) AG14(-9,-4) AG15(-8,-4) AG16(-7,-4) AG17(-6,-4) AG18(-5,-4) AG19(-4,-4) AG20(-3,-4) AG21(-2,-4) AG22(-1,-4) AG23(0,-4) AG24(1,-4) AG25(2,-4) AG26(3,-4) AG27(4,-4) AG28(5,-4) AG29(6,-4) AG30(7,-4) AG31(8,-4) AG32(9,-4) AH14(-9,-5) AH15(-8,-5) AH16(-7,-5) AH17(-6,-5) AH18(-5,-5) AH19(-4,-5) AH20(-3,-5) AH21(-2,-5) AH22(-1,-5) AH23(0,-5) AH24(1,-5) AH25(2,-5) AH26(3,-5) AH27(4,-5) AH28(5,-5) AH29(6,-5) AH30(7,-5) AH31(8,-5) AH32(9,-5) AJ14(-9,-6) AJ15(-8,-6) AJ16(-7,-6) AJ17(-6,-6) AJ18(-5,-6) AJ19(-4,-6) AJ20(-3,-6) AJ21(-2,-6) AJ22(-1,-6) AJ23(0,-6) AJ24(1,-6) AJ25(2,-6) AJ26(3,-6) AJ27(4,-6) AJ28(5,-6) AJ29(6,-6) AJ30(7,-6) AJ31(8,-6) AJ32(9,-6) AK14(-9,-7) AK15(-8,-7) AK16(-7,-7) AK17(-6,-7) AK18(-5,-7) AK19(-4,-7) AK20(-3,-7) AK21(-2,-7) AK22(-1,-7) AK23(0,-7) AK24(1,-7) AK25(2,-7) AK26(3,-7) AK27(4,-7) AK28(5,-7) AK29(6,-7) AK30(7,-7) AK31(8,-7) AK32(9,-7) AL14(-9,-8) AL15(-8,-8) AL16(-7,-8) AL17(-6,-8) AL18(-5,-8) AL19(-4,-8) AL20(-3,-8) AL21(-2,-8) AL22(-1,-8) AL23(0,-8) AL24(1,-8) AL25(2,-8) AL26(3,-8) AL27(4,-8) AL28(5,-8) AL29(6,-8) AL30(7,-8) AL31(8,-8) AL32(9,-8) AM14(-9,-9) AM15(-8,-9) AM16(-7,-9) AM17(-6,-9) AM18(-5,-9) AM19(-4,-9) AM20(-3,-9) AM21(-2,-9) AM22(-1,-9) AM23(0,-9) AM24(1,-9) AM25(2,-9) AM26(3,-9) AM27(4,-9) AM28(5,-9) AM29(6,-9) AM30(7,-9) AM31(8,-9) AM32(9,-9) P14(-9,9) P15(-8,9) P16(-7,9) P17(-6,9) P18(-5,9) P19(-4,9) P20(-3,9) P21(-2,9) P22(-1,9) P23(0,9) P24(1,9) P25(2,9) P26(3,9) P27(4,9) P28(5,9) P29(6,9) P30(7,9) P31(8,9) P32(9,9) R14(-9,8) R15(-8,8) R16(-7,8) R17(-6,8) R18(-5,8) R19(-4,8) R20(-3,8) R21(-2,8) R22(-1,8) R23(0,8) R24(1,8) R25(2,8) R26(3,8) R27(4,8) R28(5,8) R29(6,8) R30(7,8) R31(8,8) R32(9,8) T14(-9,7) T15(-8,7) T16(-7,7) T17(-6,7) T18(-5,7) T19(-4,7) T20(-3,7) T21(-2,7) T22(-1,7) T23(0,7) T24(1,7) T25(2,7) T26(3,7) T27(4,7) T28(5,7) T29(6,7) T30(7,7) T31(8,7) T32(9,7) U14(-9,6) U15(-8,6) U16(-7,6) U17(-6,6) U18(-5,6) U19(-4,6) U20(-3,6) U21(-2,6) U22(-1,6) U23(0,6) U24(1,6) U25(2,6) U26(3,6) U27(4,6) U28(5,6) U29(6,6) U30(7,6) U31(8,6) U32(9,6) V14(-9,5) V15(-8,5) V16(-7,5) V17(-6,5) V18(-5,5) V19(-4,5) V20(-3,5) V21(-2,5) V22(-1,5) V23(0,5) V24(1,5) V25(2,5) V26(3,5) V27(4,5) V28(5,5) V29(6,5) V30(7,5) V31(8,5) V32(9,5) W14(-9,4) W15(-8,4) W16(-7,4) W17(-6,4) W18(-5,4) W19(-4,4) W20(-3,4) W21(-2,4) W22(-1,4) W23(0,4) W24(1,4) W25(2,4) W26(3,4) W27(4,4) W28(5,4) W29(6,4) W30(7,4) W31(8,4) W32(9,4) Y14(-9,3) Y15(-8,3) Y16(-7,3) Y17(-6,3) Y18(-5,3) Y19(-4,3) Y20(-3,3) Y21(-2,3) Y22(-1,3) Y23(0,3) Y24(1,3) Y25(2,3) Y26(3,3) Y27(4,3) Y28(5,3) Y29(6,3) Y30(7,3) Y31(8,3) Y32(9,3)
  oval 0.508x0.406 smd: B1(-19.2,18.4) B49(19.2,18.4) BG1(-19.2,-17.6) BG49(19.2,-17.6) BH1(-19.2,-18.4) BH49(19.2,-18.4) C1(-19.2,17.6) C49(19.2,17.6)
  round 0.406 smd: B2(-18.4,18.4) B48(18.4,18.4) BH2(-18.4,-18.4) BH48(18.4,-18.4)
VX_C0201
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_C0201_H14
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_C0402_H24_SMALL
  rect 0.432x0.508 smd: 1(0.432,0) 2(-0.432,0)
VX_C0402_H26_SMALL
  rect 0.432x0.508 smd: 1(0.432,0) 2(-0.432,0)
VX_C0402_H28_SMALL
  rect 0.432x0.508 smd: 1(0.432,0) 2(-0.432,0)
VX_C0402_SMALL
  rect 0.432x0.508 smd: 1(0.432,0) 2(-0.432,0)
VX_C0603_H39_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_C0603_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_C0805_H57_SMALL
  rect 0.813x1.397 smd: 1(0.9,0) 2(-0.9,0)
VX_C1206_H49
  rect 1.041x1.6 smd: 1(1.52,0) 2(-1.52,0)
VX_C1206_H75
  rect 1.041x1.6 smd: 1(1.52,0) 2(-1.52,0)
VX_C3528
  rect 1.905x2.21 smd: 1(1.816,0) 2(-1.816,0)
VX_C7343D_3P
  rect 2.388x2.794 smd: 1(3.2,0) 3(-3.2,0)
  custom 0.675x0.675 smd: 2(0.15,0)
VX_C7343D_H83
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
VX_C_ARRAY_8P_79X49_H39
  rect 0.292x0.762 smd: 1(-0.75,-0.625) 2(-0.75,0.625) 3(-0.25,-0.625) 4(-0.25,0.625) 5(0.25,-0.625) 6(0.25,0.625) 7(0.75,-0.625) 8(0.75,0.625)
VX_CESMD_260X260_PANASONIC
  rect 3.099x1.88 smd: 1(2.35,0) 2(-2.35,0)
VX_CHOKE_2P_543X496
  rect 3.251x4.039 smd: 1(-5.625,0) 2(5.625,0)
VX_CHOKE_4P_39X49_QUIE_H24
  rect 0.356x0.559 smd: 1(-0.3,-0.625) 2(0.3,-0.625) 3(0.3,0.625) 4(-0.3,0.625)
VX_CHOKE_4P_49X39_MUR
  rect 0.762x0.305 smd: 1(-0.66,-0.275) 2(0.66,-0.275) 3(0.66,0.275) 4(-0.66,0.275)
VX_CHOKE_4P_79X47_FUKUI_H39
  rect 0.889x0.356 smd: 1(-0.85,-0.425) 2(0.85,-0.425) 3(0.85,0.425) 4(-0.85,0.425)
VX_DDR4_260P_20_4H_RE_H177
  round 1.041 hole 1.041 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
