# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 255.45,41.24 255.45,39.72 254.28,38.55 247.96,38.55 247.93,38.57 247.39,38.57 247.38,38.56 247.37,38.56 247.28,38.5 247.22,38.41 247.22,38.4 247.19,38.37 247.19,38.32 246.94,38.32 246.94,38.96 247.7,39.72 248.26,39.72 249.86,39.72 250.5,40.35 250.5,40.99 250.88,41.37 255.32,41.37
GND on TOP (solid shape): 33.17,149.47 33.17,149.09 33.48,149.09 33.48,147.74 33.17,147.74 33.17,147.43 33.06,147.32 32.83,147.32 32.78,147.37 32.79,147.4 32.79,147.55 32.74,147.69 32.74,149.23 32.79,149.34 32.8,149.46 32.83,149.54 32.9,149.57 33.08,149.57
GND on TOP (solid shape): 96.01,133.72 96.01,132.86 96.57,132.3 97.89,132.3 98.04,132.15 98.04,129.91 97.94,129.81 97.71,129.81 97.66,129.86 97.66,130.45 97.41,130.7 97.41,131.28 97.16,131.54 96.8,131.54 96.79,131.53 96.79,131.22 96.75,131.18 96.49,131.18 96.44,131.23 96.44,131.64 95.53,132.55 95.53,133.37 95.15,133.75 95.15,134.05 95.17,134.08 95.66,134.08
GND on TOP (solid shape): 96.48,28.31 96.48,27.07 96.42,27.02 96.26,27.02 96.22,27.05 96.22,27.77 96.19,27.81 96.02,27.81 95.98,27.77 95.98,27.05 95.94,27.01 95.78,27.01 95.72,27.07 95.72,27.81 95.69,27.84 95.53,27.84 95.48,27.79 95.48,27.07 95.42,27.02 95.26,27.02 95.22,27.05 95.22,27.77 95.19,27.81 95.02,27.81 94.98,27.77 94.98,27.05 94.94,27.01 94.78,27.01 94.72,27.07 94.72,28.29 94.85,28.42 96.36,28.42
GND on TOP (solid shape): 99.61,28.33 99.61,27.09 99.56,27.04 99.39,27.04 99.36,27.08 99.36,27.79 99.32,27.83 99.15,27.83 99.11,27.79 99.11,27.07 99.08,27.04 98.91,27.04 98.86,27.09 98.86,27.84 98.83,27.87 98.66,27.87 98.61,27.82 98.61,27.09 98.56,27.04 98.39,27.04 98.36,27.08 98.36,27.79 98.32,27.83 98.15,27.83 98.11,27.79 98.11,27.07 98.08,27.04 97.91,27.04 97.86,27.09 97.86,28.32 97.99,28.45 99.5,28.45
GND on TOP (solid shape): 102.4,28.35 102.4,27.11 102.35,27.06 102.18,27.06 102.15,27.09 102.15,27.81 102.11,27.85 101.94,27.85 101.9,27.81 101.9,27.09 101.86,27.05 101.7,27.05 101.65,27.11 101.65,27.86 101.62,27.88 101.45,27.88 101.4,27.83 101.4,27.11 101.35,27.06 101.18,27.06 101.15,27.09 101.15,27.81 101.11,27.85 100.94,27.85 100.9,27.81 100.9,27.09 100.86,27.05 100.7,27.05 100.65,27.11 100.65,28.33 100.78,28.46 102.29,28.46
GND on TOP (solid shape): 105.32,28.34 105.32,27.1 105.27,27.05 105.11,27.05 105.07,27.08 105.07,27.8 105.03,27.84 104.86,27.84 104.82,27.8 104.82,27.08 104.79,27.04 104.62,27.04 104.57,27.1 104.57,27.85 104.54,27.88 104.38,27.88 104.32,27.82 104.32,27.1 104.27,27.05 104.11,27.05 104.07,27.08 104.07,27.8 104.03,27.84 103.86,27.84 103.82,27.8 103.82,27.08 103.79,27.04 103.62,27.04 103.57,27.1 103.57,28.32 103.7,28.45 105.21,28.45
GND on TOP (solid shape): 108.49,28.34 108.49,27.1 108.44,27.05 108.28,27.05 108.24,27.09 108.24,27.81 108.2,27.84 108.03,27.84 107.99,27.8 107.99,27.08 107.96,27.05 107.79,27.05 107.74,27.1 107.74,27.85 107.71,27.88 107.55,27.88 107.49,27.83 107.49,27.1 107.44,27.05 107.28,27.05 107.24,27.09 107.24,27.81 107.2,27.84 107.03,27.84 106.99,27.8 106.99,27.08 106.96,27.05 106.79,27.05 106.74,27.1 106.74,28.33 106.87,28.46 108.38,28.46
GND on TOP (solid shape): 146.35,95.86 146.35,95.51 146.5,95.36 147.25,95.36 147.3,95.36 147.31,95.35 147.53,95.35 147.59,95.34 148.34,95.34 148.47,95.21 148.47,94.7 148.27,94.5 147.43,94.5 147.27,94.66 147.27,94.99 147.18,95.08 146.31,95.08 146.11,94.88 145.66,94.88 145.66,95.9 146.31,95.9
GND on TOP (solid shape): 37.9,149.44 37.9,149.09 38.15,149.09 38.15,147.81 38.09,147.74 37.9,147.74 37.9,147.55 37.66,147.31 37.57,147.31 37.51,147.38 37.52,147.41 37.51,147.57 37.44,147.72 37.44,149.2 37.5,149.31 37.52,149.43 37.55,149.51 37.63,149.53 37.8,149.53
GND on TOP (solid shape): 25.4,94.79 25.58,94.42 25.99,94.44 26.41,94.44 27.18,93.67 27.18,85.95 27.1,85.87 19.31,85.87 19.22,85.95 19.22,86.38 19.24,86.4 19.24,92.04 20.49,93.29 22.34,93.29 23.84,94.79
GND on TOP (solid shape): 33.89,172.83 33.75,172.7 33.2,172.7 33.06,172.56 33.06,171.87 33.19,171.74 33.77,171.74 33.78,171.74 33.78,170.56 30.05,170.56 28.66,169.17 28.66,166.93 28.5,166.77 25.96,166.77 25.58,167.15 25.58,168.81 25.82,169.06 25.82,169.52 25.28,170.06 25.28,172.22 25.67,172.61 32.1,172.61 32.38,172.9 32.38,174 32.49,174.11 33.89,174.11
GND on TOP (solid shape): 10.5,165.71 10.5,164.43 10.38,164.31 9.74,164.31 9.65,164.23 9.65,163.5 9.77,163.39 10.47,163.39 10.49,163.37 10.49,162.22 10.33,162.07 5.89,162.07 5.77,161.94 4.24,161.94 3.73,161.43 3.73,158.13 3.48,157.88 3.1,157.88 2.72,158.26 2.72,158.89 2.46,159.15 1.45,159.15 1.32,159.27 1.32,164.09 1.48,164.25 8.64,164.25 8.84,164.46 8.84,165.57 9,165.72 10.49,165.72
GND on TOP (solid shape): 92.2,28.46 92.68,28.46 92.68,28.46 93.19,28.46 93.31,28.35 93.31,27.1 93.25,27.05 93.09,27.05 93.05,27.09 93.05,27.81 93.02,27.84 92.85,27.84 92.81,27.8 92.81,27.08 92.77,27.05 92.61,27.05 92.55,27.1 92.55,27.85 92.52,27.88 92.36,27.88 92.31,27.83 92.31,27.1 92.25,27.05 92.09,27.05 92.05,27.09 92.05,27.81 92.02,27.84 91.85,27.84 91.81,27.8 91.81,27.08 91.77,27.05 91.61,27.05 91.55,27.1 91.55,28.33 91.68,28.46 92.19,28.46
GND on TOP (solid shape): 22.31,65.59 22.64,65.59 22.8,65.44 22.8,64.77 22.63,64.6 22.63,64.35 22.46,64.35 22.34,64.23 22.05,63.86 22.33,63.49 22.34,63.48 22.34,62.67 22.22,62.54 21.79,62.54 21.65,62.69 21.65,63.57 21.64,63.58 21.64,65.6 21.78,65.74 22.16,65.74
GND on TOP (solid shape): 261.64,78.47 261.71,78.44 261.74,78.37 261.74,74.31 261.71,74.23 261.63,74.21 261.53,74.22 261.43,74.22 261.36,74.21 261.27,74.23 261.24,74.31 261.24,75.39 261.24,75.4 261.24,76.8 261.24,77.16 260.52,77.87 260.52,78.47 261.6,78.47
GND on TOP (solid shape): 54.79,151.91 54.79,145.94 55.3,145.43 55.5,145.43 55.58,145.36 55.58,145.15 55.52,145.1 55.37,145.1 55.07,144.8 55.07,142.92 56.62,142.92 56.64,142.89 56.64,142.36 56.41,142.13 55.25,142.13 55.07,141.95 55.07,133.8 54.94,133.67 53.72,133.67 53.57,133.82 53.57,138.04 53.32,138.3 53.24,138.3 53.14,138.4 53.14,138.45 53.14,143.22 53.52,143.6 53.52,146.14 53.65,146.27 53.9,146.27 54.15,146.52 54.15,151.91 54.28,152.03 54.66,152.03
GND on TOP (solid shape): 22.95,170.78 22.95,169.47 22.89,169.41 22.23,169.41 22.11,169.29 22.11,168.54 22.24,168.41 22.87,168.41 22.91,168.37 22.91,167.37 22.8,167.26 19.09,167.26 19.01,167.19 18.52,167.19 18.34,167.01 18.34,165.45 18.97,164.81 18.97,163.46 19.16,163.28 19.16,156.45 19.03,156.31 14.01,156.31 13.9,156.42 13.9,157.87 13,158.76 13,162.86 13.01,162.91 13,162.96 13,163.39 13.39,163.77 13.39,168.91 13.81,169.33 21.35,169.33 21.51,169.48 21.51,170.78 21.53,170.8 22.93,170.8
GND on TOP (solid shape): 30.63,139.02 30.63,137.53 30.63,137.53 30.63,134.36 30.28,134 30.28,130.09 30.1,129.92 29.63,129.92 29.39,130.15 29.39,131.46 29.39,131.46 29.39,134.44 29.16,134.66 28.52,134.66 28.45,134.73 28.45,135.63 28.95,135.63 29.08,135.76 29.08,136.03 28.97,136.14 28.94,136.14 28.92,136.11 28.45,136.11 28.45,136.88 28.95,136.88 29,136.93 29,137.34 28.95,137.39 28.48,137.39 28.45,137.41 28.45,138.2 28.98,138.2 29.07,138.29 29.07,138.53 28.96,138.64 28.46,138.64 28.45,138.65 28.45,139.62 28.59,139.76 29.89,139.76
GND on TOP (solid shape): 90.51,28.36 90.51,28.35 90.51,27.11 90.46,27.06 90.3,27.06 90.26,27.09 90.25,27.1 90.25,27.82 90.22,27.85 90.05,27.85 90.01,27.81 90.01,27.09 89.98,27.05 89.81,27.05 89.76,27.11 89.75,27.12 89.75,27.87 89.73,27.9 89.56,27.9 89.51,27.85 89.51,27.11 89.46,27.06 89.3,27.06 89.26,27.09 89.25,27.1 89.25,27.82 89.22,27.85 89.05,27.85 89.01,27.81 89.01,27.09 88.98,27.05 88.81,27.05 88.76,27.11 88.75,27.12 88.75,28.34 88.89,28.47 90.39,28.47
GND on TOP (solid shape): 96.73,146.23 96.73,144.05 96.4,143.71 96.08,143.71 95.84,143.95 95.84,143.96 95.78,144.12 95.65,144.23 95.65,145.2 95.84,145.51 95.65,145.83 95.65,146 95.74,146.23 95.66,146.46 95.73,146.53 96.43,146.53
GND on TOP (solid shape): 245.13,56.23 245.16,55.69 245.7,55.72 245.75,55.77 246.86,55.77 246.94,55.84 247.07,55.72 248.59,55.72 248.65,55.66 248.65,55.47 248.52,55.34 246.25,55.34 246.25,55.34 245.72,55.34 245.59,55.47 245.16,55.47 245.16,55.5 244.4,55.5 244.4,55.47 244.02,55.47 243.89,55.59 243.89,56.1 244.02,56.23
GND on TOP (solid shape): 115.09,154.33 115.09,153.26 115.25,153.11 115.85,153.11 115.85,153.1 115.85,152.52 114.85,152.52 114.61,152.75 114.1,152.75 113.94,152.6 113.94,151.71 114.15,151.5 114.15,151.33 114.02,151.2 113.64,151.2 113.51,151.33 113.51,152.52 113.41,152.62 112.4,152.62 112.34,152.57 112.06,152.57 112,152.63 109.58,152.63 109.52,152.69 109.52,153.03 109.56,153.07 110.2,153.07 110.31,153.19 113.81,153.19 114.36,153.74 114.36,153.98 114.36,153.98 114.36,154.39 114.49,154.52 114.89,154.52
GND on TOP (solid shape): 168.73,23.64 170.55,23.64 170.55,24.17 170.55,24.18 170.56,24.21 170.57,24.24 170.6,24.26 170.63,24.27 170.66,24.27 170.69,24.26 170.71,24.25 170.72,24.24 172.64,22.32 172.64,21.18 171.5,20.03 170.55,20.03 170.55,20.74 168.73,20.74 168.73,20.13 168.73,20.11 168.72,20.08 168.71,20.06 168.68,20.04 168.66,20.03 168.63,20.02 168.6,20.03 168.57,20.04 168.56,20.05 167.82,20.79 167.82,21.1 170.55,21.1 170.55,22.01 168.73,22.01 168.73,21.1 167.82,21.1 167.82,22.37 170.55,22.37 170.55,23.28 168.73,23.28 168.73,22.37 167.82,22.37 167.82,23.84 168.45,24.48 168.73,24.48
GND on TOP (solid shape): 59.03,168.32 60.67,168.32 60.7,168.29 66.19,168.29 66.19,169.64 66.35,169.79 67.72,169.79 67.84,169.66 67.84,169 66.92,168.08 66.92,167.46 66.98,167.4 67.49,167.4 67.74,167.15 67.74,166.64 67.36,166.26 64.02,166.26 63.85,166.08 63.68,166.08 63.53,165.93 63.53,165.4 63.32,165.19 63.12,165.19 62.6,164.67 62.52,164.67 62.28,164.43 61.01,164.43 61,164.42 60.81,164.42 60.5,164.11 60.5,163.21 59.74,162.45 59.74,160.67 56.19,160.67 55.93,160.42 55.93,158.38 52.76,158.38 50.85,156.48 50.09,156.48 48.95,155.34 48.95,154.32 48.82,154.19 46.79,154.19 45.26,155.72 45.26,160.92 46.03,161.69 47.94,161.69 49.17,162.92 49.2,162.92 49.44,163.16 49.44,170.6 49.62,170.78 56.57,170.78
GND on TOP (solid shape): 6.07,96.66 0.53,96.66 0.57,96.75 0.63,96.84 2.51,101.73 0.85,106.69 4.67,106.69 5.51,107.54 6.07,107.54
GND on TOP (solid shape): 192.94,79.19 192.94,72.93 192.85,72.73 192.85,72.51 192.86,72.48 192.58,72.2 192.58,71.47 192.15,71.04 190.2,71.04 188.14,73.09 188.14,74.55 188.29,74.7 188.32,74.7 188.78,75.09 188.27,75.43 188.18,75.44 188.14,75.52 188.14,77.13 190.96,79.95 192.18,79.95
GND on TOP (solid shape): 113.61,86.2 113.89,86.2 116.76,83.33 116.76,82.48 117.75,81.49 118.78,81.49 119.3,80.97 119.3,79.6 119.43,79.47 119.94,79.47 120.07,79.34 124.38,79.34 124.51,79.21 125.53,79.21 125.91,79.6 131.75,79.6 132.13,79.98 132.13,81.37 132.26,81.5 132.53,81.5 133.15,80.88 133.15,80.48 133.51,80.12 133.51,77.56 132.84,77.56 132.55,77.26 132.55,76.37 132.4,76.22 128.7,76.22 128.65,76.17 127.94,76.17 127.69,76.42 127.69,76.87 127.11,77.44 126.42,77.44 126.16,77.69 123.24,77.69 123.1,77.83 118.67,77.83 118.66,77.84 117.86,77.84 117.85,77.83 117.82,77.83 115.87,75.88 115.87,74.18 115.75,74.06 108.99,74.06 108.78,74.27 108.78,78.07 108.55,78.3 108.55,85.61 109.14,86.2 109.35,86.2 109.37,86.22 113.59,86.22
GND on TOP (solid shape): 79.59,55.89 79.67,55.85 79.68,55.76 80.04,55.24 80.39,55.76 80.4,55.85 80.49,55.89 95.25,55.89 95.26,55.89 95.26,55.22 95.5,54.98 95.73,54.98 95.91,54.81 95.91,53.94 95.71,53.74 78.33,53.74 76.89,55.19 76.89,55.75 77.04,55.89
GND on TOP (solid shape): 44.53,146.02 44.53,143.27 44.7,143.1 44.7,138.09 44.78,138.02 44.78,133.82 44.7,133.75 41.96,133.75 41.2,132.98 40.69,132.98 40.56,133.11 40.56,133.62 40.95,134 40.95,138.32 40.98,138.36 40.98,138.94 41.45,139.41 41.45,143.22 41.58,143.35 43.87,143.35 44.04,143.53 44.04,145.12 44.09,145.26 44.08,145.4 44.08,145.4 43.81,145.65 43.46,145.53 43.46,145.52 43.4,145.42 43.38,145.3 43.38,145.28 43.1,145 42.86,145 42.57,145.29 42.57,145.43 42.42,145.59 42.42,146 42.49,146.08 44.46,146.08
GND on TOP (solid shape): 79.58,155.26 79.58,152.54 79.53,152.49 79.27,152.49 79.07,152.29 79.07,152.01 78.87,151.81 78.31,151.81 77.52,152.6 77.52,153.51 78.1,153.51 78.11,153.45 78.12,153.4 78.14,153.35 78.17,153.3 78.2,153.25 78.24,153.22 78.29,153.18 78.34,153.16 78.39,153.14 78.44,153.13 78.5,153.13 78.56,153.13 78.61,153.15 78.66,153.17 78.71,153.2 78.75,153.23 78.79,153.28 78.82,153.32 78.84,153.37 78.86,153.43 78.87,153.48 78.87,153.54 78.86,153.59 78.84,153.65 78.82,153.7 78.79,153.74 78.75,153.79 78.71,153.82 78.66,153.85 78.61,153.87 78.56,153.89 78.5,153.89 78.44,153.89 78.39,153.88 78.34,153.86 78.29,153.84 78.24,153.8 78.2,153.77 78.17,153.72 78.14,153.67 78.12,153.62 78.11,153.57 78.1,153.51 77.52,153.51 77.52,154.78 78.28,155.54 79.3,155.54
GND on TOP (solid shape): 36.2,137.89 36.2,134.46 36.09,134.36 35.99,134.36 35.99,134.36 35.64,134.36 35.29,134.58 34.96,134.32 34.92,134.26 34.85,134.25 34.76,134.25 34.68,134.24 34.6,134.26 34.56,134.32 34.3,134.57 33.95,134.47 33.81,134.33 33.6,134.33 33.5,134.43 33.5,138.24 33.63,138.37 35.71,138.37
GND on TOP (solid shape): 95.96,151.13 95.96,151.11 95.97,151.04 95.99,150.96 95.99,150.47 95.98,150.46 95.95,150.3 95.98,150.15 95.99,150.13 95.99,150 96.25,149.73 96.32,149.73 96.4,149.71 96.47,149.65 96.47,149.6 96.88,149.19 96.92,149.19 97.01,149.16 97.1,149.14 97.28,148.96 97.28,147.92 97.18,147.82 97.05,147.82 96.09,148.79 96.09,149.37 95.84,149.62 95.83,149.63 95.75,149.75 95.63,149.83 95.62,149.84 95.05,150.41 95.04,150.42 94.96,150.54 94.84,150.62 94.83,150.63 94.69,150.77 94.58,150.77 94.55,150.8 94.55,151.22 95.88,151.22
GND on TOP (solid shape): 71.7,68.04 71.7,66.33 71.68,66.31 70.49,66.31 70.4,66.35 70.39,66.44 70.23,66.88 69.77,66.84 69.1,66.84 68.65,66.39 68.35,66.39 68.33,66.42 68.33,67.5 68.37,67.55 69.77,67.55 70.23,67.51 70.39,67.95 70.4,68.04 70.48,68.09 71.65,68.09
GND on TOP (solid shape): 174.04,86.96 174.04,80.85 173.55,80.36 173.55,79.34 173.53,79.34 172.77,78.58 160.12,78.58 159.56,79.14 159.56,82 160.07,82.36 159.56,82.72 159.56,84.42 160.1,84.96 162.07,84.96 162.23,84.8 162.23,82.01 162.48,81.75 166.04,81.75 166.17,81.63 166.17,80.74 166.42,80.48 169.47,80.48 170.23,81.25 173.15,81.25 173.28,81.37 173.28,82.64 173.15,82.77 172.39,82.77 172.26,82.9 172.26,84.8 173.03,85.56 173.03,86.83 173.28,87.09 173.91,87.09
GND on TOP (solid shape): 194.18,68.09 194.67,68.09 194.68,68.1 194.83,68.1 194.84,68.09 195.05,68.09 195.06,68.1 196.42,68.1 196.43,68.09 196.65,68.09 196.66,68.1 196.84,68.1 196.85,68.09 197.21,68.09 197.34,68.13 197.43,68.24 197.5,68.29 197.58,68.27 197.66,68.19 197.79,68.19 198.09,67.88 198.09,67.49 199.3,66.28 199.3,65.89 199.45,65.75 199.89,65.75 199.9,65.75 200.04,65.75 200.08,65.71 200.08,65.18 199.71,65.18 199.5,65.25 199.29,65.19 198.7,65.19 198.56,65.33 198.56,66.34 198.5,66.4 198.5,66.49 198.33,66.66 197.72,66.66 197.31,67.07 197.22,67.07 197.17,67.12 193.82,67.12 193.51,66.81 191.8,66.81 191.68,66.92 191.68,68.28 191.83,68.43 193.84,68.43
GND on TOP (solid shape): 163.1,46.6 163.18,46.56 163.2,46.46 163.27,46.06 163.67,45.96 163.76,45.94 163.8,45.86 163.8,45.33 163.58,45.1 162.57,45.1 162.53,45.15 162.5,45.18 162.48,45.23 162.1,45.61 161.72,45.23 161.69,45.16 161.62,45.13 161.47,45.13 161.14,45.46 161.14,46.27 161.47,46.6
GND on TOP (solid shape): 62.35,68 62.34,67.98 62.45,67.53 62.92,67.53 63.95,67.53 64.51,68.09 64.95,68.09 65,68.04 65,67.24 64.7,66.94 64.62,66.94 64.37,66.84 64.26,66.6 64.26,66.58 64.1,66.41 64.1,66.31 63.16,66.31 63.16,66.51 63.09,66.58 63.09,66.6 62.85,66.92 62.45,66.84 61.57,66.84 61.04,66.31 60.61,66.31 60.52,66.36 60.52,66.46 60.56,66.65 60.51,66.84 60.51,66.89 60.55,66.92 60.67,66.92 60.67,66.82 61.35,66.82 61.35,66.82 61.67,67.13 61.67,68.06 61.7,68.09 62.35,68.09
GND on TOP (solid shape): 243.59,37.44 243.64,37.42 243.69,37.4 243.73,37.35 243.73,37.35 243.75,37.19 243.84,37.07 243.88,36.99 243.84,36.91 243.76,36.79 243.74,36.65 243.7,36.6 243.58,36.55 243.54,36.57 243.47,36.61 243.39,36.62 242.98,36.62 242.91,36.52 242.74,36.47 242.6,36.56 242.56,36.62 242.5,36.62 242.45,36.67 242.45,36.69 242.42,36.81 242.35,36.91 242.32,36.99 242.36,37.06 242.39,37.08 242.46,37.11 242.53,37.08 242.61,37.03 242.7,37 242.74,37 242.94,37.02 243.09,37.15 243.24,37.15 243.55,37.46
GND on TOP (solid shape): 121.22,151.91 121.3,151.87 121.32,151.78 121.36,151.54 121.55,151.37 121.61,151.32 121.61,151.23 121.88,150.74 122.29,151.12 122.29,151.25 122.57,151.53 123.8,151.53 123.84,151.49 123.84,150.81 123.81,150.78 123.44,150.78 122.62,149.95 121.88,149.95 121.74,149.81 121.74,149.81 121.6,149.69 121.53,149.52 121.53,149.46 121.54,149.41 121.55,149.38 121.51,149.34 121.21,149.34 121.13,149.42 121.13,149.85 120.83,150.16 120.83,150.33 121.13,150.64 121.13,151.23 121.01,151.36 120.23,151.36 119.63,150.76 119.48,150.62 119.42,150.61 119.37,150.6 119.02,150.6 119.01,150.59 118.35,150.59 118.15,150.65 117.94,150.59 117.61,150.59 117.44,150.76 117.44,151.84 117.5,151.91
GND on TOP (solid shape): 118.92,148.36 118.92,135.14 119.05,135.02 119.05,131.46 118.92,131.33 117.78,131.33 117.65,131.46 117.65,132.22 117.91,132.48 117.91,132.95 118.27,133.31 118.44,133.62 118.26,133.93 117.91,134.28 117.91,134.97 118.31,135.38 118.44,135.64 118.32,135.92 117.91,136.33 117.91,136.88 118.28,137.26 118.44,137.57 118.27,137.86 117.91,138.22 117.91,138.91 118.31,139.31 118.44,139.55 118.36,139.82 118.36,139.82 117.91,140.28 117.91,140.94 118.31,141.35 118.44,141.6 118.34,141.87 118.34,141.88 117.91,142.31 117.91,142.97 118.34,143.4 118.34,143.4 118.44,143.64 118.35,143.89 118.35,143.9 117.91,144.34 117.91,145 118.33,145.42 118.44,145.67 118.35,145.92 117.91,146.37 117.91,148.78 117.98,148.86 118.43,148.86
GND on TOP (solid shape): 95.2,164.91 97.16,164.91 97.66,165.42 98.92,165.42 99.91,164.43 99.91,161.99 99.4,161.48 99.07,161.48 98.69,161.1 98.69,161.09 98.53,160.92 97.68,160.92 97.6,160.96 97.58,161.05 97.58,161.21 97.51,161.36 97.48,161.42 97.51,161.49 97.59,161.7 97.52,161.93 97.49,161.99 97.52,162.06 97.27,162.65 96.97,162.08 96.99,162.01 96.97,161.95 96.88,161.72 96.96,161.48 96.98,161.42 96.96,161.35 96.89,161.21 96.89,161.05 96.87,160.96 96.79,160.92 95.68,160.92 95.3,160.54 95.3,159.99 95.05,159.73 93.86,159.73 93.68,159.91 93.68,160.4 93.38,160.7 93.35,160.7 93.35,161.79 94.03,162.47 94.03,164.61 93.52,165.11 93.52,165.83 93.65,165.96 94.16,165.96
GND on TOP (solid shape): outline of 151 points within 47,174.1 74,182.4
GND on TOP (solid shape): outline of 160 points within 78.03,151.65 88.85,168.04
GND on TOP (solid shape): 84.46,68.01 84.46,66.87 84.51,66.82 85.47,66.82 85.47,66.85 85.63,66.85 85.64,66.85 86.18,67.2 85.64,67.55 85.63,67.54 85.47,67.54 85.47,67.58 85.41,67.58 85.41,68.09 95.35,68.09 95.35,67.58 95.09,67.58 94.67,67.22 95.05,66.82 95.08,66.82 95.97,66.82 95.97,66.82 96.24,66.82 96.29,66.87 96.29,68.01 96.37,68.09 98.21,68.09 98.31,68.02 98.29,67.91 97.95,67.58 97.8,67.58 97.8,67.37 97.78,67.3 97.76,67.22 97.48,66.93 97.48,66.79 97.41,66.65 97.4,66.49 97.41,66.46 97.25,66.31 90.88,66.31 90.88,66.82 90.95,66.82 90.95,66.85 91.09,66.85 91.12,66.83 91.83,66.83 91.84,66.82 92.38,67.17 91.84,67.52 91.83,67.52 91.4,67.52 91.38,67.54 91.01,67.54 90.97,67.58 89.99,67.58 89.94,67.53 89.94,66.46 89.79,66.31 80.72,66.31 80.7,66.33 80.7,67.58 80.67,67.6 79.71,67.6 79.39,67.28 79.36,67.29 78.89,66.87 79.45,66.58 79.55,66.57 79.6,66.49 79.6,66.31 76.81,66.31 76.73,66.39 76.73,67.55 76.52,67.77 76.52,67.89 76.71,68.09 84.38,68.09
GND on TOP (solid shape): outline of 192 points within 1.32,141.87 10.85,153.05
GND on TOP (solid shape): outline of 197 points within 173.66,48.15 176.58,53.46
GND on TOP (solid shape): outline of 89 points within 239.83,49.54 243.61,52.8
GND on TOP (solid shape): 259.84,65.81 260.01,65.7 260.2,65.67 261.6,65.67 261.68,65.67 261.75,65.69 262.57,64.86 263.62,65.34 265.99,65.34 266.08,65.28 266.05,65.17 265.94,64.51 266.5,64.14 268.5,64.14 269.06,64.51 268.95,65.17 268.92,65.28 269.01,65.34 269.39,65.34 269.39,52.46 269.01,52.46 268.92,52.52 268.95,52.63 269.06,53.29 268.5,53.66 266.5,53.66 265.94,53.29 266.05,52.63 266.08,52.52 265.99,52.46 263.62,52.46 262.6,52.95 261.77,52.18 261.76,52.16 261.71,52.12 261.65,52.13 261.6,52.13 260.2,52.13 259.67,51.6 260.2,51.07 261.6,51.07 261.63,51.07 261.71,51.04 261.74,50.97 261.74,46.9 261.7,46.83 261.62,46.81 261.49,46.82 261.36,46.81 261.27,46.83 261.24,46.91 261.24,47.68 261.23,47.68 261.23,49.27 260.22,50.29 259.04,50.29 258.76,50.57 258.76,52.54 259.54,53.32 259.54,54.65 258.8,54.65 258.8,63.15 259.54,63.15 259.54,65.51
GND on TOP (solid shape): outline of 111 points within 31.82,66.31 60.66,68.09
GND on TOP (solid shape): outline of 293 points within 33.38,52.85 60.7,55.89
GND on TOP (solid shape): outline of 332 points within 98.73,123.52 107.44,149.03
GND on TOP (solid shape): outline of 316 points within 119.94,154.93 125.13,159.94
GND on TOP (solid shape): outline of 442 points within 111.87,131.33 116.38,149.82
GND on TOP (solid shape): outline of 428 points within 106.86,131.33 110.03,149.85
GND on TOP (solid shape): outline of 917 points within 30.89,78.37 100.63,88.91
GND on TOP (solid shape): outline of 1334 points within 258.78,79.52 270.14,129.05
GND on TOP (solid shape): outline of 1538 points within 99.4,152.51 109.32,160.19
GND on TOP (solid shape): outline of 2837 points within 0.51,0.51 272,186.39
GND on TOP (solid shape): outline of 2180 points within 237.78,28.6 248.34,38.18
GND on BOTTOM (solid shape): 90.93,37.36 74.8,37.36 74.8,47.65 90.93,47.65
GND on BOTTOM (solid shape): 141.25,29.6 131.75,29.6 131.75,31.6 141.25,31.6
GND on BOTTOM (solid shape): 160.71,87.22 160.71,86.33 160.07,86.33 159.82,86.58 159.82,87.6 160.33,87.6
GND on BOTTOM (solid shape): 33.45,113.3 33.45,111.9 31.8,110.25 31.04,110.25 30.66,110.63 30.66,113.55 33.2,113.55
GND on BOTTOM (solid shape): 4.12,163.87 4.12,159.78 3.73,159.4 1.45,159.4 1.19,159.65 1.19,163.72 1.58,164.1 3.89,164.1
GND on BOTTOM (solid shape): 11.64,113.62 11.64,110.99 10.61,110.99 10.51,111.09 10.51,113.53 10.74,113.76 11.51,113.76
GND on BOTTOM (solid shape): 42.72,82.95 42.72,81.29 42.6,81.17 41.07,81.17 40.95,81.29 40.95,82.95 41.07,83.07 42.6,83.07
GND on BOTTOM (solid shape): 63.55,82.64 63.55,80.87 63.42,80.74 61.14,80.74 61.01,80.87 61.01,82.64 61.14,82.77 63.42,82.77
GND on BOTTOM (solid shape): 72.57,82.9 72.57,80.99 72.44,80.87 70.66,80.87 70.54,80.99 70.54,83.02 70.66,83.15 72.31,83.15
GND on BOTTOM (solid shape): 85.32,83.79 85.32,81.56 85.11,81.34 84.79,81.34 84.5,81.64 84.5,83.89 84.53,83.93 85.19,83.93
GND on BOTTOM (solid shape): 89.21,29.56 89.21,27.32 89.05,27.17 88.04,27.17 86.77,28.44 86.77,29.56 86.87,29.66 89.1,29.66
GND on BOTTOM (solid shape): 100.38,87.64 100.38,82.95 97.21,82.95 97.21,88.41 97.59,88.79 99.24,88.79
GND on BOTTOM (solid shape): 114.12,113.07 114.12,112.74 113.64,112.26 113.2,112.26 113.08,112.37 113.08,113.12 113.31,113.35 113.84,113.35
GND on BOTTOM (solid shape): 122.23,63.06 122.23,62.48 121.97,62.22 121.29,62.22 121.29,62.91 121.67,63.29 122,63.29
GND on BOTTOM (solid shape): 129.22,167.98 129.22,167.52 129.17,167.48 126.75,167.48 126.58,167.64 126.58,167.97 126.64,168.04 129.16,168.04
GND on BOTTOM (solid shape): 150.74,41.33 151.6,41.33 151.69,41.24 151.69,37.94 151.56,37.81 150.67,37.81 150.17,38.32 150.17,41.5 150.57,41.5
GND on BOTTOM (solid shape): 214.91,41.63 214.91,39.59 214.72,39.39 214.44,39.39 213.8,40.03 213.8,41.91 213.85,41.96 214.58,41.96
GND on BOTTOM (solid shape): 60.45,53.9 60.45,52.86 60.01,52.42 58.62,52.42 58.41,52.21 56.64,52.21 56.4,52.45 56.4,53.76 56.72,54.08 60.27,54.08
GND on BOTTOM (solid shape): 69.55,28.24 69.55,26.58 69.46,26.49 67.16,26.49 67.08,26.57 67.08,28.3 67.3,28.52 69.27,28.52
GND on BOTTOM (solid shape): 74.7,150.51 74.7,148.1 74.4,147.79 73.48,147.79 73.38,147.9 73.38,150.51 73.56,150.69 74.52,150.69
GND on BOTTOM (solid shape): 112.37,185.16 112.37,183.83 112.29,183.76 111.35,183.76 111.25,183.86 111.25,184.9 111.56,185.21 112.32,185.21
GND on BOTTOM (solid shape): 113.14,109.77 113.32,109.77 113.64,109.44 113.64,109.26 113.54,109.15 112.5,109.15 111.7,109.95 111.7,110.59 111.78,110.66 112.25,110.66
GND on BOTTOM (solid shape): 129.21,115.58 129.21,115.28 129.08,115.15 126.35,115.15 126.28,115.22 126.28,115.56 126.43,115.71 129.08,115.71
GND on BOTTOM (solid shape): 135.7,56.6 141.25,56.6 141.25,54.6 131.75,54.6 131.75,56.6 132.43,56.6 133.39,57.56 133.39,57.76 133.48,57.85 134.45,57.85
GND on BOTTOM (solid shape): 155.96,184.15 155.96,183.58 155.9,183.52 153.85,183.52 153.76,183.62 153.76,184.08 153.88,184.2 155.92,184.2
GND on BOTTOM (solid shape): 158.62,171.98 158.62,169.68 158.47,169.53 157.41,169.53 157.28,169.67 157.28,172.18 157.4,172.31 158.29,172.31
GND on BOTTOM (solid shape): 231.68,38.24 231.68,37.1 231.38,36.8 228.27,36.8 228.14,36.92 228.14,38.14 228.34,38.33 231.59,38.33
GND on BOTTOM (solid shape): 23.07,115.21 23.34,114.94 23.34,113.46 23.52,113.29 23.52,110.5 22.15,110.5 21.77,110.89 21.77,114.68 22.34,115.26 23.07,115.26
GND on BOTTOM (solid shape): 227.51,88.58 227.51,87.14 227.38,87.01 224.33,87.01 224.08,87.26 224.08,87.9 224.64,88.46 224.69,88.46 224.94,88.71 227.38,88.71
GND on BOTTOM (solid shape): 29.9,172.23 29.9,167.96 28.8,166.87 26.14,166.87 25.71,167.3 25.71,171.08 27.1,172.48 29.64,172.48
GND on BOTTOM (solid shape): 56.95,172.05 59.36,172.05 59.36,171.29 58.94,170.87 56.73,170.87 56.45,171.15 55.96,171.15 55.55,171.56 55.55,172.05 55.68,172.18 56.82,172.18
GND on BOTTOM (solid shape): 156.8,42.63 156.8,42.22 156.64,42.06 156.33,42.06 156,42.38 155.36,42.38 155.2,42.55 155.2,42.71 155.43,42.94 156.49,42.94
GND on BOTTOM (solid shape): 231.6,15.92 231.37,15.69 231.37,13.1 231.19,12.92 230.3,12.92 230.1,13.12 230.1,18.17 230.23,18.3 231.6,18.3
GND on BOTTOM (solid shape): 42.77,170.78 42.77,169.21 42.24,168.67 36.27,168.67 35.99,168.95 35.99,172.05 36.68,172.73 40.82,172.73
GND on BOTTOM (solid shape): 63.65,167.3 63.65,164.71 63.32,164.38 58.68,164.38 58.48,164.58 58.48,166.82 59.11,167.45 59.11,167.91 59.36,168.16 62.79,168.16
GND on BOTTOM (solid shape): 130.74,185.23 130.74,183.2 130.43,182.9 129.95,182.9 129.87,182.97 129.87,185.08 130.07,185.28 130.68,185.28
GND on BOTTOM (solid shape): 137.77,62 137.77,60.13 137.24,59.61 136.22,59.61 136.12,59.71 136.12,60.19 136.22,60.29 136.82,60.29 136.96,60.44 136.96,62.11 137.09,62.24 137.53,62.24
GND on BOTTOM (solid shape): 155.37,74.98 155.37,73.42 151.01,73.42 150.67,73.75 150.67,73.76 150.61,73.82 150.61,75.49 150.92,75.8 152.08,75.8 152.51,76.23 154.12,76.23
GND on BOTTOM (solid shape): 248.59,71.09 248.59,68.17 248.21,67.78 244.15,67.78 243.89,68.04 243.89,70.83 244.02,70.96 245.29,70.96 245.67,71.34 248.34,71.34
GND on BOTTOM (solid shape): 25.35,181.17 25.86,180.66 29.03,180.66 29.03,179.52 22.56,179.52 22.3,179.77 22.3,180.41 23.83,181.93 25.35,181.93
GND on BOTTOM (solid shape): 71.45,163.69 71.45,162.5 71.29,162.33 71.21,162.33 71.2,162.32 65.58,162.32 65.56,162.34 65.56,163.03 67.45,164.92 70.22,164.92
GND on BOTTOM (solid shape): 140.13,92.85 140.13,91.47 140.89,90.71 140.89,89.25 138.91,87.26 137.85,87.26 137.78,87.33 134.61,87.33 134.29,87.64 134.29,93.11 134.42,93.23 139.75,93.23
GND on BOTTOM (solid shape): 174.8,27.27 176.63,27.27 176.73,27.17 176.73,25.89 176.31,25.47 173.15,25.47 172.92,25.7 172.92,27.63 173.03,27.73 174.35,27.73
GND on BOTTOM (solid shape): 262.21,35.64 269.19,35.64 269.19,32.96 269.22,32.96 269.32,32.86 269.19,32.73 258.75,32.73 258.75,34.83 258.53,35.05 258.15,35.05 257.94,35.26 257.94,37.59 258.22,37.87 259.98,37.87
GND on BOTTOM (solid shape): 11.77,78.45 12.42,78.45 13.03,77.84 13.03,77.18 13.14,77.08 13.14,76.45 10.54,76.45 10.47,76.52 10.47,77.15 10.59,77.27 10.59,78.37 10.67,78.45 11.76,78.45
GND on BOTTOM (solid shape): 157.12,120.77 157.12,117.04 157.02,116.93 156.77,116.93 156.52,117.19 155.83,117.19 155.83,119.73 156.4,120.3 156.4,120.82 156.48,120.9 156.99,120.9
GND on BOTTOM (solid shape): 160.46,41.73 160.46,41.68 160.46,41.45 160.31,41.3 160.31,41.07 159.92,40.68 159.36,40.68 159.23,40.82 159.23,41.18 159.73,41.68 160.09,41.68 160.24,41.84 160.36,41.84
GND on BOTTOM (solid shape): 254.96,21.16 256.85,20.16 257.38,19.78 257.73,19.78 257.73,19.27 257.63,19.17 256.47,19.17 256.36,19.27 255.7,19.27 255.07,19.91 253.67,19.91 252.91,20.67 252.91,21.3 254.61,21.3
GND on BOTTOM (solid shape): 13.47,98.84 13.47,94.8 13.21,94.54 8.93,94.54 8.93,98.15 9.14,98.36 11.27,98.36 11.51,98.59 11.51,99.08 11.68,99.26 13.06,99.26
GND on BOTTOM (solid shape): 112.98,99.94 113.49,99.94 113.5,99.93 113.58,99.93 113.8,99.7 114.21,99.7 114.27,99.65 114.27,99.43 114.15,99.3 113.34,99.3 113.19,99.46 111.73,99.46 111.48,99.71 111.48,100.19 111.51,100.22 112.7,100.22
GND on BOTTOM (solid shape): 173.53,81.37 173.53,80.16 170.93,77.56 169.55,77.56 169.53,77.58 168.86,77.58 168.07,78.36 168.07,79.72 168.33,79.98 169.72,79.98 170.23,80.48 170.23,81.29 170.44,81.5 173.41,81.5
GND on BOTTOM (solid shape): 232.44,86.41 232.44,81.93 232.32,81.8 231.7,81.8 231.32,82.18 223.06,82.18 223.06,82.19 222.63,82.19 222.53,82.29 222.53,86.55 222.73,86.76 227.64,86.76 227.8,86.92 231.93,86.92
GND on BOTTOM (solid shape): 232.65,94.31 232.65,93.81 232.94,93.52 233.96,93.52 234.44,93.03 234.92,93.03 235.15,92.8 235.15,92.39 234.72,91.96 232.56,91.96 231.98,92.55 229.95,92.55 229.95,93.82 230.28,94.15 231.04,94.15 231.34,94.45 232.51,94.45
GND on BOTTOM (solid shape): 125.55,185.03 125.55,184.47 125.48,184.39 124,184.39 123.04,183.43 122.05,183.43 121.97,183.5 121.97,183.86 122.5,184.39 122.5,185.16 122.61,185.26 125.32,185.26
GND on BOTTOM (solid shape): 146.88,108.54 147.39,108.54 147.75,108.18 147.75,107.15 148.26,106.65 149.45,106.65 149.45,102.2 148.77,101.52 148.77,100.38 148.59,100.19 144.85,100.19 144.5,100.55 144.5,101.69 143.61,102.58 143.61,107.78 144.38,108.55 146.86,108.55
GND on BOTTOM (solid shape): 196.84,27.44 196.99,27.44 197.87,26.56 197.87,25.34 198.07,25.14 198.53,25.14 198.71,24.96 198.71,23.25 198.58,23.13 195.58,23.13 194.79,23.92 194.79,27.34 194.89,27.44 196.83,27.44
GND on BOTTOM (solid shape): 215.53,49.11 215.53,48.24 215.53,48.18 215.53,48.12 215.53,47.79 216.06,47.26 216.06,46.34 216.05,46.29 216.06,46.24 216.06,46.19 215.86,45.99 215.09,45.99 214.04,47.04 214.04,49.74 214.1,49.8 214.84,49.8
GND on BOTTOM (solid shape): 242.99,35.49 242.99,34.14 242.98,34.14 242.98,33.85 242.93,33.79 242.55,33.79 242.35,33.99 241.58,33.99 241.2,34.37 241.2,34.71 241.3,34.82 241.73,34.82 241.88,34.97 241.88,35.48 241.96,35.55 242.92,35.55
GND on BOTTOM (solid shape): 122.81,60.72 126.67,60.72 126.86,60.53 126.86,59.87 126.86,59.87 124.92,57.93 122.27,57.93 122.05,58.14 122.05,59.75 121.59,60.22 121.39,60.22 121.29,60.32 121.29,61 121.34,61.05 122.48,61.05
GND on BOTTOM (solid shape): 146.33,184 146.36,183.78 146.51,183.61 146.51,183.11 146.39,182.99 145.79,182.99 145.34,183.44 142.04,183.44 141.98,183.5 141.98,184.22 142.12,184.36 145.98,184.36
GND on BOTTOM (solid shape): 265.6,25.4 265.6,24.6 265.48,24.49 264.47,24.49 264.37,24.59 264.37,24.95 264.62,25.2 264.89,25.24 265.07,25.45 265.56,25.45
GND on BOTTOM (solid shape): 52.74,56.03 52.74,54.66 50.88,52.8 49.72,52.8 49.72,54.3 46.47,54.3 46.47,52.8 44.87,52.8 44.6,52.53 44.6,51.7 44.22,51.32 39.55,51.32 37.85,53.03 37.71,53.03 37.7,53.03 34.73,53.03 32.18,55.58 32.18,56.02 32.22,56.06 52.72,56.06
GND on BOTTOM (solid shape): 95.4,85.72 95.4,80.79 95.48,80.72 97.68,80.72 97.79,80.6 97.79,78.35 97.4,78.35 97.4,78.39 95.75,80.05 94.83,80.05 94.83,80.06 94.74,80.14 94.74,84.22 94.18,84.78 94.18,85.66 94.37,85.84 95.28,85.84
GND on BOTTOM (solid shape): 220.56,69.61 220.56,69.61 222.05,69.61 222.68,68.98 222.68,67.07 222.43,66.82 219.63,66.82 219.19,66.37 219.19,64.72 219,64.53 215.32,64.53 214.91,64.94 214.91,65.6 215.65,66.34 215.65,68.87 216.13,69.36 217.34,69.36 217.85,69.87 220.3,69.87
GND on BOTTOM (solid shape): 226.13,33.49 226.31,33.33 226.56,33.3 226.75,33.11 226.75,32.61 226.62,32.48 225.89,32.48 225.69,32.28 225.3,32.28 224.97,32.61 224.97,33.24 225.22,33.49
GND on BOTTOM (solid shape): 45.81,48.97 45.81,48.47 45.7,48.36 38.38,48.36 38.37,48.35 38.35,48.34 37.58,48.34 37.38,48.14 37.38,47.54 36.96,47.12 36.96,46.74 36.88,46.67 35.08,46.67 34.62,46.21 32.24,46.21 32.18,46.27 32.18,46.65 34.55,49.02 45.76,49.02
GND on BOTTOM (solid shape): 94.49,55.69 94.43,55.64 93.53,55.64 93.22,55.33 90.6,55.33 90.35,55.07 90.35,54.55 90.25,54.45 88.7,54.45 88.57,54.58 88.57,55.6 88.92,55.94 88.95,55.94 89.01,56 94.49,56
GND on BOTTOM (solid shape): 201.6,33.62 201.6,33.22 201.38,33.22 201.38,32.97 201.27,32.86 201.27,30.37 201.07,30.33 200.92,30.19 199.67,30.19 199.64,30.22 199.64,32.96 199.66,32.97 199.66,33.74 199.85,33.93 201.3,33.93
GND on BOTTOM (solid shape): 205.03,63.64 206.17,63.64 206.3,63.51 206.3,57.44 205.9,57.04 204.58,57.04 204.53,57.09 204.53,59.24 204.18,59.59 202.62,59.59 201.89,60.32 201.89,62.54 202.46,63.11 202.97,63.11 203.51,63.64 203.51,63.9 203.63,64.02 204.65,64.02
GND on BOTTOM (solid shape): 156.95,145.76 156.95,142.84 156.92,142.81 156.29,142.81 156.19,142.92 156.19,144.07 156.1,144.15 155.9,144.15 155.85,144.2 155.85,145.78 155.91,145.84 156.88,145.84
GND on BOTTOM (solid shape): 6.91,88.36 6.91,87.98 6.99,87.9 9.21,87.9 9.33,87.78 9.33,87.23 9.3,87.2 8.17,87.2 8,87.24 7.83,87.2 5.34,87.2 5.21,87.33 5.21,87.9 6.15,87.9 6.25,88 6.25,88.36 6.35,88.46 6.8,88.46
GND on BOTTOM (solid shape): 159.89,114.16 160.93,111.04 161.8,109.14 161.79,108.84 161.43,106.98 161.43,106 158.77,103.44 158.69,103.37 156.49,103.37 156.26,103.6 156.26,108.93 156.28,108.95 156.34,109.01 156.39,109.06 156.59,109.27 156.59,110.58 156.21,110.96 154.94,110.96 154.82,111.09 154.82,114.01 155.21,114.41 155.95,114.41 155.97,114.43 159.81,114.43
GND on BOTTOM (solid shape): 58.46,183.25 58.46,182.77 58.58,182.65 59.41,182.65 59.51,182.55 59.51,182.39 58.8,181.68 58.8,178.83 58.51,178.54 57.77,178.54 57.53,178.78 57.53,180.18 57.91,180.56 57.91,181.92 58.14,182.15 58.14,182.98 58.13,182.99 58.13,183.21 58.22,183.31 58.41,183.31
GND on BOTTOM (solid shape): 104.7,183.73 104.47,183.5 102.92,183.5 102.51,183.91 102.51,183.92 103.76,183.92 103.76,184.23 103,184.23 103,183.92 102.51,183.92 102.51,184.51 104.14,184.51 104.14,185.06 103.91,185.06 103.91,184.51 102.51,184.51 102.51,185.27 102.61,185.36 104.7,185.36
GND on BOTTOM (solid shape): 170.61,96.41 170.79,96.41 171.88,95.47 173.89,93.83 174.7,93.2 174.67,92.59 172.71,90.63 172.71,90.14 172.6,90.04 170.05,90.04 168.89,88.88 167.05,88.88 166.61,89.32 166.61,93.64 166.6,93.65 166.6,94.06 166.85,94.31 166.95,94.41 167.6,94.86 168,95.06 168.49,95.41 169.24,95.93 169.78,96.42 170.6,96.42
GND on BOTTOM (solid shape): 110.67,67.89 116.08,67.89 116.43,67.53 116.43,66.79 116.2,66.56 107.52,66.56 107.39,66.69 107.39,67.18 107.59,67.38 108.2,67.38 108.24,67.42 108.24,68.69 108.48,68.93 108.5,68.93 108.56,68.98 109.58,68.98
GND on BOTTOM (solid shape): 217.91,88.41 217.91,87.49 218.06,87.34 218.06,86.93 217.68,86.55 217.68,83.2 217.98,82.9 217.98,81.53 217.73,81.27 217.09,81.27 216.79,81.58 216.79,85.16 215.9,85.16 215.85,85.21 215.85,85.31 215.87,85.33 216.76,85.33 216.79,85.36 216.79,86.63 216.61,86.81 216.48,86.81 216.31,86.98 216.31,88.43 216.43,88.56 217.75,88.56
GND on BOTTOM (solid shape): 244.4,36.21 244.4,36.19 244.37,36.06 244.4,35.94 244.4,35.93 244.4,35.45 244.4,35.44 244.39,35.33 244.42,35.23 244.42,34.62 244.37,34.56 244.02,34.56 243.99,34.59 243.99,35.07 243.87,35.2 243.87,35.76 243.69,35.93 243.69,36.29 243.71,36.31 244.3,36.31
GND on BOTTOM (solid shape): 246.26,32.35 247.53,32.35 247.83,32.05 249.48,32.05 249.52,32.01 249.88,32.01 250.07,31.83 250.07,27.92 250,27.85 248.72,27.85 247.93,28.64 247.93,31.18 247.72,31.39 247.12,31.39 246.74,31.78 246.44,31.78 246.39,31.82 245.56,31.82 245.29,32.1 245.29,32.22 245.42,32.35 246.25,32.35
GND on BOTTOM (solid shape): 46.91,35.02 46.91,33.38 46.98,33.31 49.07,33.31 49.07,32.22 47.04,32.22 46.79,31.97 46.79,30.02 46.86,29.94 46.86,29.79 46.76,29.53 46.86,29.27 46.86,29.13 46.7,28.97 46.47,28.97 46.34,29.1 46.34,34.88 46.54,35.08 46.86,35.08
GND on BOTTOM (solid shape): 126.04,69.48 127.05,69.48 127.57,68.96 127.57,68.95 127.63,68.89 127.63,67.64 128.07,67.2 128.07,66.08 128.06,66.08 128.07,65.89 127.57,64.85 127,64.28 125.65,64.28 125.53,64.4 125.53,65.29 125.4,65.42 124.46,65.42 124.03,65.86 124.03,68.19 123.24,68.98 123.24,70.12 123.37,70.25 125.27,70.25
GND on BOTTOM (solid shape): 11.4,99.94 11.4,99.59 11.3,99.48 11.02,99.48 10.99,99.46 10.99,98.77 10.83,98.6 10.26,98.6 9.9,98.96 8.46,98.96 8.45,98.96 5.33,98.96 5.27,99.02 5.27,99.54 5.33,99.6 9.78,99.6 9.78,99.61 9.9,99.61 10.34,100.04 11.3,100.04
GND on BOTTOM (solid shape): 243.2,31.49 243.2,31.26 243.31,31.16 243.31,31.02 243.45,31.02 243.54,30.92 244.11,30.92 244.16,30.88 244.16,29.42 244.02,29.29 244.02,29.29 243.66,28.93 242.94,28.93 242.94,29.15 242.64,29.45 242.64,30.17 242.8,30.34 243.14,30.34 243.14,30.49 243.15,30.49 243.15,30.85 243.14,30.86 243.14,30.89 243.1,30.89 242.92,31.08 242.8,31.08 242.69,31.19 242.69,31.56 243.13,31.56
GND on BOTTOM (solid shape): 35.8,148.83 35.8,148.71 35.68,148.46 35.8,148.22 35.8,148.06 35.75,148.01 35.69,147.92 35.49,147.92 35.48,147.95 35.41,148.04 35.31,148.1 35.3,148.1 35.03,148.37 35.03,149.13 35.19,149.29 35.34,149.29
GND on BOTTOM (solid shape): 33.42,148.89 33.42,148.68 33.32,148.46 33.42,148.24 33.42,148.03 33.39,148.01 33.37,147.98 33.29,147.9 33.14,147.9 33.13,147.91 33.06,148.03 32.95,148.1 32.94,148.1 32.63,148.41 32.63,149.14 32.7,149.19 32.75,149.26 33.05,149.26
GND on BOTTOM (solid shape): 85.01,157.75 85.01,155.03 82.22,152.24 79.93,152.24 79.81,152.37 79.81,152.87 80.82,152.87 81.2,153.26 81.2,153.31 81.21,153.32 81.26,153.52 81.2,153.71 81.2,154.25 79.71,155.75 79.71,156.45 79.49,156.66 77.86,156.66 77.67,156.86 77.63,156.86 77.61,156.88 77.61,157.23 77.62,157.24 78.18,157.24 78.31,157.37 78.33,157.37 78.33,157.39 78.4,157.45 80.07,157.45 81.02,158 84.76,158
GND on BOTTOM (solid shape): 243.45,33.74 244.01,33.74 244.08,33.67 244.08,32.45 244.26,32.26 244.26,32.09 244.17,32 244.04,32 243.89,32.15 243.89,32.25 243.7,32.25 243.68,32.28 243.52,32.42 243.3,32.43 242.93,32.43 242.82,32.53 242.83,32.53 242.83,32.86 242.96,33 243.14,33 243.28,33.14 243.28,33.67 243.35,33.74
GND on BOTTOM (solid shape): 181.03,42.29 181.03,42.25 181.13,42.15 181.13,42.09 181.12,41.99 181.14,41.9 181.14,41.88 181.14,41.8 181.24,41.7 181.35,41.7 181.41,41.69 182,41.11 182,40.74 181.91,40.66 181.37,40.66 181.03,41 181,41.01 180.94,41.07 180.92,41.1 180.91,41.11 180.91,41.28 180.82,41.36 180.82,42.03 180.83,42.04 180.83,42.24 180.88,42.29 181.03,42.29
GND on BOTTOM (solid shape): 31.08,148.83 31.08,148.71 30.96,148.46 31.08,148.22 31.08,148.06 31.03,148.01 30.96,147.92 30.77,147.92 30.76,147.93 30.7,148.03 30.61,148.09 30.6,148.09 30.29,148.4 30.29,149.15 30.35,149.21 30.4,149.28 30.44,149.32 30.59,149.32
GND on BOTTOM (solid shape): 141.69,64.37 141.81,64.29 141.94,64.25 141.97,64.22 141.97,63.17 142.21,62.92 142.21,62.68 146.54,62.68 146.54,61.53 146.48,61.58 145.59,61.58 145.47,61.71 143.84,61.71 143.79,61.66 143.79,60.93 143.74,60.88 143.64,60.88 143.61,60.9 143.61,61.69 143.59,61.71 142.49,61.71 142.49,61.71 142.01,61.71 141.62,62.1 141.62,62.12 141.51,62.29 141.33,62.39 141.33,62.4 141.33,64.15 141.55,64.37
GND on BOTTOM (solid shape): 25.29,94.84 25.36,94.81 25.39,94.74 25.73,94.37 26.14,94.64 26.21,94.71 26.31,94.69 26.48,94.52 26.48,86.73 25.19,85.44 20.63,85.44 20.49,85.58 20.49,93.55 21.01,94.07 24.31,94.07 25.07,94.84
GND on BOTTOM (solid shape): 157.15,160.25 157.2,160.06 157.33,159.92 157.42,159.82 157.42,158.96 157.39,158.94 157.16,158.67 157.26,158.32 157.42,158.16 157.42,151.54 157.29,151.41 156.41,151.41 156.32,151.5 156.32,152.12 155.87,152.57 155.87,154.09 156.01,154.23 156.01,157.61 156.41,158.01 156.41,158.98 156.03,159.36 156.03,160.06 156.26,160.3 157.15,160.3
GND on BOTTOM (solid shape): 49.87,149.02 49.87,149.01 49.93,148.92 50.01,148.85 50.01,148.73 49.86,148.46 50.01,148.2 50.01,148.07 49.93,148.01 49.88,147.92 49.87,147.89 49.7,147.89 49.66,147.93 49.65,147.94 49.59,148.03 49.5,148.09 49.49,148.1 49.15,148.44 49.15,149.12 49.24,149.19 49.31,149.29 49.32,149.32 49.57,149.32
GND on BOTTOM (solid shape): 54.58,149.16 54.58,149.07 54.61,148.98 54.65,148.92 54.7,148.87 54.71,148.86 54.65,148.66 54.61,148.59 54.58,148.46 54.61,148.33 54.61,148.33 54.65,148.27 54.7,148.22 54.71,148.21 54.71,148.09 54.52,147.9 54.39,147.9 54.38,147.93 54.3,148.05 54.17,148.11 54.16,148.11 53.96,148.31 53.96,149.14 54.19,149.36 54.38,149.36
GND on BOTTOM (solid shape): 59.47,34.96 59.47,34.23 59.43,34.22 59.13,33.95 59.24,33.56 59.43,33.37 59.8,33.37 59.88,33.29 59.88,32.27 59.38,31.77 57.39,31.77 57.07,31.95 56.75,31.77 56.55,31.77 56.33,32 56.33,33.17 56.7,33.54 58.46,33.54 58.58,33.66 58.58,35 58.65,35.07 59.36,35.07
GND on BOTTOM (solid shape): 49.28,126.49 49.28,124.71 49.28,124.7 48.99,124.7 48.93,124.85 48.81,124.96 48.81,125.36 48.5,125.67 48.5,125.7 48.48,125.85 48.38,125.98 48.34,126.06 48.38,126.14 48.44,126.21 48.49,126.29 48.53,126.34 48.6,126.36 48.81,126.39 48.96,126.55 49.23,126.55
GND on BOTTOM (solid shape): 192.96,80.51 192.96,73.07 192.86,72.96 192.86,72.76 192.84,72.62 192.86,72.48 192.86,72.1 192.96,72 192.96,71.34 192.58,70.95 189.48,70.95 189.3,71.13 189.3,72.09 188.52,72.88 188.52,73.27 188.19,73.59 188.19,74.75 188.74,74.9 188.53,75.43 188.5,75.46 188.5,77.58 188.8,77.88 188.8,80.69 189.84,81.73 191.74,81.73
GND on BOTTOM (solid shape): 248.87,35.27 248.87,34.5 248.27,33.9 248.27,33.65 248.04,33.57 247.85,33.71 247.85,33.95 247.81,33.95 247.81,33.95 246.26,33.95 246.23,33.95 246.23,33.92 246.16,33.85 246.16,33.35 246.13,33.32 245.92,33.32 245.87,33.37 245.87,33.93 245.85,33.96 245.83,34.01 245.82,34.05 245.82,34.17 245.82,34.18 245.82,34.6 246.04,34.83 246.15,34.83 246.54,35.21 246.81,35.21 247.05,35.45 247.39,35.45 247.4,35.46 248.69,35.46
GND on BOTTOM (solid shape): 52.23,148.99 52.31,148.9 52.37,148.85 52.38,148.84 52.38,148.73 52.22,148.46 52.38,148.2 52.38,148.08 52.31,148.03 52.25,147.95 52.22,147.92 52.05,147.92 52.02,147.92 52.01,147.95 51.94,148.04 51.85,148.1 51.84,148.1 51.56,148.38 51.56,148.5 51.56,149.08 51.56,149.14 51.72,149.29 51.73,149.3 51.92,149.3
GND on BOTTOM (solid shape): 180.9,64.28 180.9,63.03 180.88,63.01 180.78,62.67 181.07,62.47 181.11,62.45 181.12,62.42 181.12,62.37 181.13,62.33 181.07,62.29 181.03,62.24 180.98,62.19 180.91,62.19 180.74,62.19 180.59,62.09 180.58,62.08 180.54,62.06 180.45,62.1 180.38,62.12 180.33,62.12 179.93,62.52 179.56,62.52 179.45,62.63 179.45,62.85 179.78,63.18 179.78,64.3 179.88,64.4 180.77,64.4
GND on BOTTOM (solid shape): 186.09,27.07 186.09,26.18 186.06,26.17 185.86,25.9 185.94,25.58 185.97,25.55 185.8,25.38 185.25,25.38 185.16,25.44 185.18,25.55 184.91,26.21 184.64,25.55 184.67,25.44 184.57,25.38 183.73,25.38 183.62,25.49 183.62,27.17 183.88,27.44 185.73,27.44
GND on BOTTOM (solid shape): 58.36,139.02 58.43,138.96 58.5,138.92 58.51,138.92 58.68,138.75 58.68,138.74 58.84,138.57 59.08,138.57 59.09,138.57 59.34,138.57 59.42,138.49 59.42,138.3 59.39,138.27 59.31,138.02 59.46,137.8 59.49,137.79 59.49,137.56 59.46,137.54 59.4,137.49 59.35,137.43 59.23,137.43 58.98,137.58 58.71,137.45 58.59,137.45 58.43,137.61 58.43,137.72 58.6,137.88 58.6,137.95 58.6,137.96 58.62,138.07 58.6,138.17 58.6,138.18 58.6,138.37 58.17,138.8 58.17,138.93 58.22,138.97 58.27,139.02
GND on BOTTOM (solid shape): 21.18,150.99 21.26,150.88 21.38,150.81 21.4,150.8 21.56,150.64 22.22,150.64 22.78,150.08 22.8,149.99 22.75,149.92 22.69,149.88 22.64,149.82 22.56,149.78 22.47,149.82 22.04,149.85 22.01,149.42 22.04,149.38 21.98,149.32 20.78,149.32 20.77,149.35 20.71,149.44 20.63,149.51 20.63,149.77 20.8,150.08 20.63,150.38 20.63,150.7 20.96,151.03 21.17,151.03
GND on BOTTOM (solid shape): outline of 82 points within 1.19,141.87 5.3,153.05
GND on BOTTOM (solid shape): 94.03,171.08 94.03,168.3 94.03,168.3 94.03,166.63 93.38,165.98 90.49,165.98 89.71,165.19 89.71,163.98 89.71,163.98 89.71,162.72 89.14,162.15 84.11,162.15 82.5,163.76 82.5,165.73 82.77,166 85.65,166 86.16,166.51 86.16,167.27 86.41,167.53 88.19,167.53 88.57,167.91 88.57,168.42 88.7,168.54 89.46,168.54 89.59,168.67 89.59,169.16 89.64,169.25 89.74,169.25 89.85,169.2 89.97,169.19 90.4,169.6 89.97,170 89.85,169.99 89.74,169.94 89.64,169.94 89.59,170.03 89.59,170.19 89.33,170.45 88.82,170.45 88.57,170.7 88.44,170.7 88.44,171.34 93.78,171.34
GND on BOTTOM (solid shape): outline of 86 points within 12.54,156.27 35.29,164.86
GND on BOTTOM (solid shape): 114.22,87.64 114.22,86.64 115.23,85.64 115.23,85.12 116.25,84.09 117.08,84.09 117.27,84.29 117.27,84.29 117.85,84.87 118.93,84.87 119.12,84.67 119.12,82.39 119.3,82.21 119.3,81.25 119.94,80.61 119.94,79.21 118.13,77.4 118.06,77.35 118.01,77.29 116,75.28 110.1,75.28 109.98,75.4 109.98,76.76 106.66,80.33 109.27,84.46 109.27,85.08 109.08,85.28 109.08,85.95 109.2,86.07 110.41,86.07 110.8,86.45 110.8,87.52 111.05,87.77 114.1,87.77
GND on BOTTOM (solid shape): 41.63,127.84 41.75,127.71 41.93,127.65 42.01,127.58 41.99,127.48 41.81,127.3 41.81,127.04 41.68,126.93 41.62,126.77 41.69,126.5 41.93,126.37 42,126.33 42.02,126.25 41.77,126.01 41.77,125.99 41.77,124.01 41.77,124.01 41.77,123.75 41.69,123.67 41.67,123.66 41.43,123.66 41.29,123.8 41.29,124.46 41.36,124.53 41.36,125.32 41.14,125.55 41.11,125.64 41.18,125.71 41.43,126.02 41.24,126.37 41.24,127.67 41.22,127.78 41.31,127.84
GND on BOTTOM (solid shape): outline of 91 points within 245.91,16.72 255.39,23.78
GND on BOTTOM (solid shape): 60.19,135.85 60.24,135.88 60.3,135.87 61.26,134.91 61.34,134.71 61.55,134.61 61.64,134.62 61.73,134.66 62.02,134.36 62.95,134.36 63.11,134.21 63.11,134.1 62.99,133.98 62.65,133.98 62.65,133.98 61.98,133.98 61.87,134.08 61.87,134.11 61.85,134.24 61.77,134.35 61.62,134.43 61.44,134.41 61.39,134.38 61.34,134.33 61.14,134.33 61.08,134.39 61,134.42 60.98,134.43 60.94,134.48 60.95,134.5 60.9,134.7 60.76,134.84 60.76,134.9 60.57,135.08 60.52,135.08 60.45,135.16 60.36,135.21 60.33,135.21 60.29,135.26 60.3,135.28 60.27,135.45 60.17,135.59 60.14,135.61 60.11,135.63 60.11,135.67 60.07,135.71 60.09,135.76 60.12,135.79
GND on BOTTOM (solid shape): outline of 119 points within 36.15,25.94 44.37,33.3
GND on BOTTOM (solid shape): 59.31,151.09 59.33,150.94 59.42,150.82 59.46,150.76 59.45,150.69 59.45,150.67 59.43,150.66 59.36,150.58 59.32,150.49 59.31,150.48 59.26,150.44 59.24,150.44 58.99,150.36 58.86,150.13 58.86,150.12 58.81,150.07 58.8,150.07 58.63,150 58.53,149.84 58.52,149.83 58.48,149.79 58.46,149.79 58.27,149.75 58.13,149.62 58.05,149.62 58,149.56 57.96,149.6 57.91,149.67 57.86,149.72 57.65,149.93 57.51,149.93 57.41,150.02 57.29,150.07 57.28,150.07 57.23,150.11 57.23,150.13 57.2,150.21 57.14,150.27 57.08,150.38 57.09,150.5 57.21,150.62 57.47,150.62 57.47,150.61 57.74,150.34 58.09,150.11 58.34,150.44 58.69,150.79 59,150.81 59.13,151.09
GND on BOTTOM (solid shape): outline of 130 points within 35.6,36.94 41.62,40.29
GND on BOTTOM (solid shape): outline of 133 points within 37.26,156.22 63.04,166
GND on BOTTOM (solid shape): 60.27,132.73 60.34,132.7 60.44,132.63 60.56,132.59 60.6,132.58 60.61,132.54 60.65,132.4 60.75,132.3 60.75,132.25 61.13,131.87 61.16,131.87 61.23,131.84 61.26,131.77 61.31,131.6 61.45,131.48 61.46,131.48 61.5,131.44 61.53,131.34 61.46,131.27 61.39,131.23 61.32,131.16 61.24,131.12 61.16,131.16 61.09,131.23 61,131.27 60.99,131.28 60.95,131.33 60.95,131.35 60.91,131.55 60.76,131.69 60.76,131.72 60.55,131.93 60.52,131.93 60.51,131.95 60.26,132.07 59.94,131.91 59.86,131.95 59.78,132.02 59.68,132.06 59.65,132.08 59.64,132.12 59.65,132.15 59.64,132.21 59.68,132.26 59.7,132.26 59.86,132.37 59.92,132.54 59.93,132.58 59.97,132.59 60.09,132.63 60.19,132.7
GND on BOTTOM (solid shape): 60.26,131.15 60.34,131.12 60.44,131.05 60.56,131.02 60.58,131.02 60.61,130.99 60.61,130.97 60.7,130.76 60.91,130.67 60.93,130.67 61.27,130.34 62.41,130.34 62.49,130.25 62.49,130.1 62.46,130.06 61.87,130.06 61.64,129.83 61.64,129.81 61.61,129.74 61.54,129.71 61.35,129.62 61.26,129.42 61.26,129.4 60.3,128.44 60.26,128.43 60.23,128.43 60.18,128.48 60.08,128.57 60.11,128.6 60.11,128.69 60.26,128.83 60.31,129.04 60.31,129.06 60.34,129.11 60.36,129.11 60.45,129.16 60.52,129.24 60.62,129.24 60.76,129.38 60.76,129.48 60.88,130.01 60.34,130.05 60.27,130.02 60.2,130.05 60.16,130.08 60.12,130.11 60.07,130.19 60.12,130.28 60.23,130.38 60.29,130.51 60.27,130.73 60.12,130.89 60.12,131.07 60.16,131.09 60.19,131.12
GND on BOTTOM (solid shape): 59.31,136.45 59.38,136.29 59.53,136.2 59.55,136.19 59.59,136.14 59.59,136.05 59.55,136 59.53,136 59.44,135.96 59.37,135.89 59.29,135.85 59.21,135.89 58.71,135.88 58.88,135.41 58.9,135.4 58.94,135.36 58.93,135.34 58.97,135.14 59.11,135 59.16,134.92 59.11,134.83 59.07,134.8 59.04,134.77 58.97,134.74 58.89,134.77 58.8,134.84 58.68,134.87 58.67,134.88 58.62,134.92 58.61,134.98 58.6,135.03 58.6,135.07 58.56,135.09 58.51,135.15 58.44,135.19 58.4,135.33 58.33,135.4 58.33,135.41 58.26,135.54 58.15,135.63 58.14,135.71 58.16,135.78 58.22,135.82 58.27,135.87 58.3,135.88 58.34,135.88 58.52,135.93 58.6,136.11 58.6,136.38 58.61,136.42 58.62,136.49 59.31,136.49
GND on BOTTOM (solid shape): 51.79,127.73 51.79,127.59 51.78,127.58 51.74,127.47 51.73,127.36 51.76,127.19 51.87,127.06 51.86,127.02 51.84,126.98 51.74,126.64 51.97,126.38 52.01,126.37 52.01,126.29 51.79,126.08 51.79,124.37 52.35,123.81 52.35,123.48 52.21,123.34 51.91,123.34 51.46,123.79 51.46,123.8 51.39,123.96 51.26,124.07 51.25,124.07 51.21,124.12 51.22,124.15 51.24,124.26 51.23,124.37 51.23,124.99 51.33,125.1 51.43,125.18 51.49,125.3 51.5,125.5 51.39,125.67 51.37,125.74 51.4,125.81 51.52,126.04 51.45,126.29 51.41,126.33 51.38,126.41 51.41,126.48 51.51,126.61 51.54,126.77 51.51,126.88 51.45,126.99 51.44,126.99 51.41,127.06 51.43,127.13 51.53,127.38 51.39,127.7 51.42,127.77 51.44,127.8 51.46,127.83 51.48,127.86 51.66,127.86
