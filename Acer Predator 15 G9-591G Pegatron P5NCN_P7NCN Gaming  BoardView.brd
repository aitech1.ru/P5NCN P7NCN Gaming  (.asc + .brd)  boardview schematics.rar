# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N140177624: length 24.6
  BOTTOM w0.102: v1(255.7,63.47) 254.45,64.72 Q6001.1 251.98,64.72 251.69,65.01 251.69,65.88 251.51,66.06 R6006.2 249.02,68.04 C6001.2 249.02,71.16 248.08,72.1 246.05,72.1 245.54,72.61 245.54,73.12 245.03,73.63 243.26,73.63 243.16,73.72 CON6002.2 CON6002.1
N140249883: length 16.3
  BOTTOM w0.102: U7000.AV6 99.1,125.88 99.49,125.49 99.49,125.03 99.79,124.73 100.76,124.73 101.16,124.33 101.16,124.16 101.36,123.96 101.53,123.96 101.84,123.64 101.84,121.11 102.44,120.51 102.44,118.73 102.74,118.43 102.74,116.4 103.07,116.07 103.07,114.42 103.21,114.28 v1(103.21,113.76) 103.18,113.72 R7449.1 C7401.1
N140414267: length 4.5
  TOP w0.102: R5806.1 v1(246.74,128.49) 248.08,127.15 U5800.11
N140503834: length 7.8
  TOP w0.102: U3300.23 221.16,94.36 218.89,92.09 T3300.1
N140505490: length 6.2
  TOP w0.089: 127.89,40.1 127.74,39.95 U3001.119
  TOP w0.102: R3098.1 132.22,40.11 v1(131.5,40.11) 131.32,40.29 129.4,40.29 129.21,40.48 128.27,40.48 127.89,40.1
N140559812: length 4.1
  TOP w0.203: v1(126.92,76.67) 126.92,76.12 R8733.3 126.12,75.31 R8735.1
N140692797: length 19.1
  TOP w0.089: 125.54,32.92 125.55,32.91
  TOP w0.102: R3094.1 127.04,30.03 126.66,30.03 125.86,30.83 125.86,32.61 125.55,32.91 ; v2(121.51,33.72) 122.56,33.72 125.12,31.17 U3001.96 ; v2(121.49,35.81) 122.66,35.81 125.54,32.92
  BOTTOM w0.102: v2(121.51,33.72) 121.49,33.75 v1(121.49,34.59) v2(121.49,35.81)
N140692856: length 8.1
  TOP w0.102: U3001.98 127.58,31.55 128.07,31.07 128.07,30.14 v1(128.38,29.82) 128.58,29.63 131.93,29.63 132.31,29.25 132.31,28.8 R3096.1
N140692863: length 5.9
  TOP w0.102: R3095.1 v1(130.02,28.92) 129.62,29.33 128.17,29.33 127.86,29.63 127.86,30.93 127.64,31.15 U3001.97
N140692954: length 8.8
  TOP w0.102: R3097.1 133.35,28.64 133.22,28.64 132.74,29.13 v1(132.74,29.28) 132.11,29.91 129.11,29.91 128.35,30.68 128.35,31.07 127.94,31.48 127.94,31.74 127.73,31.95 U3001.99
N140693429: length 18.2
  TOP w0.102: U3001.70 114.72,28.79 114.19,28.25 111.78,28.25 109.65,26.13 109.65,25.37 108.89,24.6 101.02,24.6 v1(100.76,24.35) 100.71,24.3 R3087.1
N140693431: length 15.2
  TOP w0.102: U3001.71 115.12,28.69 114.49,28.05 112.08,28.05 109.91,25.87 109.91,25.24 109.02,24.35 104.45,24.35 v1(104.06,23.97) R3088.1
N140693523: length 13.4
  TOP w0.102: R3085.1 v1(107.24,23.59) 107.75,24.1 109.14,24.1 110.16,25.11 110.16,25.75 112.14,27.73 115.44,27.73 115.75,28.04 115.75,28.41 115.52,28.64 U3001.72
N140693525: length 9
  TOP w0.102: R3086.1 v1(111.35,25.37) 111.35,26.64 112.24,27.53 115.52,27.53 115.95,27.96 115.95,28.62 115.92,28.65 U3001.73
N140693591: length 6.8
  TOP w0.102: U3001.76 117.12,28.77 117.5,28.39 117.5,28.06 116.92,27.48 116.92,26.48 117.15,26.26 R3089.1 117.43,25.72 117.58,25.57 117.58,23.64 v1(117.49,23.55)
N140693593: length 4.3
  TOP w0.102: R3090.1 117.65,26.1 117.65,26.46 v1(117.35,26.76) 117.35,27.45 117.7,27.81 117.7,28.57 117.52,28.75 U3001.77
N140693595: length 8.2
  TOP w0.102: R3091.1 117.99,22.46 118.79,23.27 v1(119.03,23.51) 118.51,24.03 118.51,26.02 117.92,26.61 U3001.78
N140788656: length 5.2
  BOTTOM w0.102: v1(222.71,37.58) 222.51,37.58 222.05,38.05 R8821.1 222.43,38.65 223.34,39.57 Q8807.3
N141163560: length 5.6
  BOTTOM w0.254: v1(13.89,74.73) 13.05,73.89 12.94,73.89 L6700.2 11.94,72.9 11.94,72.6 11.08,71.75 CON6700.21
N141163567: length 4.4
  BOTTOM w0.254: v1(12.74,70.59) 12.74,71.49 L6701.2 11.69,71.25 CON6700.20
N141512226: length 10.1
  TOP w0.076: v4(241.9,49.71) 241.99,49.79 U1201.F4
  BOTTOM w0.102: T1209.1 235.67,51.96 236.74,50.88 239.95,50.88 240.07,50.77 240.97,50.77 241.9,49.84 v4(241.9,49.71)
N141512229: length 15.9
  TOP w0.076: U1201.G4 242.49,49.75 v4(242.44,49.71)
  BOTTOM w0.102: T1210.1 230.43,51.12 231.82,52.52 235.84,52.52 236.8,51.55 237.49,51.55 237.87,51.17 239.04,51.17 239.99,52.13 241.06,52.13 241.69,51.49 241.69,50.71 242.44,49.96 v4(242.44,49.71)
N143100577: length 4.8
  BOTTOM w0.102: v1(140.07,75.57) 139.75,75.9 138.51,75.9 138.32,75.7 SR8200.2
  BOTTOM w0.254: C8206.1 137.23,75.12 U8200.3
  BOTTOM w0.457: C8206.1 SR8200.2
N143100638: length 6.9
  BOTTOM w0.102: R8203.1 141.73,68.76 141.14,68.17 140.14,68.17 v1(139.56,67.59) 139.56,68.25 140.22,68.91 140.22,69.46 140.45,69.69 140.45,70.21 140.19,70.47 139.83,70.47 139.73,70.57 U8200.11
N143101184: length 2.8
  BOTTOM w0.102: R8204.1 137.72,69.1 v1(137.86,69.24) 137.86,69.72 138.23,70.09 U8200.14
N143118416: length 4
  BOTTOM w0.203: v1(80.85,153.51) SR9400.2
  BOTTOM w0.254: 79.98,154.78 79.55,155.21 79.38,155.21 79.15,155.44 U9400.3
  BOTTOM w0.381: SR9400.2 79.93,153.99 79.98,154.04 C9403.1 79.98,154.78
N143118445: length 2.4
  BOTTOM w0.203: v1(77.11,160.44) 76.89,160.22 R9404.1 76.65,159.69 U9400.11
N143118589: length 5.4
  BOTTOM w0.102: U9400.14 78.15,159.98 78.54,160.37 79.43,160.37 79.76,160.7 R9402.1 79.76,161.36 80.29,161.89 v1(81.51,161.89)
N143129465: length 3.3
  TOP w0.102: U9600.11 83.26,175.28 C9612.1 82.75,175.43 82.09,176.09 v1(82.09,176.37)
N143236334: length 4.2
  BOTTOM w0.203: R8208.2 144.25,68.16 144.55,67.86 v1(144.55,67.53) 144.94,67.92 144.94,68.63 145.28,68.98 R8207.1 145.8,68.98 145.84,69.02 C8216.2
N143236888: length 3.1
  BOTTOM w0.102: v1(73.58,151.91) 73.15,152.34 R9408.2
  BOTTOM w0.203: R9408.2 C9416.2 72.19,153.05 R9407.1
N143246738: length 2.7
  TOP w0.102: D9500.2 126.2,61.65 125.96,61.89 R9507.1 126.59,63.21 v1(126.59,63.56)
N143287072: length 6.2
  TOP w0.102: U1101.AA1 238.31,39.05 237.9,39.46 236.83,39.46 234.99,41.3 v1(234.33,41.3) 234.08,41.55 R1161.2
N143287155: length 36.5
  TOP w0.102: U1101.F4 245.08,37.65 v4(245.39,37.96)
  IN4 w0.102: v2(242.14,54.91) 243.11,53.94 243.11,52.19 242.91,51.99 242.91,49.67 242.04,48.8 240.32,48.8 239.7,48.18 239.7,47.74 240,47.44 240,46.67 237.2,43.87 237.2,43.19 237.87,42.52 237.87,41.91 238.46,41.31 239.27,41.31 240.32,40.27 241.22,40.27 241.44,40.04 243.42,40.04 245.39,38.07 v4(245.39,37.96)
  BOTTOM w0.102: v2(242.14,54.91) 241.81,54.91 240.98,55.75 235.94,55.75 235.16,54.96 R1162.1 233.48,54.96 v1(233.45,54.93)
N144172051: length 26
  TOP w0.102: v2(59.49,40.33) 59.1,39.95 59.1,39.13 59.91,38.32 59.91,33.22 57.38,30.7 57.02,30.7 v1(56.74,30.42) 55.74,29.41 R5104.2
  IN2 w0.102: v2(53.14,39.88) 54.06,39.88 54.51,40.33 v2(59.49,40.33)
  BOTTOM w0.102: CON5103.38 54.06,43.1 53.34,43.1 53.14,42.89 v2(53.14,39.88)
N144184021: length 16.7
  TOP w0.076: U1201.H7 243.3,51.7 v4(243.51,51.91)
  BOTTOM w0.102: v1(230.81,49.15) 230.92,49.26 232.52,49.26 C1229.1 233.13,48.92 243.11,48.92 243.89,49.7 243.89,51.53 v4(243.51,51.91)
N144362774: length 6.8
  TOP w0.102: v1(116.25,55.43) 116.25,55.43 116.25,53.16 116.14,53.05 U0703.2 114.71,53.05 114.42,52.76 114.42,52.15 114.66,51.92 115.43,51.92 115.62,51.73 R0749.2
N144362810: length 4.9
  TOP w0.102: U0703.1 116.35,52.4 116.55,52.6 116.55,53.3 v1(116.88,53.64) 116.88,52.46 116.51,52.09 R0748.2
N144673370: length 25
  BOTTOM w0.102: CON5100.6 40.42,35.65 39.6,36.47 33.86,36.47 33.27,37.05 33.27,39.11 34.37,40.2 35.46,40.2 35.74,40.48 38.74,40.48 40.26,42 40.26,46.3 R5131.1 39.73,47.26 v1(39.11,47.87)
N144979028: length 39.8
  TOP w0.102: v2(239.35,100.17) 239.35,99.32 v1(239.45,99.23) 241.18,97.5 245.57,97.5 245.83,97.76 Q7201.3 ; R7218.2 235.37,121.44 Q7203.1 237.48,121.44 238.05,120.87 238.05,118.2 237.6,117.76 Q7202.1 236.62,118.22 v2(237.03,118.64)
  IN1 w0.102: v2(237.03,118.64) 237.03,118.46 235,116.43 235,110.33 235.38,109.95 236.91,109.95 239.35,107.5 v2(239.35,100.17)
N144979032: length 2.5
  TOP w0.102: v1(235.2,118.48) 235.18,118.51 R7216.2 235.24,119.54 Q7203.2
N144979034: length 2.6
  TOP w0.102: Q7202.2 235.24,115.86 R7217.2 235.18,114.72 v1(235.2,114.7)
N144979663: length 6.9
  TOP w0.508: R3162.1 v1(191.73,29.94) 191.73,29.01 194.76,25.99 D3104.1
N144979768: length 4.3
  TOP w0.508: R3161.1 189.73,26.79 v1(191.33,26.79) 191.35,26.76 192.27,26.76 D3104.2
N144980835: length 2.6
  TOP w0.279: R4628.1 247.32,101.44 v1(247.52,101.64) 247.42,101.75 U4601.10
N145218678:
  vias: v1(223.57,52.24)
N145218684: length 7.3
  BOTTOM w0.254: v1(221.87,53.48) 221.46,53.08 R3167.2 R3168.1 R3164.2 221.46,49.2 222.75,47.91 U3103.3
N145218718: length 2.6
  BOTTOM w0.102: R3166.1 224.6,45.46 v1(225.73,45.46)
  BOTTOM w0.508: U3103.1 224.65,45.66 R3166.1
N145218847: length 6.4
  BOTTOM w0.102: v1(226.16,49.5) 226.54,49.12 226.54,48.43 226.25,48.14 R3169.1
  BOTTOM w0.254: R3169.1 225.02,48.14 224.78,48.38 224.73,48.38 224.64,48.47 223.15,48.47 222.75,48.87 U3103.4
N145280710: length 2.2
  TOP w0.102: U1101.W19 239.2,30.47 v4(239.5,30.17)
  BOTTOM w0.102: v4(239.5,30.17) 238.49,29.16 T1105.1
N145280722: length 6.4
  TOP w0.102: v4(238.86,30.17) 238.55,30.49 U1101.Y19
  BOTTOM w0.102: v4(238.86,30.17) 238.79,30.17 237.29,28.67 236.57,28.67 236.57,28.67 235.64,28.67 235.63,28.67 234.91,28.67 234.39,28.15 T1106.1
N145280742: length 4.6
  TOP w0.102: T1107.1 234.77,25.75 237.39,28.36 U1101.AC23
N145280776: length 5.2
  TOP w0.102: T1108.1 235.44,26.01 237.85,28.42 U1101.AB23
N145283752: length 4.2
  TOP w0.102: U1101.A23 247.51,28.69 248.55,27.65 250.05,27.65 T1109.1
N145283762: length 2.8
  TOP w0.102: T1110.1 249.01,27.3 248.55,27.3 247.51,28.35 247.39,28.35 U1101.B23
N145283804: length 2.7
  TOP w0.102: U1101.E18 245.7,31.16 246.01,30.85 v4(246.01,30.83)
  BOTTOM w0.102: T1111.1 246.43,29.04 246.43,30.4 246.01,30.82 v4(246.01,30.83)
N145283824: length 5.4
  TOP w0.102: v4(240.17,31.47) 239.85,31.15 U1101.V18
  BOTTOM w0.102: T1112.1 239.24,27.5 239.7,27.96 239.7,29.84 240.54,30.68 240.54,31.21 240.28,31.47 v4(240.17,31.47)
N145473962: length 1.9
  TOP w0.114: T1301.1 212.4,58.64 211.91,58.15 U1301.33
N145473964: length 4.2
  TOP w0.114: U1301.34 211.41,58.44 211.89,58.92 211.89,59.57 T1302.1
N145676608: length 9.7
  TOP w0.102: U5000.2 170.35,76.24 169.91,75.79 168.75,75.79 168.25,76.29 Q5001.3 167.46,77.04 167.26,77.24 Q5001.1 163.9,77.24 v1(163.63,77.51) C5004.1
N145676610: length 7.9
  TOP w0.102: C5004.2 164.02,75.34 Q5001.2 166.57,75.34 166.81,75.59 169.06,75.59 v1(169.34,75.3) 169.63,75.59 U5000.3
N145824487: length 2.6
  BOTTOM w0.102: v1(232.63,99.11) 232.41,98.9 R5017.1 231.62,99.23 231.15,99.7 U5003.1
N146001886: length 21.9
  TOP w0.102: CON4500.16 62.75,181.86 62.44,182.16 62.44,183.07 61.05,184.46 46.62,184.46 46.36,184.19 v1(45.26,184.19) 45.19,184.12 R4527.2
N146002641:
  vias: v3(50.98,182.59)
N147122449: length 17.5
  TOP w0.102: U5103.4 163.33,19.65 160.45,19.65 159.82,20.29 159.82,24.35 161.66,26.19 161.66,27.84 160.07,29.43 C5173.1 R5139.2 159.61,30.45 v1(159.61,31.33)
N147122492: length 10.8
  TOP w0.102: U5103.1 165.71,24.1 166.17,24.55 166.17,26.51 165.17,27.51 164.12,27.51 v1(162.67,28.96) 161.51,28.96 R5134.2
N147122942: length 166.4
  TOP w0.102: C5174.1 26.85,44.49 R5137.1 36.62,43.83 40.56,39.89 40.56,37.81 37.9,35.15 v2(36.29,35.15) 32.87,35.15 30.63,32.91 v1(30.07,32.91) 28.14,32.91 26.96,34.1 U5102.4 ; v2(160.83,26) 160.73,25.9 Q5102.1
  IN4 w0.102: v2(36.29,35.15) 44.38,35.15 45.12,34.4 49.88,34.4 51.13,35.65 67.74,35.65 70.28,33.1 111.41,33.1 113.59,30.93 124.27,30.93 126.8,28.4 153.87,28.4 157.13,25.14 160.14,25.14 160.83,25.83 v2(160.83,26)
N147124273: length 18.9
  TOP w0.102: Q5102.3 155.39,26.85 R5136.2 154.99,26.45 v1(154.99,25.75) C5172.1 155.32,20.59 156.39,19.52 159.06,19.52 159.31,19.78 159.31,23.9 158.8,24.41 Q5101.1
N147446396: length 5
  TOP w0.254: Q4601.1 256.15,91.3 v1(255.88,91.03) 256.72,90.19 R4630.1 R4629.2
N147836713: length 3.7
  BOTTOM w0.102: D4504.1 57.07,180.94 56.79,180.66 55.91,180.66 v1(55.5,181.07) 55.42,180.99 R4591.2
N147836837: length 7.4
  BOTTOM w0.102: U4502.5 57.33,178.02 57.07,178.27 D4504.2 57.07,180.18 57.58,180.69 57.58,182.42 57.4,182.59 C4544.1 56.44,183.15 v1(56.39,183.1)
N148386775: length 7.3
  TOP w0.102: U3600.4 23.01,68.51 v2(23.01,68.51)
  BOTTOM w0.102: v1(18.42,69.84) 19,70.43 19.81,70.43 19.96,70.27 D3601.2 19.96,68.83 20.17,68.62 R3632.2 22.9,68.62 v2(23.01,68.51)
N1484083071: length 3.6
  TOP w0.102: v1(173.56,78.45) 174.46,79.35 SR8900.2 175.17,79.11 D8900.2

## Copper pours and planes (outline as drawn)
1.0VSUS_BST on BOTTOM (solid shape): 141.78,72.02 141.78,70.89 140.71,70.89 140.13,71.47 139.82,71.47 139.57,71.72 139.57,71.97 139.62,72.02 140.77,72.02 141.13,72.38 141.42,72.38
1.0VSUS_BST_R on BOTTOM (solid shape): 143.09,69.95 143.09,69.36 143.01,69.27 141.36,69.27 141.11,69.02 141.11,68.71 140.97,68.57 140.65,68.57 140.5,68.72 140.5,69.2 140.89,69.6 140.89,70.02 140.92,70.05 143,70.05
1.0VSUS_LX on BOTTOM (solid shape): 144.87,74.82 145.75,74.82 146.22,74.36 146.22,70.29 145.67,69.75 143.57,69.75 143.46,69.87 143.46,70.66 143.2,70.91 142.16,70.91 142.04,71.04 142.04,71.59 141.91,71.72 141.91,72.07 141.48,72.51 141.07,72.51 141,72.43 140.94,72.39 140.89,72.33 140.75,72.18 138.34,72.18 138.28,72.25 138.28,72.47 138.42,72.61 138.99,72.61 139.03,72.65 139.03,73.19 139.16,73.32 139.92,73.32 140.45,73.85 141.26,73.85 141.58,74.17 141.58,74.83 144.86,74.83
1.0VSUS_RC on BOTTOM (solid shape): 142.84,77.35 142.84,75.99 142.77,75.91 140.64,75.91 140.51,76.04 140.51,77.23 140.65,77.36 141.91,77.36 142.24,77.68 142.51,77.68
1.05V_BST on TOP (solid shape): 84.46,175.48 84.46,173.86 84.18,173.58 83.57,173.58 83.57,173.58 83.57,174.12 83.7,174.26 83.7,175.22 84.08,175.6 84.34,175.6
1.05V_BST_R on TOP (solid shape): 86.46,175.9 86.46,174.73 85.65,173.93 85.23,173.93 85.01,174.14 85.01,175.61 85.32,175.92 86.44,175.92
1.05V_LX on TOP (solid shape): 88.8,175.62 88.8,175.21 88.69,175.1 88.32,175.1 88.09,174.87 88.09,170.99 87.94,170.83 86.87,170.83 86.41,171.29 84.29,171.29 84,171.58 82.7,171.58 82.52,171.75 82.52,172.89 82.71,173.07 85.17,173.07 86.69,174.59 86.69,175.28 87.18,175.78 88.64,175.78
1.05V_RC on TOP (solid shape): 87.1,170.23 87.23,170.23 87.34,170.13 87.34,169.77 87.2,169.64 86.83,169.64 86.7,169.73 86.54,169.77 85.32,169.77 85.22,169.87 85.22,170.57 86.76,170.57
1.5VS_IN on TOP (solid shape): 174.85,28.08 174.85,26.31 174.8,26.26 173.84,26.26 173.51,26.58 172.9,26.58 172.85,26.63 172.85,26.92 173.66,26.92 174.09,27.35 174.09,28.03 174.3,28.23 174.7,28.23
1.5VS_VDD on TOP (solid shape): 174.54,25.79 174.54,25.29 174.87,24.96 175.39,24.96 175.41,24.94 175.41,24.5 175.31,24.4 173.86,24.4 173.84,24.43 173.84,25.06 173.81,25.09 173.81,25.42 173.69,25.54 172.87,25.54 172.87,25.77 172.9,25.8 173.61,25.8 173.76,25.95 174.37,25.95
3V_BST on TOP (solid shape): 217.5,74.2 217.5,74.16 217.4,74.06 216.62,74.06 216.19,73.63 215.39,73.63 214.94,73.17 214.94,72.94 214.83,72.84 213.97,72.84 213.94,72.86 213.94,73.68 214.02,73.75 214.07,73.75 214.58,74.26 217.43,74.26
3V_BST_R on TOP (solid shape): 213.08,72.83 212.21,72.83 211.76,73.28 211.76,74.76 212.31,75.31 213.08,75.31
3V_HG on TOP (solid shape): 217.57,73.86 217.57,73.65 217.56,73.64 216.96,73.64 216.95,73.63 216.95,73.53 216.21,72.79 215.32,72.79 215.22,72.89 215.22,73.22 215.47,73.47 216.24,73.47 216.61,73.84 216.64,73.88 217.55,73.88
3V_HG on BOTTOM (solid shape): 216.36,73.17 216.36,72.41 215.09,71.14 214.33,71.14 214.33,72.31 215.4,73.37 216.15,73.37
3V_HG on BOTTOM (solid shape): 212.64,65.42 212.58,65.11 212.71,64.82 212.71,64.47 212.42,64.18 211.35,64.18 211.25,64.28 211.25,65.29 211.38,65.42
3V_LG on TOP (solid shape): 206.43,65.83 206.43,65.06 205.73,64.36 204.92,64.36 204.79,64.49 204.79,65.47 205.23,65.91 206.35,65.91
3V_LG on TOP (solid shape): 217.92,73.51 217.92,72.76 216.99,71.83 216.8,71.65 215.6,71.65 215.49,71.75 215.49,72.11 215.81,72.42 216.24,72.42 217.2,73.39 217.56,73.39 217.69,73.52 217.91,73.52
3V_LG on BOTTOM (solid shape): 206.3,65.17 206.3,64.28 206.17,64.15 205.03,64.15 204.78,64.4 204.78,65.29 204.78,65.39 204.87,65.48 205.98,65.48
3V_LX on TOP (solid shape): 216.72,74.67 217.51,74.67 217.53,74.64 217.53,74.5 217.51,74.48 216.86,74.48 216.78,74.39 214.12,74.39 214,74.51 214,75.22 214.06,75.28 216.1,75.28
3V_LX on BOTTOM (solid shape): 214,75.43 216.33,75.43 216.56,75.2 216.56,74.72 216.15,74.31 214.4,74.31 213.16,73.07 213.16,67.67 211.58,66.09 211.29,65.8 210.36,65.8 209.35,64.78 209.35,60.98 209.04,60.67 207.11,60.67 206.81,60.97 206.81,65.55 206.59,65.76 204.61,65.76 204.39,65.55 204.39,64.66 204.27,64.53 203.51,64.53 203.38,64.66 203.38,66.56 203.74,66.92 205.87,69.05 205.87,76.24 206.28,76.66 212.77,76.66
3V_RC on BOTTOM (solid shape): 203,65.37 203,64.15 203.12,64.02 203.12,63.77 202.87,63.51 202.49,63.51 202.24,63.77 202.24,65.37 202.36,65.5 202.87,65.5
5V_BST on TOP (solid shape): 221.72,73.95 221.95,73.95 222.26,73.64 222.26,72.85 222.14,72.74 221.85,72.74 221.35,73.23 221.35,73.44 220.73,74.06 220.07,74.06 220.07,74.07 219.83,74.07 219.81,74.09 219.81,74.22 219.86,74.27 221.4,74.27
5V_BST_R on TOP (solid shape): 224.54,74.79 224.54,73.29 223.95,72.71 223.32,72.71 223.22,72.81 223.22,75.17 223.36,75.31 224.02,75.31
5V_HG on TOP (solid shape): 220.8,73.53 220.8,72.94 221.34,72.4 221.34,72.1 221.23,72 220.8,72 220.3,72.5 220.3,73.26 219.89,73.67 219.77,73.67 219.77,73.85 219.78,73.86 220.47,73.86
5V_HG on BOTTOM (solid shape): 225.23,62.06 225.35,61.94 225.35,61.54 225.22,61.41 223.44,61.41 223.44,61.99 224.1,61.99 224.18,62.07 225.23,62.07
5V_HG on IN1 (solid shape): 221.89,73.53 221.89,72.69 221.74,72.53 220.42,72.53 220.29,72.66 220.29,73.45 220.55,73.7 221.72,73.7
5V_HG on IN1 (solid shape): 224.74,62.55 225.07,62.55 225.32,62.3 225.32,61.54 225.22,61.43 224.36,61.43 224.09,61.7 224.09,61.8 223.27,62.63 223.27,63.21 223.34,63.29 224,63.29
5V_LG on BOTTOM (solid shape): 224.04,68.74 224.04,67.03 223.95,66.94 223.29,66.94 223.19,67.05 223.19,67.86 223.04,68.01 223.04,68.88 223.14,68.98 223.8,68.98
5V_LG on IN2 (solid shape): 220.17,73.25 220.17,72.05 223.22,69 223.44,69 223.6,68.85 223.6,67.99 223.42,67.81 223.11,67.81 218.94,71.99 218.94,73.21 219.2,73.47 219.94,73.47
5V_LX on TOP (solid shape): 222.39,76 222.39,74.41 222.23,74.25 221.64,74.25 221.43,74.46 219.92,74.46 219.87,74.51 219.87,74.62 219.91,74.66 220.75,74.66 221.4,75.31 221.4,75.89 221.87,76.36 222.03,76.36
5V_LX on BOTTOM (solid shape): 223.19,75.38 223.19,74.74 222.98,74.52 222.67,74.52 222.65,74.54 222.28,74.54 221.72,75.1 221.72,76.17 221.87,76.33 222.24,76.33
5V_LX on BOTTOM (solid shape): outline of 230 points within 219.81,62.63 237.92,71.07
5V_RC on BOTTOM (solid shape): 223.06,70.12 222.94,69.99 222.56,69.99 222.45,70.1 220.88,70.1 220.8,70.17 220.8,70.55 221,70.75 223.06,70.75
+0.6VO on TOP (solid shape): 133.47,61.2 133.47,60.94 132.23,59.71 132.23,59.32 132,59.1 132,55.15 131.99,55.14 131.72,55.14 131.02,54.44 129.98,54.44 129.16,55.26 129.16,59 129.36,59.2 130.86,59.2 130.99,59.32 130.99,59.96 131.4,60.37 132.64,61.28 133.39,61.28
+1.0VO on TOP (solid shape): outline of 269 points within 149.62,60.87 157.92,72.29
+1.0VO on BOTTOM (solid shape): 142.97,63.88 142.97,62.92 142.92,62.87 142.45,62.87 142.4,62.92 142.4,63.51 142.1,63.81 142.1,64.21 142.18,64.28 142.22,64.31 142.26,64.33 142.52,64.33
+1.0VO on BOTTOM (solid shape): 150.32,73.81 150.32,73.47 150.6,73.19 155.21,73.19 155.34,73.06 155.34,70.48 154.64,69.77 150.88,69.77 150.32,69.21 150.32,67.94 150.29,67.91 150.29,65.4 147.77,62.87 146.57,62.87 146.56,62.87 144.56,62.87 144.39,63.03 144.39,63.52 144.4,63.52 144.4,63.85 144.78,64.23 145.36,64.23 146.5,65.37 146.92,65.37 146.97,65.42 147.12,65.57 147.17,65.78 147.17,65.8 147.88,66.51 147.88,69.12 147.5,69.5 147.13,69.5 146.88,69.76 146.88,74.1 147.06,74.28 149.85,74.28
+1.0VS on TOP (solid shape): 56.32,145.37 56.32,145.11 56.06,144.85 56.06,143.14 55.99,143.07 55.47,143.07 55.4,143.14 55.4,144.82 55.49,144.92 55.73,145.02 55.83,145.26 55.98,145.4 56.29,145.4
+1.0VS on BOTTOM (solid shape): 145.52,61.44 146.18,61.44 146.5,61.12 146.5,59.23 146.22,58.94 145.57,58.94 145.33,59.18 145.33,59.77 145.53,60.22 145.12,60.49 145.01,60.61 144.55,60.61 144.38,60.78 144.38,61.53 144.4,61.56 145.41,61.56
+1.0VSUS on TOP (solid shape): 161.96,67.26 161.96,66.4 161.93,66.36 160.96,66.36 160.73,66.59 160.73,67.58 160.83,67.68 161.54,67.68
+1.0VSUS on TOP (solid shape): 173.56,54.65 173.56,54 173.45,53.89 172.35,53.89 172.19,54.04 172.19,54.54 172.32,54.68 173.14,54.68 173.23,54.76 173.45,54.76
+1.0VSUS on TOP (solid shape): outline of 1282 points within 147.83,46.55 168.28,63.75
+1.0VSUS on BOTTOM (solid shape): 154.23,43.43 154.23,42.92 154.1,42.79 152.58,42.79 152.58,43.3 152.81,43.53 154.13,43.53
+1.0VSUS on BOTTOM (solid shape): 156.57,47.01 156.57,45.94 155.83,45.2 155.63,45.2 155.5,45.33 155.5,45.97 155.91,46.37 155.91,46.91 156.08,47.08 156.49,47.08
+1.0VSUS on BOTTOM (solid shape): 165.49,55.76 165.59,55.75 165.68,55.76 165.69,55.77 165.94,55.77 166.04,55.66 166.04,55.02 166.02,54.91 166.04,54.8 166.04,54.78 166.1,54.71 166.19,54.62 166.52,54.62 166.57,54.68 166.57,54.78 166.6,54.8 166.6,55.59 167.18,55.59 167.2,55.58 167.2,54.09 167.67,53.62 167.67,53.14 167.98,52.83 167.98,51.13 167.98,51.06 168.45,50.59 168.45,49.39 168.2,49.14 167.84,49.14 167.79,49.19 167.79,49.82 167.36,50.25 167.36,52.44 167.06,52.74 167.06,52.75 167,52.82 166.93,52.88 166.92,52.88 166.65,53.15 166.65,53.89 166.52,54.02 165.66,54.02 165.35,54.32 165.35,55.03 165.42,55.09 165.35,55.16 165.35,55.72 165.4,55.77 165.48,55.77
+1.0VSUS on IN2 (solid shape): 149.9,63.59 150.55,63.59 151.25,62.89 151.25,62.32 151.21,62.32 149.56,60.67 148.9,60.67 148.88,60.69 148.17,60.69 147.93,60.93 147.93,62.03 148.51,62.6 148.51,62.71 149.4,63.61 149.88,63.61
+1.0VSUS on IN2 (solid shape): outline of 4440 points within 151.35,48.58 174.4,62.37
+1.0VSUS on IN3 (solid shape): outline of 620 points within 147.8,49.75 161.83,65.75
+1.0VSUS on IN4 (solid shape): outline of 375 points within 165.44,49.06 173.53,55.72
+1.2VO_DDR on TOP (solid shape): 128.51,63.25 128.51,62.41 128.32,62.22 128.32,61.38 127.28,61.38 126.97,61.69 126.97,62.95 127.57,63.55 128.22,63.55
+1.2VO_DDR on TOP (solid shape): 115.78,71.48 116.63,70.63 117.55,69.7 117.55,69.18 117.45,69.08 116.64,69.08 116.15,68.6 115.04,68.6 114.91,68.47 109.3,68.47 109.02,68.75 109.02,73.29 109.14,73.42 115.78,73.42
+1.2VO_DDR on BOTTOM (solid shape): 115.02,74.24 115.02,68.67 114.71,68.36 110.78,68.36 109.37,69.77 109.37,74.39 110.01,75.02 114.24,75.02
+1.2VO_DDR on IN1 (solid shape): 115.74,71.76 115.74,68.64 115.57,68.47 111.08,68.47 110.9,68.65 110.9,72.33 111.25,72.69 114.81,72.69
+1.2VO_DDR on IN2 (solid shape): 117.37,72.51 117.37,69.08 116.66,68.37 111.81,68.37 111.53,68.65 111.53,72.97 111.73,73.17 116.71,73.17
+1.2VO_DDR on IN4 (solid shape): 115.43,72.19 115.43,68.76 115.04,68.37 112.05,68.37 111.69,68.74 111.69,72.48 111.89,72.69 114.93,72.69
+1.5VO on TOP (solid shape): 171.7,27.98 171.7,26.79 171.53,26.61 170.49,26.61 170.49,26.65 169.72,26.65 169.72,26.61 168.99,26.61 168.71,26.89 168.07,26.89 168.07,27.64 167.95,27.64 167.95,28.31 171.37,28.31
+1.05VO_VGA on TOP (solid shape): 92.38,176.24 92.38,175.61 92,175.23 92,171.92 92.51,171.42 93.02,171.42 93.65,170.78 93.65,169.13 92.89,169.13 92.76,169 90.91,169 90.23,169.68 89.17,169.68 88.97,169.89 88.97,174.85 89.01,174.88 89.83,174.88 90.55,175.61 91.36,175.61 91.62,175.86 91.62,176.24 91.75,176.37 92.25,176.37
+1.5VS on TOP (solid shape): 164.7,30.32 165.61,30.32 165.99,30.7 166.42,30.7 166.78,30.34 166.78,29.33 167,29.11 167,28.57 167.17,28.4 167.58,28.4 167.69,28.29 167.69,26.89 167.02,26.89 166.68,27.24 166.68,28.32 165.51,29.48 163.19,29.48 163.01,29.67 163.01,30.18 162.74,30.45 162.74,30.95 162.77,30.98 163.09,30.98 163.12,31.02 164,31.02
+1.35VO_VGA on TOP (solid shape): 160.19,95.23 160.97,95.23 160.98,95.22 161.28,95.02 161.59,94.83 162,94.64 162.24,94.54 162.35,94.48 162.46,94.45 162.55,94.42 164.03,93.81 164.14,93.57 164.14,89.68 156.21,89.68 154.86,91.03 154.86,94.71 155.12,94.71 156.13,95.72 159.69,95.72
+1.35VO_VGA on BOTTOM (solid shape): 161.1,94.94 162.19,94.37 163.36,93.82 165.51,93.82 166.17,93.17 166.17,88.49 166.42,88.23 167.69,88.23 167.95,87.98 167.95,85.56 167.82,85.44 161.16,85.44 160.91,85.69 160.91,86.39 160.96,86.58 160.91,86.77 160.91,87.35 160.3,87.96 159.67,87.96 159.55,88.07 159.41,88.34 159.15,88.48 158.73,88.89 158.68,88.96 158.61,89.02 158.41,89.22 156.93,89.22 155.37,90.77 154.99,90.77 154.86,90.9 154.86,94.71 155.12,94.71 155.12,95.34 156.26,96.49 159.18,96.49
+1V_PRIM_W12MIL on TOP (solid shape): outline of 1769 points within 154.01,49.44 174.48,58.01
+1V_PRIM_W12MIL on BOTTOM (solid shape): 174.04,53.61 174.04,52.94 174.21,52.77 174.48,52.77 174.67,52.58 174.67,51.86 174.54,51.73 174.21,51.73 174.04,51.56 174.04,51.2 173.91,51.07 173.41,51.07 173.2,51.27 173.18,51.32 173.15,51.36 173.15,51.78 173.22,51.96 173.15,52.14 173.15,52.55 173.22,52.73 173.15,52.91 173.15,53.33 173.17,53.36 173.19,53.4 173.53,53.74 173.91,53.74
+1V_PRIM_W12MIL on BOTTOM (solid shape): 171.55,52.13 171.55,51.74 171.28,51.47 171.23,51.45 171.16,51.39 171.1,51.29 171.08,51.22 171.08,51.13 171.11,51.06 171.17,50.97 171.26,50.9 171.27,50.9 171.58,50.59 171.58,50.27 170.79,49.48 169.82,49.48 169.75,49.56 169.75,49.57 169.56,49.76 169.3,50.03 169.3,50.09 169.32,50.12 169.32,50.19 169.32,50.25 169.33,50.26 169.37,50.41 169.33,50.56 169.32,50.57 169.32,50.65 169.27,50.71 168.89,51.08 168.89,52 169.02,52.12 169.09,52.12 169.13,52.07 169.21,52.01 169.51,51.96 169.76,52.12 169.87,52.12 169.96,52.03 169.96,51.75 169.67,51.47 169.67,51.44 169.65,51.42 169.62,51.39 169.59,51.36 169.57,51.32 169.55,51.28 169.53,51.19 169.55,51.09 169.55,51.06 169.62,50.97 169.72,50.89 169.75,50.88 169.98,50.88 170.02,50.94 170.07,51 170.13,51.03 170.34,51.03 170.4,51 170.44,50.94 170.48,50.88 170.7,50.88 170.75,50.89 170.8,50.96 170.82,50.96 170.85,50.99 170.88,51.03 170.92,51.19 170.87,51.34 170.83,51.4 170.76,51.45 170.71,51.47 170.49,51.69 170.49,52.05 170.69,52.25 170.69,52.38 170.89,52.58 171.1,52.58
+1V_PRIM_W12MIL on IN1 (solid shape): outline of 3334 points within 153.62,45.33 173.53,57.42
+1V_PRIM_W12MIL on IN3 (solid shape): outline of 3417 points within 153.6,46.02 173.41,59.02
+2.5VO on TOP (solid shape): 111.94,64.56 112.09,64.4 113.69,64.4 114.17,63.92 114.17,60.65 113.56,60.04 109.6,60.04 109.59,60.05 109.59,62.18 109.46,62.18 109.46,64.28 109.27,64.28 108.7,64.85 108.7,65.1 108.89,65.29 111.94,65.29
+2.5VO on BOTTOM (solid shape): 112.84,66.3 113.3,66.3 113.44,66.16 113.44,59.23 113.34,59.12 109.83,59.12 109.75,59.2 109.75,60.57 109.3,61.03 109.3,62.86 109.29,62.87 109.29,63.16 107.34,65.11 107.34,66.16 107.49,66.31 112.83,66.31
+3V on BOTTOM (solid shape): 216,88.53 216,86.73 216.13,86.6 216.46,86.6 216.54,86.53 216.54,86.04 216.46,85.97 215.44,85.97 214.76,86.65 214.76,86.76 214.76,86.76 214.78,86.89 214.76,87.01 214.76,87.02 214.76,87.39 214.49,87.66 214.49,87.66 214.49,88.58 214.64,88.74 215.8,88.74
+3V3_AON on TOP (solid shape): 195.89,82.01 196.52,82.01 196.77,81.75 196.77,79.98 196.39,79.6 195.12,79.6 193.98,80.74 193.98,82.39 194.11,82.52 195.38,82.52
+3V3_AON on TOP (solid shape): 98.35,146.19 98.6,146.19 98.73,146.06 98.73,145.43 98.6,145.3 97.97,145.3 97.71,145.56 97.71,146.19 97.97,146.45 98.1,146.45
+3V3_AON on TOP (solid shape): 93.67,134.28 93.67,133.73 93.42,133.48 90.18,133.48 89.93,133.23 89.17,133.23 88.81,132.87 88.81,132.7 88.8,132.6 88.81,132.51 88.81,132.41 88.66,132.27 88.35,132.27 88.27,132.34 88.27,133.38 88.93,134.04 89.67,134.04 90.12,134.49 93.46,134.49
+3V3_MAIN on TOP (solid shape): 155.87,76.16 155.87,74.53 155.67,74.33 155.07,74.33 154.7,74.69 154.7,75.63 154.33,76.01 154.33,76.66 154.62,76.95 155.08,76.95
+3V3_MAIN on TOP (solid shape): 151.18,49.88 151.18,47.74 151.08,47.64 150.37,47.64 150.19,47.82 150.19,48.38 149.83,48.73 149.4,48.73 149.28,48.86 149.28,49.37 149.91,50 151.05,50
+3V3_MAIN on TOP (solid shape): 99.75,134.48 99.75,129.71 99.49,129.46 99.26,129.46 98.28,128.47 98.28,125.95 98.21,125.88 97.63,125.88 97.51,126 97.51,128.82 98.48,129.79 98.48,132.15 98.15,132.48 96.95,132.48 96.83,132.6 96.83,133.36 96.95,133.49 97.97,133.49 98.1,133.62 98.13,133.66 98.15,133.7 98.18,133.75 98.19,133.8 98.2,133.86 98.2,133.91 98.19,133.93 98.67,133.93 98.67,133.87 98.67,133.82 98.69,133.77 98.71,133.72 98.74,133.68 98.78,133.64 98.82,133.61 98.87,133.58 98.92,133.56 98.97,133.55 99.02,133.54 99.08,133.55 99.13,133.56 99.18,133.58 99.22,133.61 99.27,133.64 99.3,133.68 99.33,133.72 99.35,133.77 99.37,133.82 99.38,133.87 99.38,133.93 99.37,133.98 99.35,134.03 99.33,134.08 99.3,134.12 99.27,134.16 99.22,134.2 99.18,134.22 99.13,134.24 99.08,134.25 99.02,134.26 98.97,134.25 98.92,134.24 98.87,134.22 98.82,134.2 98.78,134.16 98.74,134.12 98.71,134.08 98.69,134.03 98.67,133.98 98.67,133.93 98.19,133.93 98.19,133.96 98.17,134.01 98.14,134.06 98.11,134.1 98.1,134.12 98.1,134.73 99.5,134.73
+3V3_MAIN on BOTTOM (solid shape): 99.62,133.24 99.62,131.97 100.64,130.95 106.48,130.95 106.6,130.82 106.6,129.97 106.37,129.63 106.6,129.3 106.6,129.1 106.57,129.06 106.49,129 106.42,128.92 106.37,128.92 106.35,128.92 106.3,128.91 106.25,128.92 106.23,128.92 106.17,128.92 106.02,129.07 105.97,129.07 105.97,129.12 105.28,129.81 105.25,129.81 105.24,129.82 105.24,129.83 105.02,130.05 104.71,130.42 104.38,130.08 104.27,129.96 104.27,129.87 104.26,129.87 103.05,129.87 102.61,130.3 102.55,130.3 102.26,130.42 102.01,130.23 101.68,129.9 101.68,129.81 101.08,129.81 100.99,129.86 100.99,129.96 101.01,130.01 101.02,130.07 100.89,130.36 100.58,130.4 100.43,130.27 100.38,130.07 100.39,130.05 100.34,130 100.31,130.01 100.25,130.04 100.22,130.1 99.98,130.41 99.62,130.25 99.55,130.2 99.46,130.22 98.73,130.95 98.73,131.28 98.82,131.5 98.73,131.72 98.73,132.08 98.7,132.55 98.24,132.48 97.77,132.48 97.5,132.62 97.24,132.48 96.97,132.48 96.92,132.54 96.85,132.58 96.83,132.6 96.83,132.81 96.85,132.82 97,132.99 97,133.22 97,133.32 97.09,133.36 99.49,133.36
+3V3_MAIN on IN2 (solid shape): 84.54,126.45 84.54,125.45 84.29,125.19 83.39,125.19 83.15,125.43 83.15,125.97 83.98,126.79 84.21,126.79
+3V3_MAIN on IN3 (solid shape): outline of 89 points within 173.69,89.85 177.27,92.07
+3V3_MAIN on IN4 (solid shape): 156.13,76.8 156.13,76.29 155.75,75.91 154.36,75.91 154.1,76.17 154.1,76.93 154.23,77.06 155.88,77.06
+3V_WLAN on TOP (solid shape): 237.21,93.49 239.62,93.49 239.88,93.74 241.22,93.74 242.18,92.79 243.99,92.79 244.06,92.76 244.09,92.69 244.36,92.32 244.81,92.43 244.96,92.36 245.12,92.35 245.15,92.36 245.42,92.09 245.95,92.09 246.3,91.89 246.66,92.09 247.45,92.09 247.96,91.58 253.8,91.58 254.31,91.07 254.31,90.82 254.05,90.57 253.67,90.57 253.29,90.18 251.13,90.18 250.62,89.68 245.8,89.68 245.29,90.18 241.35,90.18 240.97,90.57 240.22,90.57 239.32,91.47 239.32,91.65 238.94,92.03 236.46,92.03 235.78,92.71 235.78,93.63 235.89,93.74 236.96,93.74
+3V_WLAN on BOTTOM (solid shape): 254.36,91.07 254.36,90.79 254.12,90.56 253.96,90.26 253.21,90.26 253.14,90.34 253.14,91.1 253.24,91.2 254.23,91.2
+3VA on TOP (solid shape): 222.38,83.76 222.38,83.08 221.95,82.64 220.39,82.64 220.35,82.66 220.3,82.67 220.24,82.67 220.19,82.67 220.13,82.66 220.1,82.64 219.66,82.64 219.41,82.39 216.69,82.39 216.21,82.87 216.21,83.38 219.02,83.38 219.03,83.32 219.04,83.27 219.06,83.22 219.09,83.17 219.12,83.12 219.16,83.08 219.21,83.05 219.26,83.03 219.31,83.01 219.36,83 219.42,83 219.47,83 219.53,83.02 219.58,83.04 219.63,83.07 219.67,83.1 219.71,83.14 219.74,83.19 219.76,83.24 219.78,83.29 219.79,83.35 219.79,83.41 219.78,83.46 219.76,83.51 219.74,83.56 219.71,83.61 219.67,83.65 219.63,83.69 219.58,83.72 219.53,83.74 219.47,83.75 219.42,83.76 219.36,83.76 219.31,83.75 219.26,83.73 219.21,83.7 219.16,83.67 219.12,83.63 219.09,83.59 219.06,83.54 219.04,83.49 219.03,83.43 219.02,83.38 216.21,83.38 216.21,83.89 216.51,84.19 221.95,84.19
+3VO on TOP (solid shape): 156.24,34.79 156.24,33.98 156.17,33.91 154.7,33.91 154.1,34.51 154.1,34.87 154.15,34.92 156.11,34.92
+3VO on TOP (solid shape): 175.65,29.72 175.65,28.91 176.15,28.41 176.15,27.52 176.02,27.4 175.34,27.4 175.29,27.45 175.29,28.19 174.68,28.8 174.68,29.71 174.8,29.84 175.53,29.84
+3VO on TOP (solid shape): outline of 245 points within 192.71,67.55 202.03,80.74
+3VO on BOTTOM (solid shape): 215.73,77.22 215.82,77.09 215.95,77.01 216,76.96 216,76.24 215.74,75.97 215.16,75.97 214.86,76.28 214.86,77.02 215.05,77.22
+3VO on BOTTOM (solid shape): 220.26,88.5 220.26,88.08 219.72,87.54 219.72,86.41 219.28,85.97 218.03,85.97 217.91,86.1 217.91,86.37 218.41,86.88 218.41,87.37 218.08,87.7 218.08,88.41 218.36,88.69 220.07,88.69
+3VO on BOTTOM (solid shape): 197.36,81.45 197.36,80.76 197.56,80.56 204.47,80.56 205.54,79.49 205.54,78.4 205.69,78.25 213.08,78.25 213.21,78.12 213.21,77.06 213.03,76.88 205.54,76.88 205.54,69.21 202.36,66.03 198.86,66.03 198.3,66.59 198.3,69.03 197.36,69.97 197.36,71.1 196.47,71.99 194.23,71.99 194.23,71.85 193.85,71.47 193.47,71.47 193.38,71.56 193.38,71.98 193.37,71.99 193.15,71.99 192.98,72.16 192.98,72.91 193.22,73.14 193.22,80.96 193.83,81.57 197.24,81.57
+3VO on IN3 (solid shape): 157.53,34.54 157.53,33.01 157.28,32.76 154.94,32.76 154.43,33.27 154.43,34.46 154.86,34.89 157.18,34.89
+3VO on IN3 (solid shape): outline of 232 points within 210.37,75.51 220.4,88.46
+3VS on TOP (solid shape): 254.31,34.59 253.92,34.21 252.51,34.21 252.29,34.43 252.29,35.39 252.88,35.98 254.31,35.98
+3VS on TOP (solid shape): 258.5,93.95 258.5,92.17 258.37,92.04 257.1,92.04 256.85,92.3 256.85,93.95 256.97,94.07 258.37,94.07
+3VS on TOP (solid shape): 6.78,108.55 6.78,107.54 6.66,107.41 6.4,107.41 5.89,107.92 5.39,107.92 5.26,108.04 5.26,108.42 5.51,108.68 6.66,108.68
+3VS on TOP (solid shape): 59.61,173.37 59.61,172.99 59.23,172.61 57.58,172.61 57.46,172.73 57.46,173.5 57.58,173.62 59.36,173.62
+3VS on TOP (solid shape): 252.53,93.82 252.53,92.8 252.27,92.55 250.88,92.55 250.75,92.68 250.75,93.82 251,94.07 252.27,94.07
+3VS on TOP (solid shape): 211.18,22.6 211.18,20.79 210.52,20.13 208,20.13 207.39,20.74 207.39,22.56 207.95,23.12 210.66,23.12
+3VS on TOP (solid shape): 236.4,113.41 236.4,110.96 236.27,110.84 235.45,110.84 234.32,111.96 234.32,113.63 234.42,113.73 236.08,113.73
+3VS on TOP (solid shape): 244.64,95.23 244.64,93.22 244.53,93.11 244.39,93.09 244.26,93.03 242.24,93.03 241.28,93.99 240.1,93.99 239.88,94.2 239.88,95.31 240,95.43 241.22,95.43 241.51,95.3 241.8,95.43 241.99,95.62 244.25,95.62
+3VS on TOP (solid shape): 177.57,33.45 177.59,33.43 177.59,33.05 177.58,33.04 177.3,33.04 177.19,32.93 177.16,32.89 177.11,32.83 177.11,32.82 177.08,32.65 177.11,32.49 177.11,32.25 177,32.14 176.68,32.14 176.61,32.21 176.61,32.76 176.7,32.85 176.79,32.85 176.84,32.9 176.84,32.98 176.89,33.04 176.89,33.42 176.92,33.45 177.55,33.45
+3VS on TOP (solid shape): 218.51,60.81 218.51,60.66 218.5,60.63 218.49,60.59 218.49,60.59 218.49,60.54 218.58,60.3 218.79,60.17 218.82,60.17 218.85,60.05 218.83,60.03 218.75,59.71 218.95,59.45 218.97,59.43 218.97,58.79 218.71,58.53 218.42,58.53 218.28,58.67 218.28,59.26 218.26,59.28 217.98,59.28 217.84,59.41 217.37,59.41 217.36,59.4 217.24,59.4 216.77,59.88 216.77,60.93 216.98,61.14 218.18,61.14
+3VS on TOP (solid shape): 96.52,50.94 96.52,50.92 96.72,50.72 96.72,42.56 96.39,42.23 94.92,42.23 94.18,42.97 94.18,47.03 94.47,47.31 95.1,47.6 94.47,47.89 91.97,50.38 91.97,53.1 92.13,53.26 94.21,53.26
+3VS on TOP (solid shape): outline of 86 points within 9.2,63.39 16.69,67.66
+3VS on TOP (solid shape): 10.43,143.04 10.46,142.97 10.43,142.9 10.34,142.7 10.38,142.47 10.38,140.96 10.3,140.7 10.42,140.46 10.43,140.42 10.42,140.39 10.31,140.13 10.4,139.87 10.43,139.81 10.4,139.74 10.31,139.47 10.43,139.21 10.44,139.2 10.45,139.17 10.44,139.13 10.34,138.84 10.5,138.57 10.5,138.48 10.31,138.14 10.5,137.8 10.5,136.84 11.06,136.28 11.06,131.37 11.05,131.36 11.05,130.61 10.84,130.41 10.84,129.97 10.87,129.94 10.72,129.79 10.32,129.79 10.04,130.07 10.04,130.65 9.39,131.3 8.51,131.3 8.05,131.75 8.05,142.8 8.38,143.12 10.35,143.12
+3VS on TOP (solid shape): 194.64,66.92 194.64,66.18 194.67,66.16 194.84,66.16 194.87,66.18 194.87,66.92 194.89,66.94 195,66.94 195.03,66.92 195.03,65.66 195.01,65.64 194.63,65.53 194.52,65.15 194.44,65.07 194.44,62.91 194.82,62.53 196.25,62.53 196.59,61.92 196.82,62.58 196.79,62.65 196.82,62.72 196.91,62.87 196.92,63.04 196.92,63.33 197.36,63.77 197.36,64.53 196.47,65.42 196.47,66.92 196.49,66.94 196.65,66.94 196.65,66.18 196.67,66.16 196.82,66.16 196.85,66.18 196.85,66.92 196.88,66.94 197.26,66.94 197.7,66.5 198.22,66.5 198.43,66.29 198.43,65.24 198.78,64.9 198.78,61.97 197.71,60.9 193.42,60.9 192.81,61.52 192.81,65.86 192.84,66.01 192.81,66.16 192.81,66.45 192.87,66.51 193.52,66.51 193.95,66.94 194.62,66.94
+3VS on TOP (solid shape): outline of 155 points within 69.23,120.11 79.8,125.27
+3VS on TOP (solid shape): outline of 248 points within 69.72,26.31 74.69,40.94
+3VS on TOP (solid shape): outline of 495 points within 197.16,25.39 205.16,36.96
+3VS on BOTTOM (solid shape): 24.97,103.7 24.97,100.31 24.76,100.09 23.05,100.09 22.47,100.67 22.47,103.55 22.74,103.82 24.85,103.82
+3VS on BOTTOM (solid shape): 234.2,46.27 234.2,45.38 234.1,45.29 233.11,45.29 232.71,45.69 232.71,46.13 232.76,46.18 233.1,46.18 233.1,46.35 234.12,46.35
+3VS on BOTTOM (solid shape): 38.4,51.85 38.4,51.56 37.59,50.75 37.59,49.23 35.58,49.23 35.41,49.4 35.41,52.41 35.56,52.56 37.7,52.56
+3VS on BOTTOM (solid shape): 90.89,86.31 90.89,84.29 90.23,83.63 88.96,83.63 88.82,83.77 88.82,83.93 89.08,84.19 89.15,84.19 89.15,84.19 89.51,84.19 89.98,84.66 89.98,86.37 90.08,86.47 90.73,86.47
+3VS on BOTTOM (solid shape): 6.91,108.55 6.91,107.13 6.3,106.52 6.3,103.43 5.71,103.43 5.71,104.97 5.64,105.04 5.35,105.04 5.3,104.99 5.3,103.43 4.69,103.43 4.69,105.05 4.62,105.12 4.62,107.42 5.16,107.96 5.16,108.14 5.83,108.81 6.66,108.81
+3VS on BOTTOM (solid shape): 57.58,174.59 57.58,173.58 57.84,173.32 58.85,173.32 59.03,173.5 59.72,173.5 59.84,173.38 59.84,172.88 59.77,172.72 59.77,172.54 59.41,172.18 57.46,172.18 56.95,172.69 56.41,172.69 56.38,172.72 56.38,173.15 56.55,173.32 56.82,173.32 57.07,173.58 57.07,174.46 57.33,174.72 57.46,174.72
+3VS on BOTTOM (solid shape): outline of 176 points within 21.51,62.37 30.92,79.11
+3VS on BOTTOM (solid shape): outline of 235 points within 81.1,51.97 101.57,56.1
+3VS on BOTTOM (solid shape): outline of 758 points within 229.34,57.12 248.45,64.41
+3VS on IN1 (solid shape): 251.04,64.54 251.04,60.55 249.32,58.83 247.67,58.83 247.32,59.18 247.32,61.43 247.48,61.43 247.49,61.38 247.5,61.32 247.52,61.27 247.55,61.22 247.58,61.18 247.62,61.14 247.67,61.11 247.72,61.08 247.77,61.07 247.82,61.06 247.88,61.05 247.94,61.06 247.99,61.07 248.04,61.1 248.09,61.12 248.13,61.16 248.17,61.2 248.2,61.25 248.22,61.3 248.24,61.35 248.25,61.41 248.25,61.46 248.24,61.52 248.22,61.57 248.2,61.62 248.17,61.67 248.13,61.71 248.09,61.75 248.04,61.77 247.99,61.8 247.94,61.81 247.88,61.82 247.82,61.81 247.77,61.8 247.72,61.79 247.67,61.76 247.62,61.73 247.58,61.69 247.55,61.65 247.52,61.6 247.5,61.55 247.49,61.49 247.48,61.43 247.32,61.43 247.32,63.51 248.63,64.82 250.76,64.82
+3VS on IN1 (solid shape): outline of 83 points within 251.61,74.88 254.41,81.05
+3VS on IN1 (solid shape): outline of 148 points within 78.73,120.57 82.05,147.87
+3VS on IN1 (solid shape): outline of 311 points within 91.35,168.07 100.23,177.8
+3VS on IN1 (solid shape): outline of 431 points within 195.26,54.65 218.45,62.78
+3VS on IN1 (solid shape): outline of 420 points within 75.41,151.21 83.58,159.65
+3VS on IN1 (solid shape): outline of 435 points within 28.62,51.63 38.85,64.23
+3VS on IN2 (solid shape): 212.9,23.69 212.9,22.37 212.41,21.87 209.33,21.87 209.23,21.98 209.23,22.37 210.81,23.96 212.64,23.96
+3VS on IN2 (solid shape): 254.97,35.63 254.97,34.08 254.21,33.32 252.6,33.32 252.12,33.79 252.12,35.5 252.47,35.85 254.75,35.85
+3VS on IN2 (solid shape): outline of 1114 points within 88.46,52.19 98,84.46
+3VS on IN3 (solid shape): outline of 640 points within 65.95,72.1 93.12,127.52
+3VS on IN3 (solid shape): outline of 652 points within 6.27,101.7 24.88,132.25
+3VS on IN3 (solid shape): outline of 831 points within 216.76,54.35 231.56,62.58
+3VS on IN3 (solid shape): outline of 817 points within 239.5,78.5 257.61,98.01
+3VS on IN3 (solid shape): outline of 22238 points within 35.59,31.25 199.47,72.43
+3VS on IN4 (solid shape): 10.54,144.39 10.74,144.19 11.18,144.19 11.18,144.19 11.58,144.19 11.77,144 11.77,141.91 11.27,141.4 9.87,141.4 9.65,141.62 9.65,142.63 10.34,142.63 10.34,142.58 10.36,142.53 10.38,142.47 10.41,142.43 10.44,142.38 10.49,142.35 10.53,142.32 10.58,142.29 10.64,142.28 10.69,142.27 10.75,142.27 10.8,142.28 10.86,142.29 10.91,142.32 10.95,142.35 10.99,142.38 11.03,142.43 11.06,142.47 11.08,142.53 11.09,142.58 11.1,142.63 11.1,142.69 11.09,142.75 11.07,142.8 11.05,142.85 11.01,142.89 10.97,142.93 10.93,142.97 10.88,142.99 10.83,143.01 10.77,143.03 10.72,143.03 10.66,143.03 10.61,143.01 10.56,142.99 10.51,142.97 10.46,142.93 10.43,142.89 10.39,142.85 10.37,142.8 10.35,142.75 10.34,142.69 10.34,142.63 9.65,142.63 9.65,144.67 9.68,144.7 10.54,144.7
+3VS on IN4 (solid shape): outline of 116 points within 53.5,169.95 59.81,175.48
+3VS on IN4 (solid shape): outline of 201 points within 90.6,174.79 100.31,177.73
+3VS on IN4 (solid shape): outline of 223 points within 57.46,180.99 62.9,183.46
+3VS on IN4 (solid shape): outline of 275 points within 71.27,172.55 80.41,177.79
+3VS_CAM on BOTTOM (solid shape): 57.44,184.1 57.44,183.67 57.31,183.53 56.49,183.53 56.46,183.5 56.1,183.39 55.99,183.03 55.93,182.97 55.93,182.82 55.77,182.66 55.74,182.66 55.42,182.51 55.37,182.15 55.35,182.06 55.27,182.01 55.11,182.01 55.01,182.11 55.01,182.42 55.02,182.42 55.02,182.63 55.03,182.65 55.44,183.05 55.44,183.9 55.78,184.24 57.3,184.24
+3VS_DACVDD on TOP (solid shape): 99.37,137.68 99.37,137.3 99.68,136.98 100.28,136.98 100.3,136.96 100.3,136.41 100.2,136.31 99.87,136.31 99.23,135.67 98.07,135.67 97.97,135.77 97.97,136.33 97.98,136.34 98.19,136.6 98.1,136.92 98.1,137.68 98.22,137.81 99.24,137.81
+3VS_EDP on TOP (solid shape): 62.23,182.9 62.23,182.67 62.18,182.62 62.18,182.14 62.38,181.94 62.38,180.82 62.31,180.75 62.12,180.75 62.12,181.47 62.12,181.95 62.1,181.97 61.89,181.97 61.87,181.95 61.87,180.75 61.62,180.75 61.62,181.47 61.62,181.47 61.62,181.94 61.59,181.97 61.39,181.97 61.37,181.95 61.37,180.75 61.13,180.75 61.13,182.87 61.27,183.02 62.1,183.02
+3VS_EDP on BOTTOM (solid shape): 62.29,182.87 62.29,182.02 62.28,182.01 62.28,181.5 62.15,181.37 61.65,181.37 61.39,181.12 61.13,181.12 61.09,181.08 61.09,180.66 61.05,180.62 60.73,180.62 60.69,180.67 60.69,181.06 60.63,181.12 60.48,181.12 60.25,180.89 60.25,178.15 59.28,177.18 59.25,177.18 58.71,176.64 58.69,176.62 58.09,176.62 58.09,177.64 59.23,178.78 59.23,181.93 59.37,182.07 59.43,182.08 59.48,182.08 59.91,182.08 60.02,182.07 60.12,182.08 60.6,182.08 60.79,182.28 60.9,182.28 61.04,182.41 61.04,182.5 61.06,182.6 61.06,182.69 61.06,182.71 61.29,182.95 62.22,182.95
+3VS_EDP on IN1 (solid shape): 62.54,182.85 62.54,182.42 62.53,182.42 62.51,182.3 62.53,182.18 62.54,182.17 62.54,181.83 62.52,181.82 62.52,181.65 61.92,181.05 60.82,181.05 60.65,181.22 60.65,181.75 61.01,182.11 61.01,182.45 61.06,182.63 61.02,182.82 61.01,182.83 61.01,182.97 61.14,183.1 62.28,183.1
+3VS_EDP on IN1 (solid shape): outline of 199 points within 43.31,180.44 48.53,182.89
+3VS_HDMI on TOP (solid shape): 217.8,59.1 217.8,58.44 217.46,58.1 216.95,58.1 216.73,58.32 216.73,59.03 216.85,59.16 217.74,59.16
+3VS_S0 on TOP (solid shape): 250.12,38.42 250.37,38.32 250.63,38.42 251.78,38.42 252.03,38.32 252.29,38.42 254.16,38.42 254.38,38.19 254.38,37.89 254.18,37.69 254.18,36.87 253.23,36.87 253.09,36.73 250.72,36.73 250.72,36.78 250.36,37.18 249.92,36.86 249.91,36.82 248.97,36.82 247.96,37.83 247.93,37.83 247.92,37.85 247.16,37.85 247.08,37.76 247.04,37.76 246.94,37.86 246.94,37.97 247.07,38.09 247.24,38.09 247.31,38.16 247.31,38.31 247.42,38.42
+3VS_S0 on BOTTOM (solid shape): 227.8,38.86 227.8,38.79 227.85,38.73 227.85,37.57 226.64,37.57 226.64,38.91 226.74,39.01 227.65,39.01
+3VS_S0 on BOTTOM (solid shape): 249.99,37.3 249.99,36.73 249.54,36.28 249.54,35.97 249.35,35.78 249.13,35.78 248.99,35.92 248.99,36.77 248.73,37.03 248.73,37.44 248.85,37.56 249.73,37.56
+3VS_S0 on IN4 (solid shape): outline of 2095 points within 226.7,28.83 249.86,39.21
+3VS_S0_TBT on BOTTOM (solid shape): 234.69,36.72 234.69,36.39 234.52,36.22 233.41,36.22 232.93,35.74 227.32,35.74 227,36.06 227,36.67 227.51,36.67 227.54,36.64 227.86,36.64 227.94,36.56 231.59,36.56 232.03,37 234.42,37
+3VS_S0_TBT on IN1 (solid shape): outline of 285 points within 234.29,33.21 242.08,36.85
+3VS_SSD on TOP (solid shape): outline of 513 points within 44.03,27.4 58.2,51.35
+3VS_SSD on BOTTOM (solid shape): 53.31,52.06 53.31,47.97 53.11,47.77 51.28,47.77 51.08,47.97 51.08,52.14 51.14,52.2 53.18,52.2
+3VS_SSD on BOTTOM (solid shape): 45.48,50.78 46.44,50.78 46.59,50.63 46.59,49.44 46.29,49.15 38.62,49.15 38.45,49.32 38.45,50.42 38.83,50.79 45.47,50.79
+3VS_SSD on BOTTOM (solid shape): 56.69,34.14 56.69,33.75 56.06,33.11 54.33,33.11 54.25,33.19 54.25,33.6 54.01,33.84 54.01,34.22 54.04,34.24 56.59,34.24
+3VS_SSD_PCIE on TOP (solid shape): outline of 542 points within 62.28,26.31 70.41,50.81
+3VS_SSD_PCIE on BOTTOM (solid shape): 64.17,52.23 64.17,47.99 64.14,47.96 63.95,47.96 62.31,49.6 62.31,51.86 62.72,52.27 62.75,52.27 63.13,52.29 63.47,52.47 63.93,52.47
+3VS_SSD_PCIE on BOTTOM (solid shape): 64.41,35.26 65.86,35.26 65.86,34.94 64.41,34.94 64.41,34.76 65.86,34.76 65.86,34.44 64.41,34.44 64.41,34.26 65.86,34.26 65.86,33.22 65.75,33.11 64.31,33.11 63.92,33.5 63.92,33.51 63.72,33.83 63.42,34.07 63.42,34.76 63.93,35.27 64.41,35.27
+3VS_TP on BOTTOM (solid shape): 169.72,29.43 169.4,29.43 169.16,29.19 168.96,29.19 168.72,29.43 168.25,29.43 168.25,29.94 169.72,29.94
+3VS_TYPEC on BOTTOM (solid shape): outline of 328 points within 234.9,44.7 243.01,47.83
+3VS_VGA on TOP (solid shape): 239.19,114.25 239.19,112.46 238.91,112.18 237.22,112.18 237.15,112.26 237.15,114.15 237.35,114.36 239.08,114.36
+3VS_VGA on TOP (solid shape): 258.5,96.23 258.5,94.84 258.24,94.58 257.1,94.58 256.85,94.84 256.85,96.36 257.1,96.61 258.12,96.61
+3VS_VGA on TOP (solid shape): 258.12,106.01 258.12,103.98 257.35,103.22 254.05,103.22 253.8,103.47 253.8,104.61 254.18,105 255.83,105 256.08,105.25 256.08,106.01 256.46,106.39 257.73,106.39
+3VS_VGA on IN3 (solid shape): outline of 1616 points within 238.29,94.71 259,114.24
+3VSUS on TOP (solid shape): 216.48,90.57 216.48,89.16 215.66,88.34 215.02,88.34 214.75,88.61 214.75,90.41 215.12,90.78 216.26,90.78
+3VSUS on TOP (solid shape): 184.43,32.71 184.43,31.03 183.62,31.03 183.54,31.11 183.54,32.05 183.74,32.25 183.74,32.73 183.96,32.94 184.2,32.94
+3VSUS on TOP (solid shape): 188.95,68.21 188.95,66.87 188.8,66.72 184.99,66.72 184.89,66.82 184.89,67.63 185.12,67.86 186.26,67.86 186.74,68.34 188.82,68.34
+3VSUS on TOP (solid shape): 245.32,89.9 245.32,88.93 244.99,88.6 243.87,88.6 243.68,88.42 243.37,88.42 243.18,88.61 243.18,89.78 243.43,90.03 245.19,90.03
+3VSUS on TOP (solid shape): 208.24,80.49 208.24,79.76 208.28,79.72 208.28,70.1 203.23,65.04 200.79,65.04 200.63,65.19 200.63,65.52 200,66.16 199.54,66.16 199.49,66.21 199.49,66.27 198.22,67.54 198.22,67.94 197.84,68.32 197.71,68.32 197.51,68.52 197.51,68.78 197.66,68.93 197.89,68.93 198.55,68.27 199.21,68.27 200.18,67.3 202.51,67.3 202.63,67.42 202.63,80.71 202.81,80.89 202.97,80.89 203.21,81.13 207.6,81.13
+3VSUS on BOTTOM (solid shape): 234.2,47.57 234.2,46.64 234.12,46.56 233.1,46.56 233.1,47.65 234.12,47.65
+3VSUS on BOTTOM (solid shape): 226.87,54.3 226.87,52.08 226.68,51.9 225.68,51.9 225.64,51.94 225.64,54.39 225.7,54.45 226.71,54.45
+3VSUS on BOTTOM (solid shape): 248.31,41.39 248.41,41.34 248.52,41.31 249.61,40.22 249.61,39.46 249.41,39.27 248.8,39.27 248.77,39.29 248.77,39.89 247.83,40.84 247.83,41.26 247.96,41.39
+3VSUS on BOTTOM (solid shape): 185.57,40.1 186.66,40.1 186.66,36.85 187.33,36.17 187.33,33.35 187.21,33.22 187.03,32.68 187.59,32.57 187.63,32.58 187.66,32.56 187.71,32.5 187.78,32.45 187.85,32.38 187.85,32.27 187.48,31.9 187.01,31.9 186.47,32.44 186.44,32.52 186.48,32.59 186.62,32.95 186.36,33.25 186.33,33.26 186.33,34.21 185.37,35.17 185.37,39.1 184.82,39.65 184.82,39.66 184.58,39.85 184.27,39.81 183.95,39.81 183.7,40.06 183.7,40.49 183.77,40.56 185.12,40.56
+3VSUS on IN1 (solid shape): 244.28,89.88 244.28,88.65 244.06,88.44 242.83,88.44 242.51,88.76 242.51,89.79 242.94,90.22 243.93,90.22
+3VSUS on IN1 (solid shape): 184.96,33.75 184.96,33.38 184.99,33.35 184.99,32.94 184.69,32.64 184.69,32.04 184.47,31.82 183.82,31.82 183.78,31.86 183.78,33.11 184.58,33.92 184.8,33.92
+3VSUS on IN1 (solid shape): outline of 186 points within 187.39,40.39 190.56,49.39
+3VSUS on IN2 (solid shape): outline of 3793 points within 178.97,42.44 201.4,69.03
+3VSUS on IN4 (solid shape): 243.95,90.63 243.95,88.4 243.76,88.21 241.5,88.21 240.84,88.87 240.84,90.49 241.38,91.03 243.56,91.03
+3VSUS on IN4 (solid shape): outline of 538 points within 214.57,89.31 232.18,95.09
+3VSUS on IN4 (solid shape): outline of 1930 points within 161.47,31.39 184.53,35.93
+3VSUS_LAN on BOTTOM (solid shape): 231.95,92.09 231.95,90.92 231.78,90.74 230.31,90.74 229.91,91.15 229.91,92.19 229.98,92.27 231.78,92.27
+3VSUS_SX on BOTTOM (solid shape): 239.43,44.19 239.43,43.27 238.1,43.27 237.19,42.36 234.72,42.36 234.11,41.75 232.96,41.75 232.58,41.37 232.58,41.15 231.77,41.15 231.73,41.18 231.73,41.53 231.77,41.62 231.86,41.63 232.17,41.69 232.33,41.96 232.34,42 232.46,42 232.84,42.38 234.11,42.38 235,43.27 235,44.33 239.3,44.33
+3VSUS_SX on BOTTOM (solid shape): 249.53,38.35 249.53,37.83 249.38,37.69 248.87,37.69 248.8,37.68 248.58,37.58 248.47,37.36 248.18,37.08 248.18,35.85 247.97,35.64 247.93,35.62 246.88,35.62 246.72,35.46 246.35,35.46 245.95,35.69 245.71,35.29 245.71,35.22 245.57,35.08 245.36,35.08 245.24,35.2 245.24,35.57 245.65,35.98 246.34,35.98 246.53,36.17 246.86,36.17 247.07,36.38 247.32,36.38 247.32,37.71 247.88,38.27 248.65,38.27 248.78,38.4 249.48,38.4
