# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB1_DAT: length 606.6
  TOP w0.114: v2(214.38,63.33) 215.15,64.11 219.8,64.11 220.16,63.75 220.16,62.56 221.13,61.59 222.17,61.59 222.37,61.78 Q1201.2 ; U5000.7 176.61,76.24 177.39,75.46 177.39,75.23 R5002.2 177.54,74.31 177.06,74.31 176.17,73.42 175.06,73.42 174.73,73.75 174.73,77.14 174.96,77.36 179.93,77.36 181.09,78.52 181.09,79.18 181.57,79.66 181.57,80.11 182.55,81.08 v2(182.55,82.05) ; v2(133.58,38.06) 133.58,38.78 132.68,39.67 131.26,39.67 131.07,39.87 R3035.1 ; R5804.1 v2(250.37,121.77) ; v2(91.92,40.55) 91.51,40.96 83.71,40.96 72.5,52.17 51.92,52.17 48.97,55.13 48.37,55.13 48.32,55.18 33.46,55.18 33.15,55.49 33.15,57.03 29.25,60.93 29.25,62.75 31.02,64.53 31.02,71.21 29.44,72.79 29.44,75.78 30.42,76.75 30.42,88.85 43.54,101.97 43.54,105.66 v1(43.79,105.91) 43.54,106.16 43.54,108.48 v2(43.44,108.59) ; v2(6.4,90.26) 6.65,90.01 14.45,90.01 19.84,95.4 20.76,95.4 v2(22.68,97.33) ; v2(148.9,32.9) 148.9,32.73 147.99,31.82 147.99,27.49 147.02,26.52 147.02,25.34 R3139.2
  IN1 w0.076: v2(91.92,40.55) 92.38,41 96.25,41 96.84,40.42 111.29,40.42 111.31,40.4 111.47,40.24 112.3,40.24 113.24,39.3 114.7,39.3 115.3,38.7 132.61,38.7 133.25,38.06 v2(133.58,38.06)
  IN2 w0.114: v2(214.38,63.33) 214.16,63.33 210.79,66.7 210.79,73.9 202.94,81.74 190.35,81.74 189.76,82.33 185.97,82.33 185.84,82.46 182.96,82.46 v2(182.55,82.05) ; v2(43.44,108.59) 42.02,108.59 41.74,108.3 36.84,108.3 34.02,105.49 28.67,105.49 22.68,99.51 v2(22.68,97.33)
  IN3 w0.114: v2(205.73,30.72) 207.02,32.02 207.02,32.19 208.21,33.38 210.53,33.38 213.33,36.18 217.69,36.18 218.48,36.97 218.48,37.69 218.88,38.09 218.88,39.09 218.47,39.51 218.47,40.92 219.12,41.57 219.12,48.44 218.57,48.99 217.17,48.99 216.57,49.59 216.57,50.24 216.79,50.47 216.79,57.35 215.37,58.77 215.37,62.85 214.9,63.33 v2(214.38,63.33) 215.36,64.31 215.36,66.12 214.88,66.6 214.88,73.06 215.34,73.53 215.85,73.53 219.19,76.87 219.19,77.37 221.91,80.09 221.91,82.86 221.45,83.32 221.45,83.95 223.19,85.69 234.91,85.69 237.07,87.85 237.07,91.81 235.48,93.4 235.48,95.3 235.55,95.37 235.55,97.55 233.86,99.24 233.86,101.31 232.92,102.26 232.92,109.45 244.63,121.17 249.77,121.17 v2(250.37,121.77)
  IN4 w0.076: v2(205.73,30.72) 205.3,31.16 205.3,31.51 205.56,31.78 205.56,32.97 204.99,33.55 201.93,33.55 201.27,32.89 200.13,32.89 199.74,33.29 196.66,33.29 194.35,30.98 191.35,30.98 190.7,30.33 169.71,30.33 169.43,30.61 166.19,30.61 165.58,30 164.48,30 163.35,31.13 161.55,31.13 159.4,33.29 149.28,33.29 v2(148.9,32.9) 148.53,32.53 148.06,32.53 147.22,33.37 145.57,33.37 145.14,32.94 140.73,32.94 139.96,32.17 136.9,32.17 136.38,32.7 135.05,34.03 v2(134.18,34.03)
  BOTTOM w0.114: Q7402.3 81.46,113 78.5,110.04 71.18,110.04 70.18,111.05 67.62,111.05 ; v2(43.44,108.59) 45.9,111.05 67.62,111.05 ; CON6700.13 7.35,67.75 6.76,67.16 6.76,63.38 6.17,62.79 4.63,62.79 2.88,64.53 2.88,78.79 4.68,80.59 4.68,81.64 5.47,82.44 5.47,82.95 4.3,84.12 4.3,88.78 5.79,90.26 v2(6.4,90.26) ; v2(133.58,38.06) 133.48,37.96 133.48,34.73 v2(134.18,34.03) ; 67.62,111.05 v1(67.62,110.79)
SMB_CLK_MAIN: length 320.7
  TOP w0.114: v2(97.49,60.18) 98.63,59.04 CON1700.253 ; v2(46.1,46.18) 45.67,46.61 31.24,46.61 28.72,49.12 28.72,53.86 28.61,53.96 28.61,53.98 25.87,56.72 v1(23.78,56.72) 23.15,56.72 20.02,59.85 8.65,59.85 7.42,61.09 7.42,62.08 6.88,62.62 6.88,63.75 6.58,64.05 v2(5.18,64.05) ; 151.94,37.53 151.94,35.03 153.87,33.09 R3105.2 R3110.2 153.88,31.8 154.08,31.6 154.55,31.6 154.82,31.33 154.82,29.34 154.59,29.12 Q3102.2 ; 151.94,37.53 v1(152.18,37.53) ; 151.94,37.53 151.94,41.91 151.14,42.7 150.34,42.7 150.11,42.94 147.44,42.94 147.44,42.94 147.32,42.94 146,44.26 146,47.3 147.46,48.76 147.46,49.04 149.3,50.87 149.3,52.95 148.72,53.52 147.66,53.52 146.85,54.34 146.85,56.95 145.97,57.83 145.97,65.48 v2(146.05,65.57) ; CON1600.253 98.63,71.24 98.85,71.46 v2(99.81,71.46)
  IN1 w0.076: v2(97.49,60.18) 97.75,60.18 98.76,59.17 104.46,59.17 105.48,60.19 107.08,60.19 108.43,61.54 111.19,61.54 111.72,61.01 121.18,61.01 121.56,61.4 123.05,61.4 123.62,61.97 v2(123.62,63.21)
  IN4 w0.076: v2(146.05,65.57) 146.43,65.19 146.43,63.21 145.77,62.55 141.12,62.55 140.66,63.02 137.44,63.02 137.11,63.35 135.27,63.35 134.96,63.04 133.91,63.04 132.4,61.54 125.3,61.54 v2(123.62,63.21) ; v2(61.89,53.61) 62.26,53.98 67.85,53.98 70.5,56.63 95.51,56.63 97.17,58.29 97.17,59.86 v2(97.49,60.18) 97.77,60.47 97.77,61.24 99.55,63.02 99.55,63.51 100.55,64.51 100.55,67.12 100.71,67.28 100.71,69.53 100.33,69.92 100.33,70.95 99.82,71.46 v2(99.81,71.46) ; v2(64.01,47.56) 64.01,47.52 63.08,46.59 46.51,46.59 v2(46.1,46.18)
  BOTTOM w0.114: v2(64.01,47.56) 61.7,49.86 61.7,53.43 v2(61.89,53.61) ; v2(97.49,60.18) 98,60.7 98,61.99 97.3,62.69 97.3,64.08 97.26,64.12 97.26,64.13 97.13,64.25 96.85,64.25 96.63,64.48 CON1701.253 ; v2(5.18,64.05) 4.72,64.51 4.72,79.59 5.44,80.31 5.44,81.36 6.22,82.14 6.22,82.47 9.4,85.64 11.4,85.64 11.98,86.22 11.98,87.95 12.52,88.49 12.52,89.29 14.54,91.3 14.54,104.97 9.7,109.8 9.7,115.31 11.14,116.76 11.14,120.37 11.31,120.54 R1623.2 R4421.1 ; v2(99.81,71.46) 98.52,71.46 96.98,73.01 96.98,75.94 96.63,76.29 CON1601.253
SMB_CLK_RESUME: length 54.7
  TOP w0.114: v2(178.94,42.14) 179.26,41.83 179.26,38.75 179.97,38.04 v1(180.65,38.04) 180.98,37.72 180.98,36.34 C2304.1 180.97,35.47 180.97,34.54 R2327.2 181.83,33.68 181.83,32.76 v2(181.72,32.66) ; Q3102.3 155.78,31.03 R3110.1 155.06,32.07 v2(155.34,32.35)
  BOTTOM w0.114: U2000.AW44 178.56,41.75 v2(178.94,42.14) ; v2(181.72,32.66) 181.97,32.42 181.97,32.13 182.06,32.04 182.06,32.03 182.27,31.82 182.27,29.23 180.42,27.37 177.57,27.37 176.92,26.72 176.92,25.71 176.46,25.26 164.28,25.26 163.94,25.6 163.94,26.64 164.26,26.96 164.26,28.86 163.94,29.18 163.94,31.35 163.45,31.84 155.85,31.84 v2(155.34,32.35)
SMB_DATA_MAIN: length 318.3
  TOP w0.114: v2(97.43,61.91) 98.88,63.36 CON1700.254 ; 151.57,40.23 151.57,41.76 150.99,42.33 150.19,42.33 149.96,42.56 147.18,42.56 145.63,44.11 145.63,47.45 147.09,48.91 147.09,49.19 148.93,51.03 148.93,52.8 148.57,53.15 147.51,53.15 146.48,54.18 146.48,56.79 145.6,57.68 145.6,65.4 v2(145.42,65.58) ; 151.57,40.23 151.57,35.15 151,34.59 R3108.2 R3104.2 151,32.21 149.98,31.18 Q3100.2 ; 151.57,40.23 v1(151.31,40.23) ; v2(99.88,70.84) 100.27,71.23 100.27,71.66 100.51,71.91 100.51,73.64 98.88,75.28 CON1600.254 ; v2(5.84,63.57) 6.48,62.93 6.48,62.39 7.05,61.82 7.05,60.94 8.6,59.38 19.92,59.38 23.1,56.21 25.86,56.21 28.25,53.82 28.25,53.81 28.35,53.7 28.35,48.97 31.14,46.18 v2(45.49,46.18)
  IN1 w0.076: v2(123.62,63.85) 123.19,63.42 123.19,62 122.91,61.73 121.43,61.73 121.04,61.34 111.86,61.34 111.31,61.89 108.32,61.89 106.95,60.52 105.35,60.52 104.33,59.5 98.93,59.5 97.43,61 v2(97.43,61.91)
  IN4 w0.076: v2(99.88,70.84) 99.88,70.43 99.89,70.43 99.89,69.89 100.38,69.4 100.38,67.41 100.22,67.25 100.22,64.65 99.22,63.65 99.22,63.16 97.98,61.91 v2(97.43,61.91) 97.43,60.78 96.84,60.18 96.84,58.48 95.32,56.96 70.36,56.96 67.75,54.35 61.94,54.35 v2(61.2,53.61) ; v2(63.37,47.56) 62.73,46.92 46.23,46.92 v2(45.49,46.18) ; v2(145.42,65.58) 146.1,64.9 146.1,63.35 145.63,62.88 141.26,62.88 140.79,63.35 137.58,63.35 137.25,63.68 135.13,63.68 134.82,63.37 133.77,63.37 132.27,61.87 125.6,61.87 v2(123.62,63.85)
  BOTTOM w0.114: v2(99.88,70.84) 97.31,70.84 96.88,70.41 CON1601.254 ; CON1701.254 96.88,60.39 97.43,60.95 v2(97.43,61.91) ; v2(63.37,47.56) 61.34,49.6 61.34,53.48 v2(61.2,53.61) ; R4420.1 R1624.2 12.96,120.54 13.7,119.81 13.7,118.79 10.07,115.16 10.07,110.05 14.9,105.22 14.9,91.15 12.89,89.13 12.89,88.33 12.35,87.79 12.35,86.07 11.56,85.27 9.55,85.27 6.6,82.32 6.6,82 5.81,81.21 5.81,80.15 5.09,79.43 5.09,64.78 5.84,64.03 v2(5.84,63.57)
SMB_DATA_RESUME: length 64
  TOP w0.114: R3108.1 152.12,34 152.2,34 153.24,32.96 v2(153.24,32.45) 152.6,31.81 151.28,31.81 150.93,31.46 Q3100.3 ; v1(182.83,32.17) 182.82,32.17 v2(182.33,32.66) 182.2,32.79 182.2,33.68 R2328.2 182.2,34.1 181.94,34.36 181.94,36.34 C2305.1 182.37,37.8 181.69,38.48 180.05,38.48 179.63,38.91 179.63,39.73 180.14,40.24 180.14,40.71 179.79,41.06 v2(179.79,41.61)
  BOTTOM w0.089: U2000.BB43 179.79,41.99 179.79,41.61 v2(179.79,41.61)
  BOTTOM w0.114: v2(153.24,32.45) 154.42,32.45 155.4,31.48 163.22,31.48 163.51,31.18 163.51,29.05 163.88,28.68 163.88,27.27 163.51,26.9 163.51,25.44 164.06,24.89 176.62,24.89 177.29,25.56 177.29,26.57 177.71,26.99 180.56,26.99 182.64,29.08 182.64,31.97 182.43,32.18 182.43,32.19 182.33,32.28 v2(182.33,32.66)
SMBALERT#_PCHHOT#: length 15.6
  TOP w0.102: R2335.2 190.48,50.03 v1(189.61,50.03) 189.59,50.05 R2349.2 188.23,49.58 187.41,49.58 186.84,49.01 184.91,49.01 184.17,48.28 183.81,48.28 183.68,48.15 181.53,48.15 180.79,48.88 179.34,48.88 179.21,49.01 178.34,49.01 178.02,49.33 177.31,49.33 v2(176.91,49.73)
  BOTTOM w0.089: v2(176.91,49.73) 177.15,50.04 U2000.AT27
SMBALERT#_TLS: length 13.2
  TOP w0.102: v2(179.82,43.12) 179.82,42.5 v1(179.65,42.33) 180.2,41.79 180.2,41.16 180.55,40.81 180.55,40.15 179.99,39.58 179.99,39.06 180.2,38.84 181.84,38.84 183.26,37.42 R2348.2 183.72,36.31 183.72,35.65 183.03,34.97 183.03,34.58 R2334.2
  BOTTOM w0.089: U2000.BB41 180.1,42.84 v2(179.82,43.12)
SMBCLKCPUXDP: length 9.1
  BOTTOM w0.114: XDP4400.53 10.25,128.35 10.45,128.56 11.09,128.56 12.09,127.56 v1(12.09,124.83) 12.09,122.72 R4421.2
SMBDATACPUXDP: length 9.8
  BOTTOM w0.114: R4420.2 12.9,122.65 v1(12.9,123.23) 12.9,124.83 12.57,125.16 12.57,127.6 11.32,128.85 11.24,128.93 10.3,128.93 10.23,128.85 XDP4400.51
SMCLK0: length 3.8
  TOP w0.114: R3032.1 128.75,35.55 v1(128.38,35.17) 127.94,35.61 127.94,36.11 127.7,36.35 U3001.110
SMDAT0: length 3.1
  TOP w0.114: U3001.111 127.99,36.75 128.11,36.87 v1(128.76,36.87) 129.18,36.87 R3033.1
SML0_DATA: length 12.4
  TOP w0.114: v2(179.09,43.82) 179.3,43.61 179.3,42.84 179.05,42.59 178.8,42.59 178.51,42.29 178.51,41.96 178.89,41.58 178.89,38.5 v1(178.97,38.42) 180.01,37.38 180.01,36.41 C2307.1 180.11,35.49 180.11,34.51 R2330.2
  BOTTOM w0.089: v2(179.09,43.82) 179.16,43.75 U2000.BB39
SML1_CLK: length 6.8
  TOP w0.114: U3001.115 127.68,38.35 128.33,39 R3034.2 129.67,39.26 129.85,39.44 130.97,39.44 131.11,39.31 132.24,39.31 v1(132.72,38.83)
SML1_DATA: length 3.3
  TOP w0.114: U3001.116 127.56,38.75 v1(128.68,39.87) R3035.2
SPI_CLK: length 107.6
  TOP w0.114: v2(194.74,28.95) 195.02,29.23 R3157.2 ; R3043.1 130.63,34 v2(130.76,34.13)
  IN1 w0.076: v2(195.99,36.68) 195.96,36.65 195.96,30.56 194.92,29.52 194.92,29.13 v2(194.74,28.95)
  IN4 w0.076: v2(130.76,34.13) 132.06,34.13 133.35,32.84 134.15,32.84 135.94,31.05 158.58,31.05 160.9,28.73 166.87,28.73 167.17,28.43 176.11,28.43 176.69,29.01 191.09,29.01 191.45,29.38 194.31,29.38 v2(194.74,28.95)
  BOTTOM w0.114: v2(195.99,36.68) 195.8,36.87 195.8,38.74 196.09,39.03 196.09,40.02 195.91,40.2 195.91,43.1 196.37,43.56 196.37,44.19 195.03,45.54 195.03,46.04 194.85,46.21 192.8,46.21 192.68,46.33 190.59,46.33 190.12,46.8 189.04,46.8 188.92,46.68 188.27,46.68 C2204.1 187.83,46.37 187.29,46.92 187.05,46.92 186.68,47.28 R2232.1 ; CON4402.7 202.86,26.22 202.14,25.49 200.48,25.49 199.29,26.68 199.04,26.68 v1(198.02,27.72) 197.98,27.67 195.86,27.67 195.22,28.31 195.22,28.52 194.8,28.95 v2(194.74,28.95)
SPI_CLK_L500MIL: length 5.5
  BOTTOM w0.089: 183.25,47.31 182.91,47.65 181.08,47.65 180.97,47.75 180.77,47.75 U2000.BC31
  BOTTOM w0.114: R2232.2 184.53,47.28 v1(184.51,47.31) 183.25,47.31
SPI_CS0#: length 127.8
  TOP w0.114: v2(194.12,28.29) 194.12,28.3 194.19,28.37 194.19,29.14 193.06,30.27 193.06,31.43 194.51,32.88 194.51,34.89 194.23,35.17 194.23,36.53 196.81,39.11 v2(197.29,39.11) 198.91,39.11 199.19,39.38 U3101.1 ; R3041.1 131.02,31.79 v2(131.24,32.02) 131.55,32.32 v1(131.55,32.81)
  IN4 w0.076: v2(131.24,32.02) 132.16,31.1 134.81,31.1 135.52,30.39 154.99,30.39 157.35,28.02 166.57,28.02 166.82,27.77 176.38,27.77 176.97,28.35 185.15,28.35 186.62,26.88 193.13,26.88 194.12,27.87 v2(194.12,28.29)
  BOTTOM w0.114: v2(194.12,28.29) 193.81,27.98 193.81,23.51 194.98,22.33 200.02,22.33 203.86,26.17 CON4402.5 ; R2229.1 191.67,46.83 192.89,46.83 193.01,46.71 195.06,46.71 195.52,46.24 195.52,45.74 195.99,45.27 196.97,45.27 197.33,44.91 197.33,44.5 197.23,44.4 196.97,44.4 196.87,44.31 196.87,43.9 196.97,43.8 197.21,43.8 197.33,43.68 197.33,43.22 197.21,43.1 196.62,43.1 196.47,42.94 196.47,42.7 196.58,42.59 197.4,42.59 197.56,42.43 197.56,40.99 197.41,40.84 197.15,40.84 197.01,40.98 197.01,41.63 196.92,41.72 196.57,41.72 196.45,41.61 196.45,40.57 196.57,40.45 197.49,40.45 197.56,40.38 197.56,39.97 197.41,39.82 196.98,39.82 196.87,39.71 196.87,38.8 196.77,38.7 196.51,38.7 196.32,38.51 196.32,37.25 196.52,37.05 196.65,37.05 196.9,37.3 196.9,37.92 197.1,38.12 197.41,38.12 197.56,38.27 197.56,38.98 197.43,39.11 v2(197.29,39.11)
SPI_CS0#_L500MIL: length 10
  BOTTOM w0.089: 184.2,47.79 183.25,47.79 183.2,47.83 181.2,47.83 U2000.BD31
  BOTTOM w0.114: 184.2,47.79 186.89,47.79 187.27,47.41 187.74,47.41 v1(187.96,47.19) 188.66,47.19 188.78,47.32 190.31,47.32 R2229.2
SPI_IO2: length 306.9
  TOP w0.114: v2(195.66,48.3) 195.66,46.25 R3159.1 195.84,46.07 195.84,44.97 195.65,44.78 195.65,43.82 195.22,43.4 195.22,42.88 196.11,41.99 196.11,38.75 193.98,36.62 193.98,34.93 194.27,34.65 194.27,33.72 193.9,33.35 192.62,33.35 192.35,33.09 192.35,32.48 192.75,32.08 192.75,30.13 193.78,29.11 v2(193.78,28.82)
  IN1 w0.076: v2(27.92,40) 27.92,38.33 30.09,36.15 38.93,36.15 40.52,37.74 49.66,37.74 50.61,36.78 77.18,36.78 79.04,38.64 96.08,38.64 96.48,39.04 110.72,39.04 113.03,36.74 114.67,36.74 116.5,34.9 128.71,34.9 v2(129.01,34.61)
  IN2 w0.114: v2(27.92,40) 28.37,40.45 28.37,40.99 28.12,41.24 28.12,42.13 28.88,42.89 28.88,47.08 26.94,49.02 26.94,53.84 23.26,57.52 23.26,59.4 21.52,61.15 17.87,61.15 17.35,61.66 12.23,61.66 12,61.89 6.8,61.89 v2(6.53,61.61)
  IN4 w0.076: v2(129.01,34.61) 129.28,34.88 130.05,34.88 130.3,34.63 130.3,33.87 130.63,33.55 132,33.55 133.06,32.49 133.06,31.55 133.3,31.31 134.89,31.31 135.61,30.59 155.13,30.59 157.49,28.23 166.65,28.23 166.91,27.97 176.3,27.97 176.88,28.55 185.24,28.55 186.71,27.08 192.95,27.08 193.73,27.86 193.73,28.77 v2(193.78,28.82)
  BOTTOM w0.114: v2(195.66,48.3) 195.15,48.81 194.75,48.81 194.52,49.04 R2234.1 ; v1(1.98,118.51) 2.18,118.71 R4425.2 3.61,118.33 3.61,103.84 4.65,102.8 4.65,94.7 5.05,94.3 5.05,90.79 2.88,88.62 2.88,83.13 1.86,82.11 1.86,64.98 4.47,62.37 5.77,62.37 v2(6.53,61.61)
SPI_IO2_L500MIL: length 15
  BOTTOM w0.089: U2000.BC29 180.54,49.06 180.71,48.88 181.55,48.88 181.79,48.65 182.68,48.65
  BOTTOM w0.114: 182.68,48.65 182.78,48.75 191.81,48.75 192.09,48.47 192.51,48.47 193.08,49.04 R2234.2 193.45,49.2 193.45,49.43 194,49.98 v1(194.34,49.98)
SPI_IO3: length 28
  TOP w0.114: R3158.2 197.28,28.94 v2(197.23,28.99)
  IN1 w0.076: v2(198.09,37.39) 196.82,36.12 196.82,29.39 v2(197.23,28.99)
  BOTTOM w0.114: R2233.1 194.39,48.02 194.98,47.43 195.5,47.43 197.82,45.11 197.82,43.36 198.04,43.13 198.04,38.45 v1(198.27,38.22) 198.09,38.04 v2(198.09,37.39) ; v2(197.23,28.99) 197.68,28.54 199.01,28.54 199.11,28.64 200.33,28.64 200.43,28.54 200.94,28.54 201.36,28.12 CON4402.10
SPI_IO3_L500MIL: length 12.8
  BOTTOM w0.089: U2000.BD30 181.05,48.64 181.42,48.27 183.31,48.27
  BOTTOM w0.114: 183.31,48.27 187.09,48.27 187.46,47.9 189.46,47.9 v1(189.6,48.04) 191.79,48.04 191.85,47.99 192.92,47.99 192.96,48.02 R2233.2
SPI_MISO: length 123.8
  TOP w0.114: U3001.103 127.82,33.55 v2(128.12,33.85) ; R3160.1 v2(198.53,43.63)
  IN1 w0.076: v2(194.73,28.32) 194.55,28.49 194.55,28.49 194.28,28.76 194.23,28.81 194.23,29.48 194.46,29.71 195.5,30.75 195.5,36.87 196.48,37.85 198.28,37.85 v2(198.73,37.4)
  IN4 w0.076: v2(194.73,28.32) 194.54,28.13 194.54,27.83 193.38,26.68 186.54,26.68 185.07,28.15 177.05,28.15 176.47,27.57 166.73,27.57 166.47,27.82 157.21,27.82 154.85,30.18 135.44,30.18 134.72,30.9 131.8,30.9 130.1,32.61 130.1,34.29 129.87,34.52 129.53,34.52 128.86,33.85 v2(128.12,33.85)
  BOTTOM w0.114: v2(194.73,28.32) 194.73,27.68 194.6,27.55 194.6,23.27 195.25,22.62 199.97,22.62 203.36,26.02 CON4402.6 ; R2231.1 188.88,48.51 191.71,48.51 191.99,48.23 192.62,48.23 192.96,48.57 194.7,48.57 198.06,45.21 198.06,44.1 v2(198.53,43.63) 198.53,40.86 198.88,40.51 v1(198.88,40.38) 198.73,40.22 v2(198.73,37.4)
SPI_MISO_L500MIL: length 6.6
  BOTTOM w0.089: U2000.BE30 181.6,48.46 182.89,48.46
  BOTTOM w0.114: R2231.2 187.38,48.33 187.19,48.51 182.94,48.51 182.89,48.46
SPI_MOSI: length 316.3
  TOP w0.114: v2(195.76,28.48) 195.76,28.31 195.83,28.24 R3156.2 ; R3044.1 131.26,33.25 131.26,34.33 130.96,34.63 130.37,34.63 v1(130.23,34.49) 129.88,34.13 v2(129.7,34.13)
  IN1 w0.076: v2(195.76,28.48) 196.62,29.34 196.62,36.61 v2(197.42,37.41) ; v2(129.7,34.13) 129.7,34.5 129.1,35.11 116.58,35.11 114.75,36.94 113.12,36.94 110.81,39.25 96.4,39.25 96,38.85 78.95,38.85 77.09,36.99 50.7,36.99 49.75,37.94 40.44,37.94 38.85,36.35 30.18,36.35 28.37,38.16 28.37,40.18 v2(27.89,40.66)
  IN2 w0.114: v2(6.4,113.12) 6.81,112.71 6.81,105.74 6.27,105.19 6.27,92.75 4.77,91.25 4.77,83.49 5.29,82.97 5.29,81.46 5,81.18 4.02,81.18 3.79,80.95 3.79,62.44 5.56,60.68 21.32,60.68 22.79,59.21 22.79,57.21 26.36,53.64 26.36,44.19 27.15,43.4 27.15,41.39 v2(27.89,40.66)
  IN4 w0.076: v2(195.76,28.48) 195.62,28.48 193.61,26.47 186.46,26.47 184.98,27.95 177.14,27.95 176.55,27.36 166.61,27.36 166.35,27.62 157.12,27.62 154.76,29.98 135.36,29.98 134.64,30.7 131.72,30.7 129.7,32.71 v2(129.7,34.13)
  BOTTOM w0.114: R4414.2 10.14,116.99 10.14,116.8 6.46,113.12 v2(6.4,113.12) ; CON4402.8 202.36,26.42 201.99,26.05 200.62,26.05 198.47,28.2 196.47,28.2 196.19,28.48 v2(195.76,28.48) ; R2230.1 194.46,47.13 194.64,46.95 195.3,46.95 195.78,46.47 195.78,45.83 196.09,45.52 197.07,45.52 197.57,45.01 197.57,43.26 197.8,43.03 197.8,37.79 v2(197.42,37.41)
SPI_MOSI_L500MIL: length 18.2
  BOTTOM w0.089: U2000.BB29 180.25,48.96 180.25,48.92 180.88,48.29 181.13,48.29 181.39,48.03 183.36,48.03
  BOTTOM w0.114: 183.36,48.03 186.99,48.03 187.36,47.66 189.37,47.66 189.42,47.61 189.79,47.61 189.84,47.66 192.77,47.66 R2230.2 193.29,47.42 193.43,47.56 194.45,47.56 194.81,47.19 195.4,47.19 196.22,46.37 v1(196.22,46.08)
SRTCRST#: length 52.7
  TOP w0.102: v1(221.41,57.75) 221.23,57.75 v2(220.52,57.04)
  IN4 w0.102: v2(204.67,53.23) 206.7,55.26 215.75,55.26 216.69,56.2 217.49,56.2 218.77,57.48 220.09,57.48 v2(220.52,57.04)
  BOTTOM w0.089: U2000.BB10 180.04,58.27 180.35,57.96 181.29,57.96 181.3,57.98 181.79,57.98 181.85,58.03 182.42,58.03 183.58,59.19 183.58,60.42 184.11,60.95 184.71,60.95
  BOTTOM w0.102: R2810.2 C2827.1 220.78,56.79 v2(220.52,57.04) ; v2(204.67,53.23) 204.41,53.49 203.32,53.49 202.84,53.96 202.84,57.04 200.24,59.64 196.03,59.64 194.13,61.53 188.86,61.53 188.79,61.47 187.5,61.47 186.98,60.95 184.71,60.95
SSD_PRESENT: length 33.8
  TOP w0.102: T5102.1 37.24,27.7 38.23,28.69 39.18,28.69 44.86,34.37 44.86,37.86 45.94,38.94 45.94,41.56 48.82,44.44 48.82,45.23 v2(49.78,46.19)
  BOTTOM w0.102: v2(49.78,46.19) 50.62,47.04 50.62,51.93 50.2,52.35 CON5103.1
STRAP0: length 14.4
  BOTTOM w0.102: U7000.BA6 96.35,126.25 95.3,126.25 94.41,127.14 89.97,127.14 88.35,125.53 86.02,125.53 R7315.1 v1(84.65,125.11) 84.65,125.53 84.8,125.68 R7307.2
STRAP1: length 18.6
  BOTTOM w0.102: 84.63,129.35 85.32,128.67 R7316.1 86.07,129.14 86.88,129.14 87.25,129.51 87.25,130.37 v1(88.01,131.13) 88.21,131.34 89.81,131.34 90.09,131.06 90.09,131.04 97.19,131.04 97.81,130.43 97.81,128 U7000.AW8
STRAP2: length 18.1
  BOTTOM w0.102: U7000.BA7 96.32,127.09 96.32,128.41 96.06,128.67 89.84,128.67 88.53,127.36 86.07,127.36 85.6,126.89 R7317.1 85.14,126.89 R7309.2 84.43,126.75 83.69,126.75 83.27,127.17 82.79,127.17 v1(81.83,128.14)
STRAP3: length 15.7
  BOTTOM w0.102: R7310.2 83.97,128.26 v1(84.61,128.26) 85.11,128.26 R7318.1 86.02,128.2 88.74,128.2 89.26,128.72 89.26,128.72 89.48,128.94 89.48,128.95 90.09,129.55 96.06,129.55 96.7,128.92 U7000.BA8
STRAP4: length 14.7
  BOTTOM w0.102: v1(82.58,123.94) 82.88,123.64 84.36,123.64 R7311.2 85.47,124.09 R7319.1 86.07,124.69 88.44,124.69 89.99,126.24 94.8,126.24 95.15,125.9 U7000.BB6
SURGE_IN_C: length 8.9
  TOP w0.102: v2(240.21,148.68) 239.93,148.96 v1(239.5,148.96)
  TOP w0.457: C3400.1 v2(240.21,148.68)
  TOP w0.508: U3401.7 v2(244.53,141.54) ; C3400.1 242.15,147.89 242.49,147.54 U3401.1 ; U3401.4 v2(244.64,144.54) ; U3401.10 v2(244.53,138.54)
SURGE_OUT_C: length 12.1
  TOP w0.102: R3401.2 v1(256.74,144.54)
  TOP w0.508: R3403.2 255.91,139.23 255.91,140.71 R3402.2 255.96,142.33 255.96,143.7 R3401.2 255.91,145.33 255.91,146.17 R3400.2
SUS_PWRGD: length 191.5
  TOP w0.102: v2(130.45,49.25) 130.09,49.25 R9213.2 ; U8100.7 216.8,74.96 216.23,75.53 212.17,75.53 211.15,76.55 v2(211.15,79.29) ; v2(136.36,53.8) 136.13,53.8 T9205.1 135.28,52.95 135.23,52.95 R9202.2 134.32,52.04 D9200.2 133.18,50.63 133.37,50.44 133.37,49.62 v2(133.89,49.1) ; U3001.67 113.52,31.01 112.65,31.88 112.65,33.91 113.3,34.56 115.39,34.56 v2(116.02,33.93)
  IN2 w0.102: v2(130.45,49.25) 130.86,48.85 131.62,48.85 131.63,48.86 132.29,48.86 132.94,49.51 133.48,49.51 v2(133.89,49.1) ; v2(116.02,33.93) 116.68,34.59 124.56,34.59 125.83,35.86 135.12,35.86 v2(137.16,33.81) 139.75,36.4 147.04,36.4 147.7,37.07 158.92,37.07 159.61,37.76 167.15,37.76 168.38,36.53 184.19,36.53 185.04,37.38 193.83,37.38 194.28,37.84 203.48,37.84 206.96,41.32 207.88,41.32 209.58,43.02 209.58,46.09 209.39,46.27 209.39,49.45 210.64,50.71 210.64,55.1 212.82,57.27 212.82,59.59 215.99,62.77 215.99,64.31 211.99,68.32 211.99,77.49 211.15,78.33 v2(211.15,79.29)
  BOTTOM w0.102: v2(136.36,53.8) 136.65,53.51 136.65,34.33 v2(137.16,33.81)
SUSB#_PWR: length 482.1
  TOP w0.102: SR9101.2 136.07,39.46 136.83,38.7 145.52,38.7 145.64,38.83 145.64,41.37 145.77,41.5 v2(146.15,41.5) 147.14,41.5 147.7,40.94 147.7,40.23 147.45,39.97 Q9102.2 ; v2(219.38,90.82) 219.38,90.06 219.84,89.6 220.44,89.6 221.54,88.51 221.54,87.66 223.34,85.85 223.34,82.39 v2(224.74,80.99) ; v2(80.06,159.91) 79.38,160.59 R9403.1 78.12,160.59 77.14,159.61 D9400.2 ; v2(81.2,127.73) 80.63,127.15 69.87,127.15 v2(68.89,128.14) ; v2(151.12,77.63) 151.41,77.34 151.41,76.75 146.87,72.21 146.87,66.32 v2(146.57,66.02) 146.87,65.73 146.87,65 146.33,64.46 146.33,59.12 v2(146.63,58.82) 146.82,58.63 146.82,57.48 148.11,56.2 149.43,56.2 149.66,55.97 149.66,50.72 147.82,48.89 147.82,48.61 146.43,47.22 146.43,44.46 147.59,43.3 150.07,43.3 150.5,43.73 151.79,43.73 v2(154.05,41.47) 154.05,40.54 153.03,39.51 153.03,34.79 154.29,33.52 155.71,33.52 156.33,32.9 157.06,32.9 158.12,31.84 159.76,31.84 160.24,31.37 160.24,30.17 160.49,29.92 161.33,29.92 161.97,29.28 162.22,29.28 162.41,29.47 162.86,29.47 163.28,29.05 R8402.1 ; R8304.1 140.64,63.74 141.39,64.49 142.54,64.49 143.07,63.96 143.07,59.09 T9108.1 142.77,57.99 142.28,57.5 v2(141.61,57.5)
  IN1 w0.102: v2(146.57,66.02) 143.96,66.02 143.31,65.37 141.38,65.37 140.69,64.68 140.13,64.68 139.62,65.19 138.61,65.19 136.31,67.49 130.21,67.49 129.92,67.21 128.8,67.21 127.2,68.81 124.54,68.81 123.87,68.14 121.23,68.14 118.27,65.18 118.27,64.01 116.08,61.82 111.87,61.82 109,64.69 106.22,64.69 102.78,68.13 102.78,71.47 102.15,72.1 100.87,72.1 100.3,72.67 100.3,73.53 99.7,74.13 99.7,86.59 98.32,87.98 98.32,90.73 77.6,111.45 77.6,116.09 71.32,122.37 71.32,124.99 68.89,127.42 v2(68.89,128.14) ; v2(146.15,41.5) 147.47,40.18 152.76,40.18 v2(154.05,41.47)
  IN2 w0.102: v2(151.12,77.63) 151.12,78.04 151.45,78.38 151.45,78.86 152.21,79.62 152.21,80.71 152.64,81.14 155.59,81.14 156.31,81.86 156.31,82.8 158.33,84.81 158.33,85.38 160.03,87.09 160.03,88.31 161.05,89.33 173.47,89.33 176.55,86.25 178.37,86.25 178.47,86.35 179.71,86.35 181.13,84.93 183.88,84.93 186.02,82.79 189.06,82.79 189.5,83.23 189.5,83.88 189.64,84.03 190.67,84.03 192.3,82.4 206.41,82.4 208.76,84.75 209.03,84.75 212.58,88.31 215.17,88.31 215.8,88.94 216.57,88.94 217.54,89.91 219.12,89.91 219.38,90.17 v2(219.38,90.82)
  IN4 w0.102: v2(81.2,127.73) 81.08,127.73 80.42,128.39 80.42,146.75 76.25,150.92 76.25,155.26 80.06,159.07 v2(80.06,159.91) ; v2(146.63,58.82) 143.91,58.82 142.36,57.27 141.88,57.27 141.66,57.5 v2(141.61,57.5) ; v2(228.27,61.69) 227.41,60.83 223.74,60.83 223.36,61.21 223.36,64.09 224.21,64.94 224.21,79.88 224.74,80.41 v2(224.74,80.99) 222.82,80.99 219.78,77.95 215.89,77.95 215.4,77.46 213.99,77.46 213.59,77.06 213.59,66.95 214,66.54 214,64.25 213.21,63.47 200.87,63.47 v2(199.95,64.39)
  BOTTOM w0.102: R9104.1 194.62,70.77 194.62,69.74 194.56,69.69 194.56,67.89 195.12,67.33 197.27,67.33 197.45,67.15 197.45,67.03 197.82,66.66 197.82,65.96 199.39,64.39 v2(199.95,64.39) ; R9106.1 221.77,84.65 221.77,88.66 220.78,89.65 219.96,89.65 219.38,90.23 v2(219.38,90.82) 219.38,91.42 T9301.1 218.74,91.76 218.31,91.33 JP9301.2 ; v2(228.27,61.69) 228.85,62.27 231.49,62.27 231.62,62.14 R9109.1
SUSB_EC#: length 160.4
  TOP w0.102: R3074.2 114,22.95 v1(114.27,22.67) 114.5,22.45 114.61,22.45 115.43,21.62 117.91,21.62 118.91,22.62 119.21,22.62 120.07,23.48 v2(120.07,24.22) 120.51,23.78 120.89,23.78 121.21,24.1 121.21,25.49 120.98,25.72 R3029.1 120.73,26.13 R3079.2 ; D9201.2 139.06,52.21 138.64,52.63 136.57,52.63 136.43,52.49 136.43,52.07 135.56,51.2 135.56,48.94 R9204.1 136.02,47.08 136.88,46.22 136.88,41.67 136.61,41.41 SR9101.1 136.07,42 v2(136.25,42.18)
  IN1 w0.102: v2(120.7,31.69) 121.25,31.15 129.33,31.15 130.82,32.63 140.78,32.63 v2(140.89,32.52)
  IN2 w0.102: v2(140.89,32.52) 141.39,33.01 143.8,33.01 144.28,33.49 150.51,33.49 150.94,33.06 164.76,33.06 166.04,31.78 166.04,31.47 167.47,30.04 175.01,30.04 175.46,29.59 175.46,29.08 175.96,28.59 183.5,28.59 184.02,28.07 189.68,28.07 191.42,29.81 194.86,29.81 195.61,30.56 198.54,30.56 198.79,30.82 202.83,30.82 203.78,31.77 v2(203.78,32.93)
  BOTTOM w0.102: v2(120.7,31.69) 120.7,31.69 120.7,31.22 120.94,30.98 120.94,26.03 120.07,25.16 v2(120.07,24.22) ; v2(136.25,42.18) 136.25,34.02 136.85,33.41 137.97,33.41 138.14,33.58 139.93,33.58 140.18,33.32 140.18,33.23 v2(140.89,32.52) ; v2(203.78,32.93) 203.17,33.54 203.17,34.41 203.99,35.23 203.99,36.06 203.89,36.16 203.89,37.69 204.01,37.81 204.01,39.57 202.72,40.86 202.72,43.55 203.81,44.65 203.81,46.44 202.87,47.39 U2404.2
SUSC#_PWR: length 187
  TOP w0.102: v2(141.25,62.02) 141.56,61.71 142.53,61.71 142.86,61.37 142.86,59.63 142.28,59.04 142.28,58.12 142.06,57.9 141.43,57.9 140.39,56.86 139.05,56.86 137.34,55.15 v2(137.34,53.81) ; v2(127.91,59.71) 127.32,59.71 126.64,60.39 125.71,60.39 124.91,61.18 D9500.1 122.93,61.18 122.56,61.55 R9503.1 ; Q9103.2 142.14,32.98 141.53,33.6 140.75,33.6 140.53,33.37 140.53,33.34 SR9103.2 140.03,33.48 140.03,33.67 v2(140.22,33.87) ; R8307.1 141.03,67.81 141.23,68 141.23,68.6 141.45,68.82 141.69,68.82 141.78,68.73 D8301.2 141.78,67.07 v2(142.04,66.82) 142.33,67.11 142.33,68.41 142.44,68.52 142.44,73.72 T9111.1 142.7,74.72 142.44,74.98 142.44,76.17 143.76,77.49 v2(143.76,77.79)
  IN2 w0.102: v2(218.95,90.39) 218.87,90.31 217.66,90.31 216.49,89.14 215.72,89.14 215.09,88.51 212.5,88.51 208.94,84.96 208.68,84.96 206.33,82.61 192.38,82.61 190.76,84.23 189.56,84.23 189.29,83.96 189.29,83.32 188.97,83 186.1,83 183.96,85.13 181.21,85.13 179.79,86.55 178.22,86.55 178.12,86.45 176.63,86.45 173.55,89.53 160.97,89.53 159.83,88.39 159.83,87.17 158.12,85.47 158.12,84.9 156.11,82.88 156.11,81.94 155.51,81.34 152.55,81.34 152.01,80.8 152.01,79.71 151.25,78.95 151.25,78.5 150,77.25 150,77.02 148.55,75.56 147.17,75.56 144.94,77.79 v2(143.76,77.79) ; v2(142.04,66.82) 142.02,66.82 141.67,66.47 141.67,64.83 141.25,64.41 v2(141.25,62.02)
  IN4 w0.102: v2(141.25,62.02) 133.5,62.02 132.67,61.19 129.4,61.19 v2(127.91,59.71)
  BOTTOM w0.102: v2(140.22,33.87) 140.22,34.62 138.38,36.47 138.38,38.91 137.06,40.23 137.06,48.97 139.03,50.94 139.21,50.94 139.36,51.1 139.36,52.26 138.99,52.63 138.52,52.63 v2(137.34,53.81) ; v2(142.04,66.82) 141.7,67.15 141.02,67.15 140.59,66.72 R9112.1 140.2,66.12 139.05,66.12 138.56,65.63 R9100.1 ; v2(218.95,90.39) 218.95,89.88 218.61,89.55 JP9302.2 218.36,89.04 219.05,89.04 T9302.1 220.8,89.27 221.34,88.74 221.34,87.26 R9105.1
SUSC_EC#: length 52.5
  TOP w0.102: R3080.2 119.84,26.13 R3030.1 119.66,25.72 119.3,25.37 119.3,24.48 119.59,24.19 119.59,23.4 119.08,22.89 118.85,22.89 117.84,21.88 116.03,21.88 115.09,22.83 v2(115.09,24.21) 114.68,23.8 113.74,23.8 113.52,24.02 v1(112.42,24.02) 111.86,23.46 R3075.2 ; v2(141.5,32.52) 141.19,32.84 SR9103.1
  IN1 w0.102: v2(120.68,32.3) 120.3,31.92 120.3,31.45 120.81,30.94 129.42,30.94 130.9,32.43 140.22,32.43 140.53,32.11 141.1,32.11 v2(141.5,32.52)
  BOTTOM w0.102: v2(120.68,32.3) 120.19,31.82 120.19,31.44 120.73,30.9 120.73,26.12 119.35,24.73 118.86,24.73 118.45,24.33 118.45,24.07 118.19,23.8 115.49,23.8 v2(115.09,24.21)
SUSWARN#: length 9
  TOP w0.102: v2(187.23,55.35) 187.4,55.52 T2206.1
  BOTTOM w0.089: U2000.BD19 181.15,53.74 181.59,53.74 181.79,53.54 182.78,53.54 184.16,54.92 184.71,54.92
  BOTTOM w0.102: R2263.1 187.82,55.37 187.72,55.37 187.69,55.35 v2(187.23,55.35) 186.81,54.92 184.71,54.92
SW_3PIN: length 14.3
  TOP w0.127: v2(186.05,171.56) v1(186.05,172.22) PR700.1
  IN1 w0.127: v2(186.05,171.56) 192.82,171.56 194.06,170.32 v2(194.06,167.2)
  BOTTOM w0.127: PSW1700.3 v2(194.06,167.2)
SYS_PEX_RST_MON#: length 13.5
  TOP w0.102: v2(98.26,114.95) 96.35,114.95 D7001.1 95.67,114.74 95.37,114.44 U7002.4
  BOTTOM w0.102: R7441.1 98.73,116.35 v1(98.81,116.27) R7443.2 98.38,114.95 v2(98.26,114.95)
  BOTTOM w0.103: R7441.1 98.22,117.69 98.22,121.17 97.96,121.44 97.96,122.04 98.3,122.39 U7000.AW2
SYS_PWROK: length 115.4
  TOP w0.102: R3076.1 108.14,43.97 108.04,43.97 v1(107.7,44.32) 107.7,43.48 v2(107.95,43.22)
  IN1 w0.102: v2(191.22,64.91) 190.96,64.65 190.96,61.19 190.21,60.44 188.03,60.44 185.24,57.65 185.24,50.99 183.24,48.99 183.24,42.91 182.06,41.73 182.06,40.78 181.64,40.37 180.86,40.37 180.23,39.73 179.19,39.73 178.18,40.74 172.65,40.74 170.54,38.62 159.93,38.62 159.34,38.04 146.74,38.04 145.13,39.64 136.21,39.64 135.01,40.84 132.78,40.84 132.17,41.45 130.86,41.45 130.78,41.37 124.1,41.37 123.67,41.8 109.38,41.8 v2(107.95,43.22)
  BOTTOM w0.102: v2(191.22,64.91) 191.84,65.53 U2403.1 191.84,66.4 191.44,66.79 191.44,67.58 191.11,67.91 R2489.1
SYS_RESET#: length 238.2
  IN1 w0.102: v2(178.01,69.24) 178.01,69.24 177.6,68.83 177.6,68.59 176.59,67.58 169,67.58 168.77,67.8 158.16,67.8 157.45,67.1 153.87,67.1 152.52,65.75 149.61,65.75 146.12,62.25 143.01,62.25 142.06,61.31 138.5,61.31 136.41,59.22 132.66,59.22 131.5,58.06 122.71,58.06 122.19,57.54 117.42,57.54 116.51,58.45 109.4,58.45 107.58,56.63 99.35,56.63 98.92,56.2 41.06,56.2 38.81,58.45 38.81,62.68 37.8,63.7 33.82,63.7 32.38,65.13 31.57,65.13 26.66,70.05 26.66,70.53 25.08,72.11 25.08,77.76 20.49,82.34 12.27,82.34 11.48,83.13 11.48,83.22 10.78,83.91 9.89,83.91 9.74,84.07 8.14,84.07 7.5,84.71 7.5,86.36 v2(8,86.86)
  IN4 w0.102: v2(4.62,108.76) 6.81,106.57 6.81,88.65 8,87.46 v2(8,86.86)
  BOTTOM w0.102: v2(178.01,69.24) 178.01,68.93 178.08,68.85 178.08,68.49 177.97,68.37 177.97,67.37 R2451.2 178.87,66.46 178.87,65.98 v1(178.89,65.96) 179.06,65.79 179.06,63.42 178.51,62.86 U2000.AW1 ; v2(4.62,108.76) 4.02,109.36 4.02,116.88 3.84,117.06 3.84,118.44 R4419.2
TBT_BATLOW_N: length 18.9
  TOP w0.102: R1132.1 231.61,43.67 233.43,43.67 233.55,43.78 235.81,43.78 235.86,43.83 238.33,43.83 v1(238.56,43.6) 239.53,44.58 240.03,44.58 240.44,44.16 241.19,44.16 241.4,43.95 241.69,43.95 242.99,42.64 243.93,42.64 245.09,41.49 245.09,39.14 244.99,39.04 244.99,38.57 U1101.F2
TBT_CIO_PLUG_EVENT_N: length 94.3
  TOP w0.102: R2247.2 159.56,34.36 v1(159.12,34.8) 159.13,34.81 159.13,36.34 R2257.1 159.56,39.24 160.45,40.12 161.87,40.12 164.85,43.1 v2(164.85,43.49) ; R1152.2 233.57,42.24 R1146.1 233.36,42.45 v2(233.36,43.02)
  IN2 w0.102: v2(208.13,42.72) 207.96,42.89 206.53,42.89 206.17,42.54 206.17,41.47 203.82,39.11 200.2,39.11 199.65,39.67 184.73,39.67 183.51,38.45 182.85,38.45 182.54,38.75 181.24,38.75 180.71,38.22 170.17,38.22 169.17,39.22 168.41,39.22 164.85,42.78 v2(164.85,43.49)
  IN4 w0.102: v2(233.36,43.02) 232.66,43.71 229.32,43.71 227.04,45.99 220.47,45.99 219.31,44.82 216.53,44.82 216.41,44.71 211.87,44.71 209.88,42.72 v2(208.13,42.72)
  BOTTOM w0.089: v2(164.85,43.49) 165.12,43.76 165.12,43.9 165.45,44.23 166.19,44.23 U2000.R39
TBT_CIO_PLUG_EVENT_N_R: length 6.3
  TOP w0.089: 236.35,41.52 v1(236.8,41.06)
  TOP w0.102: U1101.W2 239.23,38.37 239,38.59 239,39.7 238.88,39.83 238.88,39.97 238.55,40.3 237.21,40.3 236.8,40.71 v1(236.8,41.06) ; R1152.1 235.63,42.24 236.35,41.52
TBT_CLKREQ_N: length 43
  TOP w0.114: U1101.AC5 236.53,36.97 236.45,37.05 236.16,37.05 235.11,38.09 233.65,38.09 232.8,38.95 R1111.1 229.29,39.26 229.08,39.47 226.94,39.47 v2(226.81,39.6)
  IN4 w0.076: v2(226.81,39.6) 226.6,39.38 224.45,39.38 220.23,43.6 211.58,43.6 210.26,42.29 207.64,42.29 206.75,43.18 202.77,43.18 202.37,43.58 v2(201.99,43.58)
  BOTTOM w0.114: R2483.2 200.63,41.75 v1(200.56,41.83) 200.56,41.87 201.99,43.3 v2(201.99,43.58)
TBT_EE_CLK: length 37.3
  TOP w0.076: U1201.A3 239.47,49.68 239.4,49.68
  TOP w0.102: U1101.AB4 237.62,37.65 236.95,37.65 236.74,37.86 236.44,37.86 234.59,39.71 234.59,39.89 234.28,40.21 230.63,40.21 228.96,41.88 227.87,41.88 v1(227.75,42) 227.52,42.24 227.52,48.06 v2(228.04,48.59) 226.87,49.76 U1103.6 ; 239.4,49.68 238.71,49.68 v2(238.38,50.01)
  IN4 w0.102: v2(228.04,48.59) 229.71,48.59 230.26,49.13 232.16,49.13 232.86,48.44 237.33,48.44 237.93,49.04 238.31,49.04 238.55,49.28 238.55,49.84 v2(238.38,50.01)
TBT_EE_CS_N: length 44
  TOP w0.076: v4(240.46,49.65) 240.46,49.65 240.42,49.7 U1201.B3
  TOP w0.102: U1103.1 224.33,47.75 v2(224.52,47.93) 223.14,49.3 v1(222.72,49.3) 222.72,49.7 222.68,49.74 R1105.1 ; v2(227.99,42.75) 228.41,42.75 230.75,40.41 234.39,40.41 234.88,39.93 234.88,39.81 236.62,38.07 236.79,38.07 236.98,37.88 237.38,37.88 U1101.AC3
  IN1 w0.102: v2(224.52,47.93) 225.93,46.52 225.93,44.49 227.67,42.75 v2(227.99,42.75)
  IN4 w0.102: v2(224.52,47.93) 224.52,47.99 224.98,48.46 225.1,48.46 225.34,48.69 225.34,48.81 225.79,49.26 228.07,49.26 228.48,48.85 229.69,48.85 230.17,49.34 232.25,49.34 232.94,48.64 237.25,48.64 237.57,48.96 237.57,50.64 237.8,50.87 239.19,50.87 240.41,49.65 v4(240.46,49.65)
TBT_EE_DI: length 38.3
  TOP w0.089: 235.86,39.47 v1(235.48,39.84)
  TOP w0.102: U1103.5 228.14,49.98 v2(227.96,49.79) 227.96,49.33 228.65,48.64 228.65,44.62 227.97,43.93 227.97,43.48 230.82,40.63 234.7,40.63 v1(235.48,39.84) ; U1101.AB3 237.61,38.12 237.01,38.12 236.86,38.27 236.71,38.27 236.47,38.5 236.47,38.85 235.86,39.47 ; v4(240.46,50.39) 240.27,50.2 U1201.B4
  IN4 w0.102: v4(240.46,50.39) 240,50.39 239.31,51.08 237.72,51.08 237.36,50.72 237.36,49.04 237.16,48.85 233.03,48.85 232.33,49.55 230.02,49.55 229.86,49.39 228.36,49.39 v2(227.96,49.79)
TBT_EE_DO: length 42
  TOP w0.076: U1201.A4 239.4,50.11
  TOP w0.102: R1104.1 224.97,54.02 224.97,51.08 225.96,50.09 v2(225.96,48.86) 225.96,48.23 225.6,47.87 U1103.2 225.6,43.73 v1(225.7,43.63) 225.7,43.44 227.67,41.47 229.08,41.47 230.54,40 233.02,40 233.65,39.38 234.34,39.38 234.87,38.84 235.17,38.84 236.35,37.66 236.66,37.66 236.89,37.43 U1101.AC4 ; v2(238.98,50.08) 239.37,50.08 239.4,50.11
  IN4 w0.102: v2(225.96,48.86) 226.64,48.18 229.61,48.18 230.36,48.93 232.08,48.93 232.77,48.24 237.42,48.24 238.02,48.84 238.39,48.84 238.78,49.22 238.78,49.87 v2(238.98,50.08)
TBT_EE_WP_N: length 31.1
  TOP w0.102: v2(231.45,43.02) 231.45,43.14 231.76,43.46 233.58,43.46 233.7,43.58 236.7,43.58 237.21,43.07 237.21,41.7 237.39,41.52 237.82,41.52 238.32,41.02 238.91,41.02 239.45,40.47 239.45,40.21 239.69,39.98 U1101.V1 ; v1(228.21,54.78) R1103.1 227.25,54.5 226.97,54.22 226.44,54.22 226.24,54.02 226.24,52.06 225.62,51.45 225.62,50.81 226.24,50.19 226.24,49.35 226.65,48.94 226.65,47.7 v2(226.43,47.48) 226.87,47.04 U1103.3
  IN1 w0.102: v2(226.43,47.48) 226.43,46.87 229.58,43.72 230.74,43.72 v2(231.45,43.02)
TBT_FORCE_PWR: length 77.7
  TOP w0.102: v1(164.46,41.48) 164.9,41.48 R2259.2 165.9,42.47 v2(165.9,42.88)
  IN2 w0.102: v2(208.08,43.54) 206.54,43.54 205.94,42.94 205.94,41.55 203.74,39.34 200.32,39.34 199.79,39.87 184.65,39.87 183.43,38.65 182.93,38.65 182.63,38.96 181.16,38.96 180.62,38.42 170.26,38.42 169.25,39.43 168.49,39.43 165.9,42.02 v2(165.9,42.88)
  IN4 w0.102: v2(230.51,48.5) 229.78,47.77 227.72,47.77 226.79,46.84 215.74,46.84 214.91,46.02 211.52,46.02 210.97,45.46 209.07,45.46 208.08,44.47 v2(208.08,43.54)
  BOTTOM w0.102: v2(165.9,42.88) 165.9,42.49 U2000.P43 ; v2(230.51,48.5) R1133.1 R1151.2
TBT_FORCE_PWR_R: length 22.2
  TOP w0.102: v4(244.75,37.32) 244.42,37.65 U1101.H4
  IN4 w0.102: v2(231.95,47.08) 232.15,46.88 233.95,46.88 236.55,44.29 236.55,43.43 237.66,42.31 237.66,41.82 238.4,41.09 239.21,41.09 240.24,40.06 241.13,40.06 241.42,39.78 241.72,39.78 241.94,39.57 241.94,39.01 242.11,38.83 243.93,38.83 244.75,38.01 v4(244.75,37.32)
  BOTTOM w0.102: v1(229.59,47.41) 229.59,47.17 230.27,46.49 231.22,46.49 231.37,46.63 R1151.1 231.83,46.96 v2(231.95,47.08)
TBT_HOLD_N: length 2.9
  TOP w0.102: U1103.7 225.6,54.07 225.25,54.42 v1(225.25,54.78) R1106.1
TBT_I2C_SCL: length 15.3
  TOP w0.076: 240.57,48.42 240.74,48.59 240.74,48.94 240.99,49.18 U1201.D2
  TOP w0.102: v2(240.18,47.98) 240.18,48.03 240.57,48.42 ; U1101.U2 239.92,38.58 239.92,39.21
  TOP w0.114: 239.92,39.21 239.91,39.22 239.91,40.04 239.65,40.29 239.65,40.66 239.07,41.24 238.38,41.24 R1141.1 238.1,41.95 v2(238.56,42.42)
  IN4 w0.076: v2(238.56,42.42) 238.34,42.65 238.34,44.34 240.47,46.47 240.47,47.66 240.18,47.95 240.18,47.97
  IN4 w0.102: 240.18,47.97 v2(240.18,47.98)
  BOTTOM w0.114: v1(239.47,42.23) 239.28,42.42 v2(238.56,42.42)
TBT_I2C_SDA: length 13.4
  TOP w0.076: 240.99,48.42 U1201.D1
  TOP w0.102: v2(240.79,48) 240.99,48.19 240.99,48.42 ; 240.11,39.46 240.11,38.85 U1101.U1
  TOP w0.114: 240.11,39.46 240.11,40.12 239.85,40.38 239.85,40.81 239.42,41.24 R1140.1 239.28,41.79 v2(238.56,41.79)
  IN4 w0.076: 240.82,47.97 240.92,47.87 240.92,46.28 238.79,44.15 238.79,43.16 239.02,42.94 239.02,42.23 238.75,41.96 238.74,41.96 v2(238.56,41.79)
  IN4 w0.102: 240.82,47.97 v2(240.79,48)
  BOTTOM w0.114: v2(238.56,41.79) 237.91,41.79 v1(237.8,41.67)
TBT_MRESET: length 163.8
  TOP w0.102: v2(118.92,24.22) 118.85,24.3 118.85,25.49 119.3,25.95 R3092.2 ; U1201.E11 241.49,54.8 240.55,55.73 232.03,55.73 v1(231.85,55.56) 231.13,55.56 R1222.1 230.73,54.81 230.45,54.53 229.25,54.53 228.61,53.89 228.61,51.98 228.37,51.74 228.37,49.56 228.98,48.95 228.98,46.22 228.86,46.1 228.86,43.79 v2(228.55,43.48)
  IN2 w0.102: v2(121.43,28.22) 121.84,28.63 131.41,28.63 132.5,27.54 135.11,27.54 135.79,28.22 146.76,28.22 146.92,28.38 153.5,28.38 156.8,25.09 159.03,25.09 160.96,27.02 165.12,27.02 165.76,26.38 166.78,26.38 167.81,25.34 173.67,25.34 174.42,26.09 177.55,26.09 178.53,25.11 192.33,25.11 193.04,25.82 196.32,25.82 197.21,26.71 204.77,26.71 204.85,26.79 208.51,26.79 209.25,27.52 213.7,27.52 215.65,29.47 217.26,29.47 218.73,30.94 218.73,32.58 218.45,32.86 216.44,32.86 215.42,33.89 215.42,34.22 216.2,35.01 219.21,35.01 223.98,39.78 223.98,41.02 225.08,42.13 227.95,42.13 228.55,42.73 v2(228.55,43.48)
  BOTTOM w0.102: v2(121.43,28.22) 121.32,28.11 121.32,24.18 120.91,23.78 119.37,23.78 v2(118.92,24.22)
TBT_PCIE_RX0_N: length 99.8
  TOP w0.114: C1102.1 238.93,25.62 238.73,25.43 238.73,25.2 238.91,25.03 v2(238.97,25.03)
  IN4 w0.089: v2(238.97,25.03) 238.86,25.13 238.86,25.8 237.44,27.22 236.73,27.22 235.92,28.03 235.92,31.33 231.86,35.39 227.21,35.39 223.64,38.96 219.73,38.96 217.8,37.03 216.45,37.03 212.19,41.29 207.24,41.29 206.47,40.52 190.54,40.52 190.3,40.76 182.96,40.76 182.67,40.47 181.54,40.47 180.84,41.18 179.19,41.18 178.47,41.9 170.56,41.9 170.03,42.43 170.03,48.09 169.54,48.58 167.99,48.58 167.41,49.16 167.41,51.85 165.33,53.94 165.33,54.32 164.62,55.03 163.95,55.03 163.78,54.86 163.78,54.53 v2(163.6,54.35)
  BOTTOM w0.102: v2(163.6,54.35) 163.96,53.99 U2000.K19
TBT_PCIE_RX0_P: length 99.7
  TOP w0.114: C1101.1 238.3,25.62 238.5,25.42 238.5,25.24 v2(238.28,25.03)
  IN4 w0.089: v2(238.28,25.03) 238.44,25.18 238.68,25.42 238.68,25.73 237.36,27.04 236.66,27.04 235.74,27.96 235.74,31.25 231.79,35.21 227.14,35.21 223.57,38.78 219.8,38.78 217.87,36.85 216.38,36.85 212.12,41.11 207.32,41.11 206.55,40.34 190.47,40.34 190.22,40.58 183.03,40.58 182.75,40.3 181.47,40.3 180.76,41 179.12,41 178.4,41.72 170.49,41.72 169.85,42.36 169.85,48.02 169.47,48.4 167.92,48.4 167.23,49.09 167.23,51.78 165.15,53.86 165.15,54.24 164.54,54.85 164.03,54.85 163.96,54.79 163.96,54.53 164.03,54.46 164.03,54.43 164.11,54.35 v7(164.39,54.35)
  BOTTOM w0.102: v7(164.39,54.35) 164.39,53.86 164.52,53.73 U2000.L19
TBT_PCIE_RX1_N: length 103.3
  TOP w0.114: C1104.1 241.22,25.62 241.35,25.49 241.35,25.11 241.19,24.95 v2(241.05,24.95)
  IN4 w0.089: v2(241.05,24.95) 241.1,24.95 241.33,25.17 241.33,25.58 241.25,25.66 240.53,25.66 240.36,25.48 240.36,24.71 239.85,24.21 237.61,24.21 236.65,25.17 236.65,26.21 235.13,27.73 235.13,30.82 231.35,34.6 226.67,34.6 224.27,37.01 219.03,37.01 218.27,36.24 216.1,36.24 212.95,39.4 209.12,39.4 208.75,39.77 185.93,39.77 185.73,39.57 181.13,39.57 180.94,39.75 179.15,39.75 177.75,41.15 170.22,41.15 168.78,42.59 168.78,47.08 168.48,47.39 167.67,47.39 167.34,47.72 167.34,48.17 166.65,48.86 166.65,51.48 164.5,53.63 162.4,53.63 162.29,53.52 162.29,53.41 162.57,53.13 v2(162.71,53.13)
  BOTTOM w0.114: v2(162.71,53.13) 162.75,53.09 162.75,52.72 162.66,52.63 U2000.G22
TBT_PCIE_RX1_P: length 103.3
  TOP w0.114: v2(241.74,24.95) 241.59,25.1 241.59,25.35 C1103.1
  IN4 w0.089: v2(241.74,24.95) 241.51,25.18 241.51,25.65 241.32,25.84 240.46,25.84 240.18,25.55 240.18,24.78 239.78,24.39 237.69,24.39 236.83,25.24 236.83,26.28 235.31,27.81 235.31,30.89 231.42,34.78 226.75,34.78 224.34,37.18 218.96,37.18 218.19,36.42 216.18,36.42 213.02,39.58 209.19,39.58 208.83,39.94 185.85,39.94 185.65,39.74 181.2,39.74 181.02,39.93 179.23,39.93 177.82,41.33 170.29,41.33 168.96,42.66 168.96,47.15 168.55,47.56 167.74,47.56 167.51,47.79 167.51,48.25 166.83,48.93 166.83,51.56 164.58,53.8 162.32,53.8 162.11,53.59 162.11,53.23 v7(162,53.13)
  BOTTOM w0.114: U2000.E22 162,52.95 v7(162,53.13)
TBT_PCIE_RX2_N: length 101
  TOP w0.114: v2(243.58,24.89) 243.63,24.89 243.97,25.22 243.97,25.34 243.82,25.49 C1106.1
  IN4 w0.089: v2(243.58,24.89) 243.84,24.63 243.84,24.03 243.62,23.81 237.42,23.81 236.02,25.22 236.02,26.26 232.92,29.35 230.63,29.35 229.91,30.07 229.91,30.48 228.27,32.12 226.89,32.12 226.25,32.76 226.25,33.24 224.06,35.43 221.51,35.43 221.1,35.84 215.86,35.84 212.74,38.96 208.88,38.96 208.47,39.37 198.75,39.37 198.03,38.65 194.39,38.65 193.68,37.94 187.76,37.94 187.34,37.52 182.82,37.52 181.63,38.71 177.64,38.71 177.14,39.21 170.81,39.21 167.74,42.28 167.74,46.21 167.45,46.5 166.87,46.5 166.24,47.12 166.24,50.81 165.74,51.32 v2(165.74,51.75)
  BOTTOM w0.114: v2(165.74,51.75) 165.34,52.15 164.79,52.15 164.55,52.39 164.55,52.52 164.65,52.63 U2000.L22
TBT_PCIE_RX2_P: length 101.1
  TOP w0.114: v2(244.23,24.88) 244.2,24.9 244.2,25.4 C1105.1
  IN4 w0.089: v2(244.23,24.88) 244.13,24.79 244.13,24.74 244.02,24.63 244.02,23.96 243.7,23.63 237.35,23.63 235.84,25.15 235.84,26.19 232.85,29.18 230.56,29.18 229.74,30 229.74,30.4 228.2,31.94 226.82,31.94 226.07,32.68 226.07,33.16 223.99,35.25 221.44,35.25 221.02,35.66 215.79,35.66 212.67,38.79 208.81,38.79 208.4,39.19 198.82,39.19 198.1,38.47 194.46,38.47 193.75,37.76 187.83,37.76 187.41,37.34 182.75,37.34 181.55,38.53 177.56,38.53 177.07,39.03 170.73,39.03 167.56,42.2 167.56,46.13 167.37,46.32 166.8,46.32 166.07,47.05 166.07,50.74 v2(165.07,51.73)
  BOTTOM w0.114: U2000.K22 163.97,52.62 164.13,52.62 164.24,52.5 164.24,52.36 164.69,51.92 164.84,51.92 165.03,51.73 v2(165.07,51.73)
TBT_PCIE_RX3_N: length 105.6
  TOP w0.114: v2(245.96,24.7) 245.97,24.7 246.05,24.78 246.05,25.39 245.95,25.49 C1108.1
  IN4 w0.089: v7(163.58,51.7) 164.03,51.25 164.64,51.25 165.48,50.41 165.48,45.63 165.3,45.45 165.3,44.85 165.87,44.28 166.1,44.28 166.46,43.92 166.46,40.4 170.09,36.77 187.78,36.77 188.16,37.15 194.2,37.15 194.86,37.81 199.61,37.81 199.87,38.07 212.47,38.07 215.46,35.08 218.06,35.08 219.49,33.65 223.19,33.65 225.56,31.28 227.44,31.28 227.97,30.75 227.97,29.66 230.54,27.09 232.01,27.09 232.64,26.46 233.69,26.46 237.08,23.06 244.61,23.06 245.18,23.63 245.18,25.13 245.43,25.38 245.89,25.38 246.15,25.12 246.15,24.89 v2(245.96,24.7)
  BOTTOM w0.114: v7(163.58,51.7) 163.58,51.68 U2000.K24
TBT_PCIE_RX3_P: length 105.7
  TOP w0.114: v2(246.66,24.68) 246.58,24.68 246.29,24.97 246.29,25.35 246.43,25.49 C1107.1
  IN4 w0.089: v2(164.31,51.68) 164.57,51.42 164.72,51.42 165.66,50.48 165.66,45.56 165.48,45.38 165.48,44.93 165.94,44.46 166.17,44.46 166.63,44 166.63,40.48 170.17,36.95 187.7,36.95 188.09,37.33 194.13,37.33 194.79,37.99 199.54,37.99 199.8,38.24 212.54,38.24 215.53,35.26 218.13,35.26 219.57,33.83 223.27,33.83 225.63,31.46 227.51,31.46 228.14,30.83 228.14,29.74 230.61,27.27 232.08,27.27 232.72,26.64 233.76,26.64 237.16,23.24 244.53,23.24 245,23.71 245,25.21 245.35,25.55 245.96,25.55 246.33,25.19 246.33,24.94 246.58,24.68 v2(246.66,24.68)
  BOTTOM w0.114: v2(164.31,51.68) 164.33,51.68 U2000.L24
TBT_PCIE_TX0_N: length 148.5
  TOP w0.089: U1101.Y22 239,28.92 239,28.48 238.86,28.35 238.86,27.93 238.87,27.92
  TOP w0.114: v2(239.48,20.7) 239.44,20.74 239.44,21.47 237.03,23.88 237.03,25.94 238.87,27.77 238.87,27.92
  IN4 w0.089: v2(189.14,31.47) 189.14,31.83 189.39,32.08 193.93,32.08 196.21,34.36 199.82,34.36 200.75,35.29 202.51,35.29 203.01,34.79 206.41,34.79 206.85,34.35 208.27,34.35 211.48,31.14 211.48,28.65 220.12,20.02 239.17,20.02 239.37,20.21 239.37,20.59 v2(239.48,20.7)
  BOTTOM w0.114: C2001.1 151.64,48.15 151.54,48.05 148.89,48.05 146.58,45.74 146.58,37.03 145.99,36.44 145.99,33.83 146.74,33.09 146.74,32.55 149.69,29.6 152.65,29.6 ; 152.65,29.6 153.35,29.6 156.17,26.78 158.04,26.78 162.69,22.13 188.52,22.13 191.01,24.63 191.01,27.42 189,29.43 189,31.33 v2(189.14,31.47) ; 152.65,29.6 v1(152.65,29.38)
TBT_PCIE_TX0_N_C: length 10.9
  BOTTOM w0.089: U2000.D22 160.87,52.78 159.95,52.78 159.91,52.74 157.02,52.74 157.01,52.72 156.99,52.72 156.96,52.69 156.92,52.69 156.91,52.69
  BOTTOM w0.114: C2001.2 153.23,48.15 154.84,49.76 154.84,50.61 156.91,52.69
TBT_PCIE_TX0_P: length 148.3
  TOP w0.089: 238.63,27.92 238.63,27.93 238.67,27.96 238.67,28.32 238.66,28.34 238.54,28.46 238.54,28.82 238.61,28.88 238.71,28.88 238.77,28.83 U1101.Y23
  TOP w0.114: 238.63,27.92 238.63,27.87 236.8,26.03 236.8,23.78 239.2,21.38 239.2,21.02 238.89,20.71 v2(238.82,20.71)
  IN4 w0.089: v2(188.53,31.47) 189.32,32.26 193.86,32.26 196.14,34.54 199.75,34.54 200.68,35.47 202.58,35.47 203.08,34.97 206.49,34.97 206.93,34.53 208.34,34.53 211.66,31.21 211.66,28.73 220.19,20.19 239.1,20.19 239.19,20.28 239.19,20.41 238.89,20.71 v2(238.82,20.71)
  BOTTOM w0.114: 150.88,29.84 v1(150.88,30.06) ; 150.88,29.84 153.45,29.84 156.27,27.02 158.14,27.02 162.79,22.37 188.42,22.37 190.77,24.73 190.77,27.33 188.77,29.33 188.77,31.23 v2(188.53,31.47) ; 150.88,29.84 149.78,29.84 146.97,32.65 146.97,33.18 146.23,33.93 146.23,36.34 146.82,36.93 146.82,45.64 148.99,47.81 151.49,47.81 151.56,47.74 151.56,47.35 151.66,47.26 C2000.1
TBT_PCIE_TX0_P_C: length 11
  BOTTOM w0.089: 157.08,52.52 157.1,52.54 159.98,52.54 160.03,52.59 160.61,52.59 160.68,52.52 U2000.C22
  BOTTOM w0.114: 157.08,52.52 155.07,50.52 155.07,49.66 153.39,47.98 153.39,47.37 153.28,47.26 C2000.2
TBT_PCIE_TX1_N: length 146.1
  TOP w0.089: U1101.T22 240.38,28.92 240.38,28.45 240.52,28.31 240.52,27.85 240.47,27.8
  TOP w0.114: v2(240.69,20.44) 240.69,22.59 240.19,23.09 240.19,26.91 240.47,27.18 240.47,27.8
  IN4 w0.089: v2(240.69,20.44) 240.69,20.71 240.08,21.32 235.47,21.32 234.6,22.19 218.92,22.19 214.59,26.52 214.59,30.24 212.92,31.92 212.92,33.47 211.27,35.12 207.21,35.12 206.44,35.88 200.51,35.88 199.6,34.97 194.74,34.97 194.23,34.46 189.46,34.46 188.34,33.34 188.34,33.01 188.57,32.77 v2(188.58,32.77)
  BOTTOM w0.114: 149.58,31.65 148.58,31.65 147.53,32.7 147.53,33.44 146.7,34.26 146.7,36.05 147.24,36.59 147.24,45.35 148.47,46.58 149.31,46.58 C2014.1 ; 149.58,31.65 150.07,31.65 151.46,30.26 153.63,30.26 156.36,27.53 158.34,27.53 163.08,22.79 188.07,22.79 190.35,25.06 190.35,26.3 188.11,28.55 188.11,31.68 188.51,32.08 188.51,32.71 188.57,32.77 v2(188.58,32.77) ; 149.58,31.65 v1(149.58,31.43)
TBT_PCIE_TX1_N_C: length 13.4
  BOTTOM w0.114: C2014.2 150.95,46.4 153.15,46.4 153.68,46.93 153.68,47.69 155.5,49.51 155.5,50.48 157.37,52.35 U2000.B22
TBT_PCIE_TX1_P: length 146
  TOP w0.089: 240.71,27.75 240.71,28.34 240.84,28.47 240.84,28.81 240.77,28.87 240.65,28.87 240.61,28.83 U1101.T23
  TOP w0.114: 240.71,27.75 240.71,27.09 240.43,26.81 240.43,23.19 240.93,22.69 240.93,20.84 241.13,20.64 241.2,20.64 v2(241.37,20.47)
  IN4 w0.089: v2(241.37,20.47) 241.01,20.83 240.82,20.83 240.15,21.5 235.54,21.5 234.67,22.37 219,22.37 214.77,26.59 214.77,30.32 213.09,32 213.09,33.54 211.34,35.29 207.28,35.29 206.51,36.06 200.44,36.06 199.52,35.15 194.67,35.15 194.16,34.64 189.39,34.64 188.16,33.41 188.16,32.97 187.97,32.77 187.97,32.78 v2(187.97,32.78)
  BOTTOM w0.114: v1(187.65,30.65) 187.87,30.65 ; 187.87,30.65 187.87,28.45 190.11,26.21 190.11,25.16 187.97,23.02 163.18,23.02 158.44,27.76 156.45,27.76 153.72,30.49 151.56,30.49 150.17,31.89 148.68,31.89 147.76,32.8 147.76,33.54 146.94,34.36 146.94,35.96 147.47,36.49 147.47,45.25 148.57,46.35 149.25,46.35 C2015.1 ; 187.87,30.65 187.87,31.78 188.27,32.18 188.27,32.47 187.97,32.77 187.97,32.78 v2(187.97,32.78)
TBT_PCIE_TX1_P_C: length 13.3
  BOTTOM w0.114: U2000.A23 159.65,52.11 159.49,52.11 159.34,51.96 159.16,51.96 159.01,52.11 158.82,52.11 158.67,51.96 158.54,51.96 158.39,52.11 158.24,52.11 158.12,51.99 157.99,51.99 157.86,52.11 157.47,52.11 155.73,50.38 155.73,49.42 153.91,47.59 153.91,46.83 153.24,46.16 151.01,46.16 150.83,45.99 C2015.2
TBT_PCIE_TX2_N: length 143.4
  TOP w0.089: U1101.M22 242.68,28.92 242.68,28.45 242.55,28.32 242.55,27.81 242.59,27.76
  TOP w0.114: 242.59,27.76 242.59,27.08 242.74,26.94 242.74,23.48 243.6,22.62 243.6,21.81 243.91,21.5 243.94,21.5 243.97,21.46 v2(243.97,21.43)
  IN4 w0.089: v2(243.97,21.43) 243.71,21.7 243.71,21.76 243.38,22.08 236.18,22.08 235.31,22.95 220.74,22.95 218.3,25.39 218.3,27.35 215.78,29.87 215.78,33.04 215.11,33.71 214.05,33.71 211.08,36.67 209.22,36.67 208.79,36.24 207.23,36.24 206.83,36.64 200.2,36.64 199.34,35.78 194.49,35.78 193.98,35.27 188.78,35.27 186.72,33.21 186.72,32.65 186.43,32.35 186.43,31.8 186.19,31.56 v2(186.19,31.55)
  BOTTOM w0.114: v1(156.13,29.94) 156.13,29.68 ; 156.13,29.68 155.58,29.68 154.12,31.15 152.03,31.15 148.13,35.04 148.13,44.85 148.66,45.37 149.07,45.37 149.22,45.22 151.42,45.22 151.54,45.1 151.54,44.8 151.62,44.72 C2016.1 ; 156.13,29.68 160.45,29.68 161.6,28.54 161.6,25.62 163.54,23.68 181.63,23.68 183.13,25.19 183.13,28.05 184.41,29.33 184.86,29.33 186.33,30.8 186.33,31.42 v2(186.19,31.55)
