# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GSENSOR_INT1_PCH: length 185.3
  TOP w0.102: v2(166.11,45.76) 165.31,44.97 165.31,43.23 161.89,39.81 160.79,39.81 v1(160.5,39.51) 160.03,39.04 160.03,34.52 R2246.2 ; R5805.1 255.58,126.63 v2(255.83,126.89)
  IN2 w0.102: v2(166.11,45.76) 166.11,45.67 166.42,45.35 166.42,43.36 171.14,38.65 180.56,38.65 181.27,39.36 182.23,39.36 183.46,40.59 199.65,40.59 200.49,39.75 203.54,39.75 205.41,41.62 205.41,44.05 206.27,44.9 206.27,47.36 209.92,51.02 209.92,56.65 210.58,57.31 210.58,58.4 213.03,60.85 213.03,61.66 213.54,62.17 214.04,62.17 214.11,62.11 214.67,62.11 215.02,62.46 215.02,64.71 211.58,68.15 211.58,74.5 208.89,77.19 208.89,83.01 210.11,84.23 210.11,84.68 213.12,87.7 215.42,87.7 216.06,88.33 216.83,88.33 217.79,89.3 221.56,89.3 222.92,90.66 222.92,92.04 226.55,95.66 231.06,95.66 233.16,97.77 233.16,110.67 243.1,120.6 251.16,120.6 255.45,124.9 255.45,126.51 v2(255.83,126.89)
  BOTTOM w0.089: v2(166.11,45.76) U2000.R35
GSENSOR_INT2: length 314
  TOP w0.102: R5807.1 v2(255.83,127.52)
  IN2 w0.102: v2(38.46,47.97) 39.12,47.97 44.85,42.24 68.3,42.24 69.17,41.37 92.86,41.37 93.35,40.88 93.35,40.18 93.66,39.87 106.85,39.87 107.05,40.07 112.73,40.07 113.32,39.48 118.85,39.48 119.41,40.05 123.94,40.05 124.14,39.85 134.76,39.85 135.58,39.03 147.64,39.03 149.45,40.84 149.45,41.79 150.05,42.38 152.11,42.38 153.69,40.81 155,40.81 155.35,41.16 155.35,42.13 154.67,42.81 154.67,45.26 155.21,45.8 165.39,45.8 165.76,46.17 167.2,46.17 167.79,45.57 167.79,42.32 171.26,38.85 180.47,38.85 181.19,39.57 182.15,39.57 183.37,40.79 199.74,40.79 200.57,39.95 203.43,39.95 205.21,41.73 205.21,44.19 206.05,45.03 206.05,47.47 209.72,51.14 209.72,56.74 210.38,57.4 210.38,58.49 212.83,60.94 212.83,61.75 213.45,62.37 214.13,62.37 214.19,62.31 214.58,62.31 214.82,62.55 214.82,64.63 211.38,68.07 211.38,74.42 208.69,77.11 208.69,83.1 209.89,84.3 209.89,84.75 213.04,87.9 215.34,87.9 215.97,88.53 216.74,88.53 217.71,89.5 221.48,89.5 222.72,90.74 222.72,92.12 226.46,95.87 230.98,95.87 232.96,97.85 232.96,110.75 243.11,120.91 251.18,120.91 255.24,124.98 255.24,126.94 v2(255.83,127.52)
  BOTTOM w0.102: v2(38.46,47.97) 37.66,47.18 v1(37.66,46.87) 37.7,46.83 R5131.2
GSPI0_CLK_50MHZ: length 8.4
  TOP w0.102: v2(178.34,49.74) 178.86,49.22 179.29,49.22 179.42,49.09 180.88,49.09 181.61,48.35 182.83,48.35 v1(183.06,48.58) 184.15,48.58 R2403.2
  BOTTOM w0.089: v2(178.34,49.74) 178.78,50.17 U2000.AW27
GSPI0_CS#: length 14.5
  TOP w0.102: v2(177.3,51.96) 177.3,51.54 177.51,51.33 v1(177.84,51.33) 178.03,51.15 180.38,51.15 180.79,50.74 181.3,50.74 181.92,50.12 182.42,50.12 182.6,49.94 183.01,49.94 183.82,50.75 183.82,51.17 184.65,52 184.65,52.27 184.93,52.55 186.75,52.55 187.26,52.04 187.53,52.04 R2419.2
  BOTTOM w0.102: U2000.AR24 177.17,51.96 v2(177.3,51.96)
GSPI0_MISO: length 4.7
  BOTTOM w0.089: U2000.BD27 180.93,49.78 181.45,49.27 181.71,49.27 181.9,49.08 182.47,49.08 182.8,49.42 184.71,49.42
  BOTTOM w0.102: 184.71,49.42 R2404.2
GSPI1_CLK: length 10.2
  TOP w0.102: R2418.2 184.76,48.27 v1(184.1,47.62) 183.74,47.62 183.62,47.74 181.36,47.74 180.63,48.48 179.17,48.48 179.04,48.61 178.17,48.61 177.88,48.9 177.42,48.9 v2(177.03,48.51)
  BOTTOM w0.102: v2(177.03,48.51) 177.1,48.51 177.59,49 U2000.AV29
GSPI1_CS#: length 5.1
  BOTTOM w0.089: U2000.BC27 180.59,50.03 180.97,50.03 181.08,49.93 181.12,49.93 182.35,49.93 182.71,50.28 v1(183.57,50.28) 184.71,50.28
  BOTTOM w0.102: 184.71,50.28 184.81,50.28 184.84,50.26 R2400.2
GSPI1_MISO: length 12.1
  TOP w0.102: v2(175.74,48.5) 176.2,48.04 176.28,48.04 176.48,47.85 178.64,47.85 178.77,47.72 179.98,47.72 v1(180.46,47.24) 180.62,47.24 181.94,45.91 183.55,45.91 184.13,46.49 184.13,46.78 184.36,47.01 184.92,47.01 R2401.2
  BOTTOM w0.102: v2(175.74,48.5) 176.24,49 U2000.AR29
GSPI1_MOSI: length 15.6
  TOP w0.102: R2424.2 R2402.2 187.18,47.51 v1(186.92,47.77) 184.83,47.77 184.73,47.67 184.73,47.39 184.56,47.21 184.27,47.21 183.92,46.86 183.92,46.58 183.46,46.12 182.03,46.12 181.17,46.98 181.17,47.15 180.39,47.92 178.87,47.92 178.74,48.05 176.8,48.05 v2(176.35,48.5)
  BOTTOM w0.102: v2(176.35,48.5) 176.85,49 U2000.AT29
H_BPM_N0: length 12.7
  TOP w0.102: v6(22.56,144.53) 22.01,144.53 v1(21.92,144.62) 21.77,144.77 17.78,144.77 17.22,145.33 16,145.33 v2(15.55,144.87)
  BOTTOM w0.102: U0300.BR27 22.56,144.46 v6(22.56,144.53) ; R4407.2 12.88,142.19 12.85,142.22 12.85,142.72 13.14,143.01 13.37,143.01 14.35,143.98 14.35,144.24 14.99,144.87 v2(15.55,144.87)
H_BPM_N0_R: length 7.6
  BOTTOM w0.102: XDP4400.21 10.58,136.35 v1(11.02,136.8) 11.19,136.96 11.19,140.6 12.01,141.42 R4407.1
H_BPM_N1: length 13.5
  TOP w0.102: v1(12.85,141.75) 12.85,141.98 v2(13.26,142.38)
  IN4 w0.102: v6(20.24,144.17) 19.57,143.5 14.37,143.5 v2(13.26,142.38)
  BOTTOM w0.102: v6(20.24,144.17) 20.61,144.54 21.13,144.54 21.27,144.4 21.32,144.4 U0300.BT27 ; v2(13.26,142.38) 13.26,141.46 13.17,141.37 12.8,141.37 12.4,140.96 11.85,140.96 11.61,140.72 R4408.2
H_BPM_N1_R: length 6.2
  BOTTOM w0.102: R4408.1 11.61,138.7 v1(12.19,138.12) 12.19,137.23 10.82,135.85 XDP4400.23
H_CFG0: length 42
  TOP w0.102: R0702.1 23.62,143.2 v6(23.86,142.95) ; v1(12.67,139.39) 12.58,139.49 v2(10.69,139.49)
  IN2 w0.102: v2(10.62,124.7) 11.71,125.8 11.71,130.25 11.23,130.73 11.23,132.07 10.83,132.47 10.83,137.12 11.13,137.41 11.13,139.05 v2(10.69,139.49)
  IN4 w0.102: v6(23.86,142.95) 23.42,143.4 21.51,143.4 21.13,143.78 20.16,143.78 19.68,143.3 15.28,143.3 13.77,141.79 12.92,141.79 12.37,141.23 12.37,141.16 10.7,139.49 v2(10.69,139.49)
  BOTTOM w0.102: XDP4400.9 10.56,139.35 v2(10.69,139.49) ; v6(23.86,142.95) 23.86,142.89 U0300.BN25 ; v2(10.62,124.7) 9.36,123.45 9.36,120.14 R4416.2
H_CFG1: length 31.3
  TOP w0.102: v6(23.86,144.53) 23.47,144.92 23.01,144.92 22.6,145.33 21.69,145.33 21.33,144.97 19.96,144.97 19.76,145.18 R0701.1 17.53,145.41 17.25,145.69 16.36,145.69 16.15,145.89 v2(16.15,146.05) 15.65,146.05 v1(15.52,145.92)
  IN1 w0.102: v2(16.15,146.05) 15.76,146.05 14.72,145.01 14.72,144.53 12.83,142.64 12.83,140.21 8.41,135.79 6.67,135.79 6.15,136.31 v2(6.15,136.47)
  BOTTOM w0.102: v6(23.86,144.53) 23.54,144.2 U0300.BN27 ; v2(6.15,136.47) 6.15,136.68 6.49,137.02 6.49,138.48 6.68,138.68 7.49,138.68 7.67,138.85 XDP4400.11
H_CFG2: length 19.6
  TOP w0.102: R0723.1 22.83,143.33 v6(23.21,142.95) ; v1(10.72,138.14) v2(10.72,138.88)
  IN4 w0.102: v2(10.72,138.88) 10.72,138.9 10.84,138.9 12.57,140.63 12.57,141.15 13.01,141.58 13.86,141.58 15.37,143.09 19.76,143.09 19.79,143.12 20.06,143.12 20.16,143.02 20.48,143.02 20.58,143.12 20.62,143.12 20.72,143.02 21.04,143.02 21.14,143.12 23.05,143.12 v6(23.21,142.95)
  BOTTOM w0.102: v6(23.21,142.95) 23.54,143.28 U0300.BN26 ; XDP4400.15 10.53,137.85 10.72,138.04 10.72,138.89 10.72,138.9 v2(10.72,138.88)
H_CFG3: length 26.1
  TOP w0.102: v6(23.21,144.53) 22.83,144.15 21.73,144.15 21.31,144.57 19.54,144.57 19.13,144.16 R0725.1 17.3,143.7 16.15,143.7 15.27,142.82 12.08,142.82 11.91,142.66 v1(11.35,142.66) 10.74,142.66 10.74,142.65 v2(10.72,142.65)
  IN1 w0.102: v2(6.89,138.25) 6.89,138.64 9.46,141.21 9.46,142.72 9.92,143.18 10.5,143.18 10.72,142.96 v2(10.72,142.65)
  BOTTOM w0.102: v2(10.72,142.65) 10.52,142.85 10.52,143.65 R4422.2 ; v2(6.89,138.25) 6.89,137.67 7.21,137.35 XDP4400.17 ; U0300.BN28 23.54,144.92 23.21,144.6 v6(23.21,144.53)
H_CFG4: length 23.5
  TOP w0.102: v6(20.24,139.41) 19.69,139.97 19.3,139.97 R0724.1
  IN4 w0.102: v2(6.9,135.37) 6.93,135.37 7.34,134.95 11.22,134.95 15.09,138.82 17.7,138.82 18.29,139.41 v6(20.24,139.41)
  BOTTOM w0.102: v6(20.24,139.41) 19.61,139.41 19.53,139.33 v1(19.53,139.08) 19.66,138.95 21.91,138.95 U0300.BR20 ; v2(6.9,135.37) 7.41,134.85 XDP4400.27
H_CFG5: length 28
  TOP w0.102: v6(23.86,138.23) 23.48,138.61 22.96,138.61 22.82,138.75 R0745.2 R0703.1 ; v2(6.27,133.69) 5.84,133.27 v1(5.66,133.27)
  IN4 w0.102: v2(6.27,133.69) 6.29,133.69 7.05,134.45 11.39,134.45 15.21,138.27 21.73,138.27 22.15,137.85 23.48,137.85 v6(23.86,138.23)
  BOTTOM w0.102: v6(23.86,138.23) 24.19,138.56 U0300.BM20 ; v2(6.27,133.69) 6.93,134.35 XDP4400.29
H_CFG6: length 26.1
  IN1 w0.102: v2(15.6,142.16) 14.53,142.16 13.69,141.32 13.69,139.61 8.4,134.32 7.49,134.32 v2(6.88,133.71)
  BOTTOM w0.102: R0744.2 R0705.1 15.31,141.87 v2(15.6,142.16) 16.11,141.65 v1(16.11,141.44) 16.11,139.61 16.69,139.03 18.75,139.03 19.15,138.62 U0300.BT20 ; XDP4400.33 7.91,133.35 7.8,133.24 7.35,133.24 v2(6.88,133.71)
H_CFG7: length 26.6
  TOP w0.102: v2(16.21,142.15) 15.98,142.38 v1(15.98,142.84) 16.41,143.27 17.25,143.27 R0709.1 17.84,142.67 19.97,142.67 20.6,142.05 20.6,141.49 21.2,140.89 21.51,140.89 21.92,140.48 21.92,139.79 22.33,139.39 22.84,139.39 v6(23.21,139.02)
  IN1 w0.102: v2(16.21,142.15) 16.21,141.02 15.98,140.78 14.66,140.78 14.17,140.3 14.17,139.46 v2(7.45,132.74)
  BOTTOM w0.102: v2(7.45,132.74) 7.46,132.74 7.57,132.85 XDP4400.35 ; U0300.BP20 22.89,138.69 v6(23.21,139.02)
H_CFG8: length 25.7
  TOP w0.102: v6(20.98,141.65) 21.13,141.8 v1(21.13,142.36) 20.51,142.98 18.97,142.98 18.8,143.16 R0726.1
  IN4 w0.102: v6(20.98,141.65) 20.22,142.41 19.91,142.41 19.86,142.46 17.1,142.46 16.38,141.74 15.35,141.74 13.92,140.31 13.92,140.15 11.84,138.07 9.05,138.07 8.26,138.86 6.22,138.86 v2(6.07,139.01)
  BOTTOM w0.102: XDP4400.10 5.72,139.35 v2(6.07,139.01) ; U0300.BR23 21.81,141.42 21.21,141.42 v6(20.98,141.65)
H_CFG9: length 22.7
  TOP w0.102: v2(14.73,140.26) 14.73,140.72 v1(14.89,140.88) 15.07,140.7 15.67,140.7 R0700.2 16.09,141.12 R0710.1 17.3,140.25 v2(17.65,140.6)
  IN4 w0.102: v2(5.84,137.81) 6.04,137.62 8.09,137.62 8.15,137.55 12.03,137.55 v2(14.73,140.26)
  BOTTOM w0.102: U0300.BR22 21.9,140.54 21.46,140.54 20.99,141.02 20.03,141.02 19.3,140.29 17.97,140.29 v2(17.65,140.6) ; v2(5.84,137.81) 5.55,138.11 5.05,138.11 4.3,138.85 XDP4400.12
H_CFG10: length 24.3
  TOP w0.102: v2(17.63,141.21) 18.11,141.7 18.11,142.18 18.19,142.25 R0712.1
  IN4 w0.102: v2(17.63,141.21) 17.63,141.26 17.42,141.46 17.03,141.46 16.36,140.79 14.69,140.79 14.33,140.43 14.33,140.27 11.82,137.76 9.04,137.76 8.14,138.65 6.34,138.65 v2(6.08,138.4)
  BOTTOM w0.102: U0300.BT23 21.35,141.23 19.76,141.23 19.27,140.73 v1(18.96,140.73) 18.1,140.73 v2(17.63,141.21) ; XDP4400.16 4.79,137.85 5.25,137.4 6.13,137.4 6.28,137.55 6.28,138.19 v2(6.08,138.4)
H_CFG11: length 23.2
  TOP w0.102: v2(17.68,139.99) 17.98,139.99 18.3,140.32 18.3,140.87 R0714.1 19.22,140.95 19.94,140.95 19.97,140.97 20.49,140.97 v6(20.87,140.6)
  IN4 w0.102: v2(17.68,139.99) 17.14,139.46 14.87,139.46 11.86,136.45 7.28,136.45 v2(6.88,136.84)
  BOTTOM w0.102: XDP4400.18 4.41,137.35 5.71,136.06 6.32,136.06 6.55,136.3 6.55,136.52 v2(6.88,136.84) ; v2(17.68,139.99) 17.5,139.82 v1(16.89,139.82) ; v6(20.87,140.6) 20.88,140.6 20.88,140.54 21.07,140.35 21.44,140.35 U0300.BT22
H_CFG12: length 25.1
  TOP w0.102: v2(6.72,134.74) 7.2,134.27 v1(7.2,134.26) ; v6(24.51,138.23) 24.49,138.2 R0713.1
  IN4 w0.102: v2(6.72,134.74) 11.3,134.74 15.17,138.61 24.13,138.61 v6(24.51,138.23)
  BOTTOM w0.102: v6(24.51,138.23) 24.19,137.91 U0300.BM19 ; v2(6.72,134.74) 6.61,134.85 XDP4400.28
H_CFG13: length 25
  IN1 w0.102: v2(6.3,134.3) 7.17,134.3 7.39,134.52 7.43,134.52 v2(13.26,140.35)
  BOTTOM w0.102: v2(13.26,140.35) 13.26,140.17 R0715.1 13.44,139.41 v1(13.51,139.34) 13.81,139.04 16.05,139.04 18.29,136.8 19.41,136.8 20.04,137.43 21.83,137.43 U0300.BR19 ; v2(6.3,134.3) 5.82,134.3 5.76,134.35 XDP4400.30
H_CFG14: length 27.5
  IN1 w0.102: v2(6.77,132.73) 7.28,133.23 7.61,133.23 13.92,139.55 13.92,140.78 14.33,141.2 v2(15.46,141.2)
  BOTTOM w0.102: v2(15.46,141.2) 14.92,141.2 R0719.1 14.96,140.73 15.55,140.73 15.88,140.4 15.88,139.5 17.08,138.29 v1(17.83,138.29) 22.43,138.29 U0300.BP19 ; XDP4400.34 4.89,133.35 5.11,133.14 6.34,133.14 6.75,132.73 v2(6.77,132.73)
H_CFG15: length 23.2
  TOP w0.102: v6(20.37,137.89) 20.42,137.94 R0718.1
  IN4 w0.102: v6(20.37,137.89) 15.11,137.89 10.38,133.15 6.57,133.15 v2(6.15,132.73)
  BOTTOM w0.102: XDP4400.36 6.02,132.85 v2(6.15,132.73) ; U0300.BT19 21.4,137.65 20.61,137.65 v6(20.37,137.89) 19.88,137.89 v1(19.23,137.23)
H_CFG16: length 24.9
  TOP w0.102: v1(5.82,140.02) 6.26,139.58 6.32,139.58 v2(6.63,139.27)
  IN4 w0.102: v2(6.63,139.27) 6.84,139.06 8.34,139.06 9.13,138.27 11.75,138.27 13.72,140.23 13.72,140.86 15.52,142.66 19.94,142.66 19.99,142.61 21.21,142.61 21.26,142.66 21.28,142.66 v6(22.56,141.38)
  BOTTOM w0.102: U0300.BP23 22.89,141.05 v6(22.56,141.38) ; v2(6.63,139.27) 6.38,139.52 6.38,140.07 6.09,140.35 XDP4400.6
H_CFG17: length 25.6
  TOP w0.102: v2(6.91,139.82) 7.34,139.39 v1(7.34,139.05)
  IN4 w0.102: v6(23.21,141.38) 21.73,142.87 21.17,142.87 21.12,142.81 20.64,142.81 20.6,142.85 20.56,142.81 20.08,142.81 20.02,142.87 15.44,142.87 13.95,141.38 13.09,141.38 12.78,141.06 12.78,139.8 11.45,138.47 9.22,138.47 8.43,139.26 7.47,139.26 v2(6.91,139.82)
  BOTTOM w0.102: U0300.BN23 23.21,141.31 v6(23.21,141.38) ; v2(6.91,139.82) 5.87,140.85 XDP4400.4
H_CFG18: length 23.7
  TOP w0.102: v2(6.29,135.35) 5.88,135.76 v1(5.64,135.76)
  IN4 w0.102: v2(6.29,135.35) 6.72,135.78 11.76,135.78 15.01,139.02 17.61,139.02 18.78,140.18 22.41,140.18 22.41,140.19 22.72,140.19 22.73,140.18 22.83,140.18 v6(23.21,139.8)
  BOTTOM w0.102: XDP4400.24 4.75,135.85 5.26,135.35 v2(6.29,135.35) ; v6(23.21,139.8) 23.54,140.13 U0300.BN22
H_CFG19: length 23.7
  TOP w0.102: v2(6.95,136.19) 7.03,136.11 v1(7.65,136.11)
  IN4 w0.102: v6(23.21,140.59) 22.04,140.59 21.65,140.98 19.28,140.98 17.56,139.26 14.95,139.26 11.89,136.19 v2(6.95,136.19)
  BOTTOM w0.102: v2(6.95,136.19) 6.54,135.79 5.31,135.79 4.74,136.35 XDP4400.22 ; v6(23.21,140.59) 22.89,140.27 U0300.BP22
H_PECI_EC: length 241.4
  TOP w0.114: v2(106.35,58.87) 106.57,58.65 109.7,58.65 110.31,59.26 117.92,59.26 v2(118.02,59.16) ; v2(121.5,39.43) 121.5,39.01 121.65,38.86 123.02,38.86 123.31,39.15 U3001.117
  IN1 w0.076: v6(19.26,152.05) 19.6,152.05 20.12,151.53 22.11,151.53 24.23,149.4 24.23,146.74 23.64,146.14 23.05,146.14 21.81,144.9 21.81,138.73 19.32,136.24 19.32,133.73 15.16,129.58 15.16,129.05 13.75,127.64 13.04,127.64 12.04,126.64 11.13,126.64 9.76,125.26 9.76,90.83 11.39,89.2 13.58,89.2 15.78,86.99 17.75,86.99 19.09,85.65 20.26,85.65 28.86,77.06 28.86,72.82 34.01,67.66 34.01,66.59 34.72,65.88 48.27,65.88 55.14,59.01 65.44,59.01 66.1,59.67 71.92,59.67 73.12,58.47 83.16,58.47 84.9,60.2 88.12,60.2 88.75,59.57 94.19,59.57 94.74,60.11 96.37,60.11 97.21,59.28 98.19,59.28 98.62,58.84 106.2,58.84 106.22,58.87 v2(106.35,58.87)
  BOTTOM w0.114: v2(121.5,39.43) 122.75,40.67 122.75,43.17 v1(123.16,43.59) 124.03,44.46 124.03,50.13 124.96,51.05 124.96,52.07 123.22,53.81 115,53.81 114.1,54.7 114.1,56.74 114.48,57.12 115.74,57.12 117.79,59.16 v2(118.02,59.16) ; v6(19.26,152.05) 19.25,152.06 19.25,153.2 18.4,154.05 18.4,154.28 18.24,154.45 R0733.1
H_PRDY#: length 262.4
  TOP w0.102: v1(11.46,140.71) 11.28,140.71 v2(10.69,140.12)
  IN1 w0.102: v2(16.18,85.3) 16.26,85.23 16.26,84.94 17.88,83.32 20.67,83.32 25.89,78.1 25.89,75.39 27.5,73.79 27.5,70.38 31.94,65.95 32.72,65.95 34.16,64.51 38.25,64.51 38.92,63.85 48.35,63.85 50.11,62.08 50.11,59.54 52.64,57.01 98.58,57.01 99.01,57.44 107.23,57.44 109.08,59.29 115.02,59.29 115.38,59.65 121.74,59.65 122.13,60.04 127.03,60.04 127.62,60.62 132.36,60.62 132.76,61.02 135.92,61.02 136.12,61.22 136.12,63.11 136.37,63.36 136.85,63.36 137.14,63.07 145.74,63.07 149.25,66.58 152.2,66.58 153.53,67.91 157.12,67.91 157.82,68.61 168.96,68.61 170.23,69.89 176.15,69.89 176.67,70.41 v2(176.67,71.3)
  IN2 w0.102: v2(10.69,140.12) 10.16,139.59 10.16,120.78 11.02,119.91 11.02,117.26 16.51,111.77 16.51,85.63 v2(16.18,85.3)
  IN4 w0.102: v2(10.69,140.12) 12.26,141.68 12.26,142.9 13.82,144.46 17.24,144.46 17.44,144.67 20.35,144.67 v6(20.85,144.16)
  BOTTOM w0.102: v6(20.85,144.16) 21.21,143.81 22.56,143.81 U0300.BP27 ; XDP4400.5 10.46,140.35 v2(10.69,140.12) ; v2(176.67,71.3) 176.9,71.06 177.34,71.06 R2325.2
H_PREQ#: length 22.8
  BOTTOM w0.102: XDP4400.3 10.21,140.85 10.5,141.15 10.71,141.15 11.63,142.08 11.63,142.2 R4403.1 13.3,143.22 14.15,144.07 14.15,144.51 14.97,145.33 15.37,145.33 v1(15.64,145.61) 15.75,145.71 15.75,148.11 16.17,148.54 16.55,148.54 R0738.2 17.2,148.43 17.94,148.43 18.14,148.22 18.14,147.67 18.94,146.86 18.97,146.86 19.2,146.64 19.2,146.61 19.65,146.15 19.65,146.1 19.87,145.87 21.06,145.87 21.25,146.06 24.52,146.06 U0300.BL30
H_TCK: length 268.6
  TOP w0.102: v2(10.34,86.78) 10.22,86.66 v1(10.22,85.97) 11.15,85.97 v2(11.28,86.1)
  IN1 w0.102: v2(176.45,71.89) 176.25,71.7 176.25,70.5 175.84,70.09 170.15,70.09 168.87,68.82 157.74,68.82 157.03,68.11 153.45,68.11 152.12,66.78 149.17,66.78 145.66,63.27 139.09,63.27 135.89,66.47 130.63,66.47 124.39,60.24 122.04,60.24 121.66,59.85 110.93,59.85 110.68,60.11 109.2,60.11 108.02,58.92 108.02,58.52 107.15,57.65 98.93,57.65 98.49,57.22 55.3,57.22 48.34,64.18 38.9,64.18 38.36,64.71 34.24,64.71 32.81,66.15 32.02,66.15 27.7,70.47 27.7,73.87 26.09,75.48 26.09,78.18 20.76,83.52 18.81,83.52 16.55,85.78 15.58,85.78 15.27,86.1 v2(11.28,86.1) ; v6(19.69,144.17) 19.48,143.97 19.48,138.11 18.35,136.98 18.35,134.12 12.11,127.88 10.87,127.88 v2(10.77,127.79) 10.6,127.62 10.34,127.62 7.75,125.02 7.75,123.82 8.79,122.78 8.79,101.62 9.2,101.21 9.2,97.88 8.9,97.59 8.9,90.27 9.77,89.4 9.77,87.36 v2(10.34,86.78)
  BOTTOM w0.102: R2346.2 176.51,70.68 176.38,70.81 176.38,70.98 176.25,71.1 176.25,71.7 v2(176.45,71.89) ; U0300.BR28 21.91,144.59 21.35,144.59 21.19,144.75 18.56,144.75 R0741.1 17.75,144.98 18.19,144.54 19.31,144.54 v6(19.69,144.17) ; XDP4400.57 10.34,127.35 v2(10.77,127.79)
H_TDI: length 280.3
  TOP w0.102: v2(8.59,88.46) 9.55,87.5 9.55,85.31 v2(10.48,84.38) ; R0737.2 20.45,150.23 v6(20.45,150.08) 21.13,149.39 21.13,148.28 21.35,148.06 24.09,148.06 24.67,147.48 v6(25.36,147.48) ; v2(5.71,127.54) 5.48,127.54 v1(4.87,126.93)
  IN1 w0.102: v2(10.48,84.38) 11.14,85.05 11.42,85.05 11.86,85.49 15.41,85.49 17.81,83.1 20.6,83.1 25.69,78.02 25.69,75.31 27.3,73.7 27.3,70.28 31.83,65.74 32.64,65.74 34.08,64.31 38.17,64.31 38.83,63.64 48.26,63.64 49.91,61.99 49.91,59.45 52.55,56.81 98.66,56.81 99.09,57.24 107.32,57.24 109.14,59.06 116.76,59.06 117.68,58.15 118.88,58.15 119.96,59.23 121.89,59.23 122.25,59.58 127.21,59.58 127.86,58.93 131.25,58.93 132.93,60.61 136.37,60.61 137.9,62.15 140.44,62.15 141.15,62.86 145.86,62.86 149.35,66.36 152.27,66.36 153.62,67.71 157.2,67.71 157.91,68.41 169.13,68.41 169.35,68.19 175.58,68.19 v2(176.01,68.61) ; v6(20.45,150.08) 19.51,149.14 19.51,148.52 17.62,146.63 17.62,146.26 18.49,145.39 18.49,138.69 17.74,137.94 14.62,137.94 9.83,133.14 9.83,129.67 7.71,127.54 v2(5.71,127.54) 5.05,127.54 4.83,127.31 4.83,126.06 6.11,124.78 6.11,124.42 7.27,123.27 7.27,122.65 8.03,121.89 8.03,89.02 v2(8.59,88.46)
  BOTTOM w0.102: v2(176.01,68.61) 176.35,68.26 R2345.1 ; U0300.BL32 25.29,147.48 v6(25.36,147.48) ; XDP4400.56 5.4,127.85 v2(5.71,127.54)
H_TDO: length 273.3
  TOP w0.102: v2(5.73,128.77) 5.73,128.82 5.64,128.72 v1(5.07,128.72)
  IN1 w0.102: v2(16.99,146.17) 18.08,145.08 18.08,138.86 17.57,138.34 14.45,138.34 9.42,133.31 9.42,129.83 8.41,128.82 5.75,128.82 5.73,128.81 ; 5.73,128.81 5.72,128.82 5.08,128.82 4.42,128.16 4.42,125.89 5.64,124.68 5.64,122.53 7.32,120.85 7.32,88.58 8.48,87.41 8.48,86.4 8.71,86.17 10.74,86.17 11.07,86.5 15.15,86.5 15.65,86 16.61,86 18.89,83.72 20.84,83.72 26.3,78.27 26.3,75.56 27.9,73.96 27.9,72.42 32.96,67.36 32.96,66.29 34.34,64.91 47.89,64.91 55.38,57.42 98.41,57.42 98.84,57.85 106.77,57.85 107.81,58.89 107.81,59 109.12,60.31 110.76,60.31 111.02,60.06 121.57,60.06 121.96,60.44 124.31,60.44 130.54,66.68 135.97,66.68 139.18,63.47 143.26,63.47 144.31,64.52 146.62,64.52 149.09,66.98 152.03,66.98 153.36,68.31 156.93,68.31 157.64,69.02 168.79,69.02 170.06,70.3 174.8,70.3 v2(175.77,71.27) ; 5.73,128.81 v2(5.73,128.77)
  BOTTOM w0.102: v2(5.73,128.77) 5.73,128.82 5.7,128.85 XDP4400.52 ; v2(16.99,146.17) 16.83,146.33 R0739.2 17.47,146.44 17.47,146.43 17.92,145.98 18.04,145.98 19.02,145 21.21,145 21.29,144.92 U0300.BT28 ; v2(175.77,71.27) 175.77,71.25 175.95,71.07 R2344.2
H_THMTRIP#: length 187.9
  TOP w0.114: v2(68.28,128.14) 67.71,127.57 67.71,123.37 70.32,120.76 72.09,120.76 73.15,119.7 77.29,119.7 80.64,116.35 80.64,113.72 83.14,111.22 91.74,111.22 93.45,109.51 96.32,109.51 97.28,108.55 97.28,106.44 97.51,106.21 v2(98.68,106.21) ; v2(157.05,87.51) 157.05,85.9 159.26,83.7 159.26,79.08 160.33,78.02 v1(160.33,77.64) 160.32,77.64 160.32,72.59 160.95,71.96 163.78,71.96 165.64,73.82 170.17,73.82 170.87,73.12 170.87,69.78 v2(170.31,69.23)
  IN1 w0.076: v2(157.05,87.51) 157.05,87.51 154.91,89.65 149.05,89.65 148.26,88.87 143.32,88.87 142.39,87.94 139.84,87.94 138.76,86.86 137.9,86 123.26,86 120.46,83.2 118.49,83.2 117.53,84.16 114.05,84.16 113.26,84.95 113.26,87.84 98.68,102.42 v2(98.68,106.21)
  IN2 w0.114: v6(57.64,147.49) 57.85,147.7 58.44,147.7 59.38,146.76 59.61,146.76 60.63,145.73 60.63,143.64 61.33,142.94 63.32,142.94 63.77,142.5 69.1,142.5 70.45,141.14 70.45,131.8 68.28,129.63 v2(68.28,128.14)
  BOTTOM w0.114: v6(57.64,147.49) 57.31,147.16 U0300.J31 ; R2454.2 169.94,68.46 169.94,68.93 169.6,69.27 R2450.2 169.73,69.81 v2(170.31,69.23)
H_TMS: length 276.7
  TOP w0.102: v2(11.14,84.39) 10.72,83.97 10.31,83.97 9.09,85.19 v2(9.09,86.81) ; v2(5.69,126.92) 6.45,126.92 v1(6.68,126.69)
  IN1 w0.102: v2(177.02,68.59) 177.02,68.59 176.21,67.78 169.08,67.78 168.86,68 158.07,68 157.37,67.3 153.79,67.3 152.44,65.95 149.52,65.95 146.03,62.46 142.92,62.46 141.98,61.51 138.42,61.51 136.33,59.43 132.58,59.43 131.41,58.26 122.61,58.26 122.09,57.74 117.51,57.74 116.59,58.65 109.3,58.65 107.48,56.83 99.26,56.83 98.83,56.4 41.14,56.4 39.01,58.53 39.01,62.88 38,63.9 33.91,63.9 32.47,65.34 31.66,65.34 26.89,70.11 26.89,73.53 25.28,75.14 25.28,77.85 20.51,82.61 12.29,82.61 11.74,83.16 11.74,83.3 11.14,83.91 v2(11.14,84.39) ; v2(18.02,146.45) 18.69,145.78 18.69,138.61 17.82,137.73 14.71,137.73 10.09,133.12 10.09,129.64 7.37,126.92 v2(5.69,126.92) 5.28,126.92 5.16,126.8 5.16,126.01 6.32,124.85 6.32,124.5 7.47,123.35 7.47,122.8 8.51,121.76 8.51,101.61 8.99,101.13 8.99,97.96 8.7,97.67 8.7,90.18 9.17,89.71 9.17,86.89 v2(9.09,86.81)
  BOTTOM w0.102: v2(18.02,146.45) 17.67,146.8 R0736.2 18.14,147.08 18.43,146.78 18.43,146.32 19.5,145.25 22.56,145.25 U0300.BP28 ; R2343.1 177.02,68.03 v2(177.02,68.59) ; v2(5.69,126.92) 5.25,127.35 XDP4400.58
H_TRIGIN: length 282.8
  TOP w0.102: v2(27.02,99.85) v1(27.02,97.71) 27.02,97.48 27.13,97.36 27.13,95.62 28.02,94.73 28.02,86.04 27.46,85.49 20.06,85.49 v2(18.95,84.38)
  IN1 w0.102: v2(18.95,84.38) 19.37,83.96 20.89,83.96 26.5,78.35 26.5,75.65 28.11,74.04 28.11,72.51 33.17,67.45 33.17,66.37 34.42,65.12 47.97,65.12 55.47,57.62 98.33,57.62 98.76,58.05 106.69,58.05 107.61,58.98 107.61,59.09 109.04,60.51 110.97,60.51 111.23,60.26 121.49,60.26 121.87,60.65 124.23,60.65 130.46,66.88 136.06,66.88 139.26,63.68 143.17,63.68 144.22,64.72 146.54,64.72 149.02,67.21 151.9,67.21 153.21,68.52 156.85,68.52 157.55,69.22 168.67,69.22 169.95,70.5 171.2,70.5 172.24,71.54 v2(172.24,71.87)
  IN3 w0.102: v6(56.44,140.63) 57,140.07 57,138.75 57.56,138.19 57.56,134.94 58.85,133.65 61.24,133.65 61.67,133.22 61.67,128.8 62.51,127.96 63.53,127.96 65,126.49 65,115.08 63.27,113.35 63.27,111.59 63.83,111.03 63.83,108.99 63.59,108.75 48.75,108.75 47.68,109.82 42.46,109.82 41.17,108.53 35.69,108.53 v2(27.02,99.85)
  BOTTOM w0.102: v2(172.24,71.87) 172.39,71.72 R2326.2 ; v6(56.44,140.63) 56.63,140.82 57.22,140.82 U0300.H23
H_TRIGOUT: length 205.5
  TOP w0.102: v2(90.86,110.12) 83.32,110.12 79.93,113.51 79.93,116.1 77.13,118.89 72.86,118.89 71.74,120.01 69.77,120.01 67.23,122.55 63.35,122.55 58.49,127.41 58.49,132.2 58.14,132.55 57.58,132.55 56.7,133.44 56.7,133.88 57,134.18 57,134.71 57.3,135.02 57.3,137.29 v1(56.72,137.87) 56.9,138.04 56.9,138.61 56.63,138.88 55.96,138.88 55.68,139.16 R0743.1
  IN1 w0.102: v2(113.36,55.69) 114.07,54.98 123.45,54.98 123.85,55.39 135.22,55.39 135.68,55.85 139.56,55.85 140.25,56.54 141.66,56.54 144.22,59.1 145.61,59.1 146.21,59.7 150.51,59.7 154,63.19 155.04,63.19 155.74,63.9 157.97,63.9 158.88,64.81 168.26,64.81 168.86,65.41 170.8,65.41 171.32,64.89 v2(172.52,64.89)
  IN4 w0.102: v2(90.86,110.12) 91.87,109.1 94.09,109.1 94.54,108.65 94.54,105.15 107.79,91.9 107.79,84.91 109.47,83.23 111.98,83.23 113.6,81.61 113.6,78.82 116.16,76.26 121.29,76.26 124.49,73.07 124.49,65.12 124.3,64.93 121.77,64.93 121.33,64.49 121.33,64.06 121.67,63.72 121.67,63.09 121.48,62.9 121.48,60.21 118.26,57 114.66,57 v2(113.36,55.69)
  BOTTOM w0.121: U2000.AK1 173.93,63.73 172.77,64.89 v2(172.52,64.89)
H_TRST#: length 287.7
  TOP w0.102: v2(11.76,84.39) 11.89,84.52 v1(11.89,85.38) 11.89,86.14 v2(10.92,87.11) ; v2(177.02,69.24) 177.85,68.41 R2322.1
  IN1 w0.102: v2(177.02,69.24) 176.93,69.24 176.45,68.76 176.45,68.48 175.96,67.99 169.16,67.99 168.94,68.21 157.99,68.21 157.28,67.5 153.7,67.5 152.35,66.15 149.43,66.15 145.94,62.66 141.24,62.66 140.52,61.94 137.99,61.94 136.46,60.41 133.02,60.41 131.33,58.73 127.78,58.73 127.13,59.38 122.33,59.38 121.97,59.02 120.04,59.02 118.96,57.94 117.59,57.94 116.68,58.86 109.22,58.86 107.4,57.04 99.18,57.04 98.75,56.61 41.23,56.61 39.22,58.62 39.22,62.97 38.08,64.1 33.99,64.1 32.55,65.54 31.74,65.54 27.09,70.19 27.09,73.62 25.48,75.23 25.48,77.93 20.56,82.86 17.76,82.86 15.37,85.25 11.91,85.25 11.68,85.03 11.68,84.47 v2(11.76,84.39) ; v2(10.92,87.11) 10.92,86.71 10.59,86.38 8.8,86.38 8.69,86.49 8.69,87.5 7.52,88.66 7.52,122.1 7.06,122.56 7.06,123.18 5.91,124.34 5.91,124.7 4.63,125.98 4.63,127.8 4.98,128.15 v2(5.71,128.15) 8.03,128.15 9.63,129.75 9.63,133.23 14.54,138.14 17.65,138.14 18.29,138.77 18.29,145.23 17.4,146.12 17.4,146.7 19.3,148.6 19.3,150.63 18.84,151.09 18.77,151.09 v6(18.59,151.27)
  BOTTOM w0.102: XDP4400.54 5.52,128.35 5.72,128.15 v2(5.71,128.15) ; U0300.BP30 22.56,146.82 22.25,146.82 21.92,147.15 21.92,147.38 21.72,147.58 21.47,147.58 21.31,147.74 20.33,147.74 19.48,148.58 19.48,150.67 19.26,150.89 18.97,150.89 v6(18.59,151.27) 18.59,151.6 18.31,151.88 17.78,151.88 17.7,151.96 R0740.1
HDA_AZRST#_L500MIL: length 10.5
  BOTTOM w0.089: 182.44,60.4 182.44,60.23 181.56,59.35 U2000.BD8
  BOTTOM w0.102: 182.44,60.4 182.44,60.55 183.31,61.41 183.31,62.43 183.76,62.88 183.76,63.64 v1(184.39,64.27)
  BOTTOM w0.114: R2306.2 185.73,66.13 185.73,65.88 184.51,64.66 184.51,64.39 v1(184.39,64.27)
HDA_BCLK: length 187.2
  TOP w0.114: R3616.2 28.23,67.5 v1(28.23,66.64) 28.23,65 26.95,63.72 26.95,59.98 30.86,56.07 30.86,54.53 32.56,52.83 45.12,52.83 45.45,52.49 45.45,52.2 v2(45.87,51.78)
  IN1 w0.076: v2(45.87,51.78) 45.9,51.78 46.28,52.16 46.28,52.51 47.24,53.47 50.63,53.47 51.94,52.17 61.91,52.17 62.27,51.81 63.85,51.81 64.21,52.17 90.93,52.17 92.06,53.3 100.06,53.3 101.86,55.11 109.06,55.11 110.88,56.93 115.88,56.93 116.79,56.01 122.93,56.01 123.34,56.43 134.81,56.43 135.26,56.88 137.93,56.88 140.43,59.37 142.28,59.37 143.64,60.73 149.99,60.73 154.18,64.92 157.49,64.92 158.4,65.84 167.73,65.84 168.85,66.96 178.85,66.96 180.16,68.27 180.16,69.61 180.9,70.35 183.72,70.35 184.56,71.19 184.56,71.75 v2(184.69,71.89)
  BOTTOM w0.114: v2(184.69,71.89) 184.92,71.89 185.42,71.39 185.42,70.25 C2301.1 186.07,69.6 186.07,68.49 185.85,68.27 R2301.1
HDA_BCLK_R: length 7.3
  TOP w0.114: U3600.6 23.46,69.31 24,68.77 24,68.3 24.25,68.05 25.4,68.05 25.68,68.33 C3629.1 26.46,68.74 v1(26.81,68.39) 27.14,68.72 R3616.1
HDA_BITCLK_24MHZ_L500MIL: length 11.5
  BOTTOM w0.089: 184.71,65.2 183.57,64.06 183.57,62.95 183.12,62.5 183.12,61.49 182.25,60.62 182.25,60.3 181.55,59.6 180.37,59.6 179.91,59.14 179.74,59.14 U2000.BA9
  BOTTOM w0.114: R2301.2 185.34,66.64 185.34,65.84 184.71,65.2
HDA_RST#: length 243.1
  TOP w0.114: Q3601.5 2.72,70.04 2.46,70.29 1.73,70.29 1.32,70.71 1.32,79.47 3.03,81.18 5.11,81.18 v1(5.99,82.06) 6.32,82.38 22.23,82.38 22.79,81.82 22.79,76.16 22.99,75.95 23.59,75.95 23.73,75.81 23.73,74.44 23.3,74.01 C3626.1 ; C3626.1 22.92,73.76 22.92,71.7 22.52,71.31 U3600.11 ; C3626.1 23.55,73.62 23.55,72.6 24.64,71.51 26.2,71.51 26.6,71.91 26.98,71.91 29.45,69.44 29.45,65.18 27.67,63.41 27.67,60.28 31.58,56.37 31.58,54.83 32.86,53.55 45.91,53.55 46.74,52.71 v2(46.74,52.42)
  IN1 w0.076: v2(46.74,52.42) 47.3,52.98 50.52,52.98 51.53,51.97 61.82,51.97 62.18,51.61 63.93,51.61 64.3,51.97 91.02,51.97 91.45,52.41 99.45,52.41 101.95,54.9 109.15,54.9 110.97,56.72 115.79,56.72 116.71,55.81 123.02,55.81 123.44,56.22 134.89,56.22 135.34,56.67 139.09,56.67 141.58,59.17 142.37,59.17 143.72,60.53 150.17,60.53 153.65,64.01 154.69,64.01 155.4,64.72 157.57,64.72 158.49,65.64 167.81,65.64 168.93,66.75 178.94,66.75 180.37,68.18 180.37,69.53 180.98,70.14 184.4,70.14 185.45,71.19 185.45,71.8 v2(185.52,71.87)
  BOTTOM w0.114: v2(185.52,71.87) 185.83,71.87 186.28,71.42 186.28,70.28 C2300.1 R2306.1
HDA_SDI0: length 195.9
  TOP w0.114: v2(184.07,71.87) 183.57,71.87 v1(183.44,72) ; v2(45.87,52.42) 45.22,53.07 32.66,53.07 31.1,54.63 31.1,56.17 27.19,60.08 27.19,63.62 28.96,65.39 28.96,67.65 R3613.1
  IN1 w0.076: v2(45.87,52.42) 45.87,52.67 47.18,53.98 53.47,53.98 54.96,52.49 61.87,52.49 62.35,52.01 63.76,52.01 64.13,52.38 90.85,52.38 91.98,53.51 99.97,53.51 101.78,55.31 108.98,55.31 110.8,57.13 115.96,57.13 116.87,56.22 122.83,56.22 123.24,56.63 134.72,56.63 135.17,57.08 137.84,57.08 140.34,59.58 142.2,59.58 143.55,60.93 149.9,60.93 154.1,65.13 157.37,65.13 158.28,66.04 167.64,66.04 168.76,67.16 178.77,67.16 179.96,68.35 179.96,69.73 180.78,70.55 183.02,70.55 183.6,71.14 183.6,71.4 v2(184.07,71.87)
  BOTTOM w0.102: 184.51,65.42 184.51,65.29 183.39,64.17 183.39,63.03 182.94,62.58 182.94,61.57 182.06,60.69 182.06,60.41 181.51,59.85 U2000.BE7
  BOTTOM w0.114: 184.51,65.42 185.02,65.94 185.02,67.12 184.82,67.33 184.82,68.86 184.96,69 C2310.1 184.51,70.27 184.51,71.44 184.07,71.87 v2(184.07,71.87)
HDA_SDO: length 192
  TOP w0.114: v1(181.66,71.9) 182.59,71.9 v2(183.2,71.29) ; U3600.5 22.48,68.91 22.64,69.07 23.36,69.07 23.7,68.73 23.7,68.13 24.34,67.49 26.99,67.49 27.66,66.81 27.66,64.8 26.68,63.82 26.68,59.95 26.71,59.92 26.71,59.88 30.61,55.97 30.61,54.43 32.46,52.59 44.71,52.59 v2(45.01,52.29)
  IN1 w0.076: v2(183.2,71.29) 182.66,70.75 180.69,70.75 179.76,69.82 179.76,68.44 178.68,67.36 168.62,67.36 167.5,66.25 158.2,66.25 157.9,65.95 154.34,65.95 152.4,64.01 149.46,64.01 146.59,61.14 143.47,61.14 142.52,60.19 140.67,60.19 138.58,58.1 133.53,58.1 132.36,56.94 123.26,56.94 122.74,56.42 116.96,56.42 116.04,57.33 109.86,57.33 108.04,55.51 101.69,55.51 99.89,53.71 91.89,53.71 90.77,52.58 64.04,52.58 63.68,52.22 62.44,52.22 61.96,52.7 55.04,52.7 53.55,54.19 46.91,54.19 v2(45.01,52.29)
  BOTTOM w0.114: v2(183.2,71.29) 183.44,71.29 183.64,71.09 183.64,70.25 C2303.1 184.38,69.51 R2308.1
HDA_SDO_L500MIL: length 20.8
  TOP w0.114: v2(184.07,66.05) 184.7,66.68 184.7,67.71 185.04,68.05 185.87,68.05 v1(186.11,68.29) 186.6,68.77 186.6,70.65 186.26,70.98 186.26,71.44 185.95,71.76 185.95,72.05 185.64,72.37 R2378.2 185.06,73.47 D2301.2
  BOTTOM w0.089: 183.2,64.86 183.2,63.22 182.75,62.77 182.75,61.64 181.88,60.77 181.88,60.48 181.54,60.14 181.1,60.14 181.09,60.15 180.23,60.15 U2000.BB7
  BOTTOM w0.114: v2(184.07,66.05) 184.38,66.36 R2308.2 183.96,66.64 183.52,66.19 183.52,65.18 183.2,64.86
HDA_SPKR_LN: length 33.8
  TOP w0.203: U3600.43 19.5,65.01 19.35,64.86 19.22,64.86 v2(18.9,64.53)
  IN4 w0.508: 12.51,64.94 12.51,64.73 13.27,63.97 18.51,63.97 18.9,64.37 v2(18.9,64.53)
  IN4 w0.762: 11.88,78.89 11.48,78.49 10.8,78.49 9.07,76.75 9.07,75.14 7.37,73.45 7.37,68.82 8.05,68.15 10,68.15 12.51,65.63 12.51,64.94
  BOTTOM w0.762: 13.26,79.97 13.26,81.77 15.29,83.8
  vias: v1(12.89,79.4) v2(12.24,79.27)
HDA_SPKR_LP: length 35.7
  IN4 w0.508: 11.5,64.94 11.5,64.87 11.63,64.75 11.63,64.57 11.75,64.44 11.75,64.41 12.95,63.21 18.82,63.21 19.66,64.05 19.66,64.91 19.11,65.47 v2(19,65.47)
  IN4 w0.762: 11.63,80.08 11.06,79.5 10.38,79.5 8.05,77.17 8.05,75.56 6.36,73.87 6.36,68.4 7.63,67.13 9.58,67.13 11.5,65.21 11.5,64.94
  BOTTOM w0.762: 13.75,83.69 12.24,82.19 v1(12.24,81.49) 12.24,80.74
  vias: v2(12.24,80.08)
HDA_SPKR_RN: length 49.5
  TOP w0.203: U3600.44 19.9,65.24 v2(20.47,64.67)
  IN4 w0.508: v2(20.47,64.67) 20.7,64.44 20.7,63.3 19.6,62.2 11.89,62.2 11.56,62.53 11.56,62.56
  IN4 w0.762: 14.5,80.81 13.88,81.44 11.44,81.44 11.22,81.66 9.95,81.66 9.39,82.21 7.25,82.21 5.97,80.93 5.97,80 5.07,79.1 5.07,67.61 7.95,64.73 9.39,64.73 11.56,62.56
  BOTTOM w0.762: 17.04,84.89 17.04,83.76 14.94,81.65
  vias: v1(14.74,81.23) v2(14.93,80.32)
HDA_SPKR_RP: length 55.5
  IN4 w0.508: v2(20.47,65.44) 20.86,65.44 21.46,64.84 21.46,62.98 19.91,61.43 11.25,61.43 10.84,61.84
  IN4 w0.762: 15.75,81.01 14.3,82.45 11.86,82.45 11.64,82.68 10.37,82.68 9.82,83.23 6.83,83.23 4.95,81.35 4.95,80.42 4.05,79.52 4.05,67.19 7.53,63.71 8.97,63.71 10.84,61.84
  BOTTOM w0.203: v2(20.47,65.44) 20.13,65.1 v1(19.74,65.1)
  BOTTOM w0.762: 18.06,84.41 18.06,83.33 15.95,81.23
  vias: v2(15.69,80.29)
HDA_SYNC: length 197.2
  TOP w0.114: U3600.10 22.73,70.91 23.04,71.21 26.54,71.21 v1(26.8,71.47) 27.01,71.47 29.21,69.27 29.21,65.28 27.43,63.51 27.43,60.18 31.34,56.27 31.34,54.73 32.76,53.31 45.56,53.31 46.28,52.59 46.28,52.25 v2(46.74,51.78)
  IN1 w0.076: v2(186.44,71.86) 186.26,71.68 186.26,71.11 185.09,69.94 182.23,69.94 181.58,69.29 181.58,68.36 179.77,66.55 169.12,66.55 168,65.43 158.57,65.43 157.65,64.52 155.49,64.52 154.78,63.81 153.74,63.81 150.25,60.32 145.93,60.32 145.32,59.72 143.96,59.72 143.21,58.97 141.67,58.97 139.17,56.47 135.43,56.47 134.98,56.02 123.55,56.02 123.13,55.61 116.62,55.61 115.71,56.52 111.05,56.52 109.23,54.7 102.03,54.7 99.53,52.2 91.54,52.2 91.1,51.77 64.38,51.77 64.02,51.4 62.1,51.4 61.74,51.77 51.32,51.77 50.31,52.77 47.82,52.77 46.83,51.78 v2(46.74,51.78)
  BOTTOM w0.114: v2(186.44,71.86) 186.73,71.86 187.18,71.41 187.18,70.27 C2302.1 R2300.1
HDA_SYNC_L500MIL: length 13.5
  BOTTOM w0.089: 183.5,62.15 183.5,61.35 182.63,60.47 182.63,60.16 181.53,59.07 181.04,59.07 U2000.BD9
  BOTTOM w0.114: v1(188.59,68.42) 188.16,67.99 188.16,67.68 R2300.2 187.63,66.63 187.5,66.5 186.69,66.5 184.83,64.64 184.83,64.01 183.95,63.14 183.95,62.79 183.5,62.34 183.5,62.15
HDMI_CEXT: length 5.1
  TOP w0.102: C1304.1 207.44,48.48 208.08,49.12 209.09,49.12 v1(209.6,49.5) 209.78,49.32 210.49,49.32 210.91,49.73 U1301.2
HDMI_CFG0: length 5.4
  TOP w0.102: R1304.2 211,48.91 212.41,50.32 U1301.5 ; R1304.2 210.58,48.16 v1(210.58,46.78) ; R1304.2 R1305.1
HDMI_CFG1: length 3.9
  TOP w0.102: R1306.2 R1307.1 207.14,55.42 v1(208,55.42) 208.3,55.11 U1301.40
HDMI_HOTPLUG_DET: length 18.8
  TOP w0.102: Q4801.3 R4803.1 v2(251.36,78.5)
  BOTTOM w0.102: CON4800.19 258.33,86.25 257.4,86.25 256.46,85.31 256.46,82.9 v1(255.19,81.63) 253.78,81.63 252.12,79.97 252.12,79.26 v2(251.36,78.5)
HDMI_OUT_5V_L1: length 3.3
  TOP w0.254: R4806.1 249.15,74.74 249.07,74.82 D4800.1 247.75,74.82 247.32,74.39 v1(247.32,73.63)
HDMI_OUT_5V_L2: length 5.5
  TOP w0.254: R4807.1 249.17,76.12 D4800.2 245.66,76.12 245.03,75.49 v1(245.03,75.02)
HDMI_OUT_CLK_N: length 13.5
  TOP w0.102: v2(257.86,84.62) 257.83,84.65 256.35,84.65 RN4803.1
  IN1 w0.089: v2(257.86,84.62) 257.86,84.63 258.05,84.82 258.46,84.82 262.2,88.56 262.2,89.46 262.16,89.53 262.09,89.7 262.09,89.97 262.18,90.23 262.18,90.49 262.08,90.74 262.09,90.86 262.1,90.98 262.16,91.19 262.18,91.31 262.18,91.49 262.09,91.7 262.09,91.97 262.18,92.23 262.18,92.49 262.08,92.74 262.09,92.86 262.1,92.98 262.16,93.19 262.24,93.26 262.24,93.27 262.38,93.27 262.63,93.02 CON4800.12
HDMI_OUT_CLK_P: length 13.5
  TOP w0.102: v7(257.86,85.31) 257.43,84.88 256.26,84.88 RN4803.3
  IN1 w0.089: CON4800.10 262.26,93.48 262.15,93.48 262.09,93.42 262.01,93.31 261.99,93.28 261.91,93.03 261.88,92.72 261.99,92.43 261.99,92.27 261.9,92.03 261.9,91.66 261.99,91.45 261.99,91.32 261.97,91.23 261.92,91.04 261.91,91.03 261.88,90.72 261.99,90.43 261.99,90.27 261.9,90.03 261.9,89.66 261.98,89.46 261.98,88.64 258.37,85.03 258.14,85.03 257.86,85.31 v7(257.86,85.31)
HDMI_OUT_DATA0_N: length 13.4
  TOP w0.102: v2(257.86,87.37) 257.68,87.55 256.32,87.55 RN4800.1
  IN1 w0.089: v2(257.86,87.37) 258.11,87.62 259.89,87.62 260.13,87.86 260.13,88.96 259.86,89.24 259.51,89.24 259.36,89.39 259.36,90.02 260.22,90.88 260.22,94.35 260.62,94.76 261.02,94.76 CON4800.9
HDMI_OUT_DATA0_P: length 13.4
  TOP w0.102: v7(257.86,88.05) 257.59,87.78 256.29,87.78 RN4800.3
  IN1 w0.089: CON4800.7 261.05,94.97 260.53,94.97 260,94.44 260,90.97 259.14,90.11 259.14,89.3 259.42,89.03 259.77,89.03 259.92,88.87 259.92,87.95 259.8,87.83 258.08,87.83 v7(257.86,88.05)
HDMI_OUT_DATA1_N: length 10.1
  TOP w0.102: RN4801.1 256.32,97.96 257.23,97.96 v2(257.47,97.69)
  IN1 w0.089: v2(257.47,97.69) 257.71,97.93 259.08,97.93 260.06,98.91 261.67,98.91 261.98,98.6 261.98,98.24 261.9,98.04 261.9,97.67 261.99,97.43 261.99,97.27 261.88,96.98 261.91,96.67 261.99,96.42 262.05,96.33 262.15,96.23 262.5,96.23 262.63,96.11 CON4800.6
HDMI_OUT_DATA1_P: length 10.1
  TOP w0.102: RN4801.3 256.29,98.19 257.28,98.19 v7(257.47,98.38)
  IN1 w0.089: v7(257.47,98.38) 257.7,98.15 258.99,98.15 259.97,99.12 261.76,99.12 262.17,98.71 262.17,98.2 262.09,98 262.09,97.73 262.18,97.47 262.18,97.21 262.08,96.96 262.09,96.83 262.1,96.72 262.16,96.51 262.24,96.44 262.24,96.43 262.4,96.43 262.63,96.66 CON4800.4
HDMI_OUT_DATA2_N: length 7
  TOP w0.102: RN4802.1 256.27,100.32 257.17,100.32 v2(257.41,100.08)
  IN4 w0.089: v2(257.41,100.08) 257.69,100.37 258.02,100.37 260.65,97.74 261.04,97.74 CON4800.3
HDMI_OUT_DATA2_P: length 7
  TOP w0.102: RN4802.3 256.34,100.55 257.12,100.55 v7(257.4,100.83)
  IN4 w0.089: CON4800.1 261.08,98 260.69,98 258.11,100.58 257.65,100.58 v7(257.4,100.83)
HDMI_OUT_DDC_CLK: length 25.5
  TOP w0.114: R4807.2 249.63,77.65 249.83,77.85 252.81,77.85 253.08,78.12 Q4803.3 255.29,78.12 255.62,78.45 C4809.1 257.38,78.45 v1(257.45,78.53) 257.45,78.91 v2(257.2,79.16)
  IN3 w0.114: v2(257.2,79.16) 257.53,78.83 257.82,78.83 257.91,78.92 257.91,83.89 259.25,85.22 259.25,86.44 260.76,87.95 260.76,89.53 260.4,89.88 260.4,91.03 260.72,91.35 CON4800.15
HDMI_OUT_DDC_DATA: length 27.1
  TOP w0.114: R4806.2 250.14,73.35 253.92,73.35 254.46,73.88 Q4802.3 254.46,75.3 255.55,76.39 C4810.1 256.08,77.19 256.58,77.69 v2(257.38,77.69)
  IN3 w0.114: CON4800.16 262.63,90.7 262.39,90.45 262.38,90.45 262.03,90.1 262.03,89.61 262.03,89.6 262.03,88.52 259.75,86.23 259.75,85.02 258.41,83.68 258.41,78.72 v2(257.38,77.69)
  BOTTOM w0.114: v1(256.97,77.18) 256.97,77.28 v2(257.38,77.69)
HDMI_PD#: length 14.1
  TOP w0.102: R1314.2 216.25,58.5 v2(216.34,58.4) 216.34,58.36 215.41,57.43 U1301.26 ; v2(216.98,49.77) 216.39,49.77 215.81,49.19 Q1302.3
  IN3 w0.102: v2(216.34,58.4) 217.73,57.02 217.73,52.24 217.48,51.99 217.48,50.26 v2(216.98,49.77)
  BOTTOM w0.102: v2(216.98,49.77) 216.59,49.37 v1(216.59,49.25)
HDMI_REQ: length 7.4
  TOP w0.102: U1301.4 211.91,50.33 210.69,49.12 209.81,49.12 209.57,48.88 209.57,48.49 R1308.2 208.71,48.66 R1309.1 207.88,48.21 207.88,47.76 207.79,47.67 207.36,47.67 207.06,47.36 v1(207.06,47.11)
HDMI_REXT: length 5
  TOP w0.102: U1301.7 213.41,49.72 212.81,49.13 212.68,49.13 R1301.1 211.79,48.24 211.79,48.09 211.71,48.01 211.71,47.19 v1(212.37,46.53)
HDMI_SE_STBY_OFF_CK: length 6.8
  TOP w0.254: R4814.2 252.45,85.26 253.06,85.87 v2(253.29,85.87) ; R4812.2 v2(253.16,99.84) ; R4808.2 v2(253.16,98.57) ; R4809.2 v2(253.16,101.11) ; v2(253.34,83.45) 253.09,83.45 252.45,84.09 R4813.2 ; R4811.2 v2(253.16,88.15) ; R4815.2 v2(253.16,97.3) ; R4810.2 v2(253.14,86.88)
  BOTTOM w0.102: v2(253.16,98.57) v1(254,98.57)
  vias: v2(252.4,95.72) v2(252.4,95.09)
HDMI_TMDSD_AUXN: length 40.8
  TOP w0.114: R1316.2 215.14,60.33 215.14,58.04 214.79,57.7 214.79,57.53 214.91,57.42 U1301.27 214.91,56.63 v2(215.04,56.5)
  IN1 w0.089: v2(215.04,56.5) 214.8,56.26 214.8,56.04 214.95,55.89 215.67,55.89 220.02,51.55 220.02,47.05 224.87,42.19 225.7,42.19 226.76,41.12 226.76,40.84 226.99,40.61 v2(226.99,40.6)
  BOTTOM w0.114: v2(226.99,40.6) 226.78,40.39 226.78,40.19 226.11,39.53 226.11,36.33 227.5,34.95 233.32,34.95 ; 233.32,34.95 v1(233.32,35.22) ; 233.32,34.95 234.18,34.95 234.23,35 234.23,35.41 234.29,35.47 C1190.1
HDMI_TMDSD_AUXP: length 40.7
  TOP w0.114: v2(214.41,56.51) U1301.28 214.41,57.38 214.56,57.53 214.56,57.79 214.9,58.13 214.9,59.33 R1315.1 R1320.2
  IN1 w0.089: v2(226.36,40.61) 226.36,40.62 226.59,40.85 226.59,41.05 225.62,42.01 224.8,42.01 219.84,46.97 219.84,51.48 215.6,55.71 214.87,55.71 214.62,55.97 214.62,56.3 v2(214.41,56.51)
  BOTTOM w0.114: 231.65,34.71 v1(231.65,34.49) ; 231.65,34.71 227.41,34.71 225.88,36.24 225.88,39.63 226.54,40.29 226.54,40.43 v2(226.36,40.61) ; 231.65,34.71 C1189.1
HDMI_TMDSD_CLK#_C: length 4.6
  TOP w0.102: C4808.2 250.8,84.45 250.91,84.55 251.49,84.55 251.59,84.45 R4813.1 252.07,84.57 253.75,84.57 253.76,84.56 253.88,84.56 254.12,84.32 RN4803.2
HDMI_TMDSD_CLK_C: length 4.5
  TOP w0.102: RN4803.4 254.15,85.12 253.82,84.8 252.02,84.8 R4814.1 251.59,84.86 251.51,84.78 250.92,84.78 250.8,84.91 C4807.2
HDMI_TMDSD_DATA0#_C: length 4.4
  TOP w0.102: C4805.2 251.29,100.32 251.61,100.32 251.71,100.21 R4812.1 252.26,100.38 254.06,100.38 RN4802.2
HDMI_TMDSD_DATA0_C: length 4.4
  TOP w0.102: C4804.2 251.23,100.55 251.62,100.55 251.71,100.64 R4809.1 252.21,100.61 254.11,100.61 RN4802.4
HDMI_TMDSD_DATA1#_C: length 4.4
  TOP w0.102: RN4801.2 254.19,97.84 252.26,97.84 R4815.1 251.71,97.71 251.59,97.83 251.1,97.83 250.93,97.66 C4803.2
HDMI_TMDSD_DATA1_C: length 4.4
  TOP w0.102: C4802.2 250.93,98.31 251.18,98.06 251.56,98.06 251.71,98.21 R4808.1 252.21,98.07 253.81,98.07 254.2,98.46 RN4801.4
HDMI_TMDSD_DATA2#_C: length 4.6
  TOP w0.102: RN4800.2 254.13,87.48 252.18,87.48 R4810.1 251.59,87.27 251.45,87.41 250.96,87.41 250.8,87.25 C4801.2
HDMI_TMDSD_DATA2_C: length 4.6
  TOP w0.102: C4800.2 250.8,87.72 250.88,87.64 251.45,87.64 251.59,87.78 R4811.1 252.03,87.71 254.03,87.71 RN4800.4
HDMID_DDI2_AUXN: length 240.1
  TOP w0.102: v6(59.29,143.97) 59.29,143.8 59.61,143.48 61.75,143.48 62.19,143.92 62.19,144.35 R0306.2
  TOP w0.114: 207.44,62.78 207.14,62.78 205.53,61.17 205.53,59.82 205.19,59.48 202.75,59.48 202.33,59.91 200.59,59.91 200.46,60.03 200.46,60.3 v2(200.69,60.52) ; 207.44,62.78 209.91,62.78 C1316.1 ; 207.44,62.78 v1(207.44,63.04)
  IN1 w0.089: v2(200.69,60.52) 200.33,60.87 200.33,63.34 200.86,63.87 200.86,64.72 199.33,66.25 198.23,66.25 195.15,69.32 195.02,69.32 194.75,69.59 191.08,69.59 188.12,72.55 187.24,72.55 186.46,73.33 171.74,73.33 170.41,72 169.19,72 168.46,72.74 166.32,72.74 164.67,71.08 161.39,71.08 160.8,71.67 153.25,71.67 150.88,69.3 143.44,69.3 141.68,67.54 138.13,67.54 134.69,70.98 129.54,70.98 128.11,69.55 124.11,69.55 123.37,68.81 120.85,68.81 116.68,64.64 110.39,64.64 106.45,68.57 106.45,69.66 100.56,75.55 100.56,89.71 78.54,111.73 78.54,116.53 72.64,122.42 72.64,146.63 70.79,148.49 68.26,148.49 67.67,147.9 63,147.9 62.27,147.17 62.27,144.23 61.52,143.48 59.78,143.48 v6(59.29,143.97)
  BOTTOM w0.114: v6(59.29,143.97) 59.29,143.91 U0300.E26
HDMID_DDI2_AUXN_C: length 8.1
  TOP w0.114: 212.27,63.21 212.56,63.21 212.9,62.88 212.97,62.81 212.97,61.06 213.41,60.62 213.41,58.41 213.77,58.05 213.77,57.54 213.91,57.41 U1301.29 ; 212.27,63.21 211.31,63.21 C1316.2 ; 212.27,63.21 v1(212.27,63.44)
HDMID_DDI2_AUXP: length 240.2
  TOP w0.102: v6(59.29,143.18) 59.39,143.29 61.83,143.29 62.38,143.84 62.38,144.39 R0307.1
  TOP w0.114: 209.4,62.55 210.22,62.55 C1315.1 ; 209.4,62.55 v1(209.4,62.3) ; 209.4,62.55 207.23,62.55 205.77,61.08 205.77,59.73 205.28,59.24 202.66,59.24 202.23,59.67 200.49,59.67 200.23,59.94 200.23,60.35 v2(200.06,60.52)
  IN1 w0.089: v2(200.06,60.52) 200.06,60.78 200.15,60.88 200.15,63.41 200.69,63.95 200.69,64.64 199.26,66.07 198.16,66.07 195.08,69.15 194.95,69.15 194.68,69.41 191,69.41 188.05,72.37 187.17,72.37 186.38,73.16 171.82,73.16 170.49,71.83 169.12,71.83 168.38,72.56 166.4,72.56 164.74,70.9 161.32,70.9 160.73,71.49 153.32,71.49 150.95,69.12 143.51,69.12 141.75,67.36 138.06,67.36 134.62,70.8 129.61,70.8 128.19,69.38 124.18,69.38 123.44,68.63 120.93,68.63 116.75,64.46 110.31,64.46 106.27,68.5 106.27,69.59 100.38,75.48 100.38,89.63 78.36,111.65 78.36,116.45 72.47,122.35 72.47,146.56 70.72,148.31 68.33,148.31 67.74,147.72 63.08,147.72 62.45,147.09 62.45,144.16 61.59,143.3 59.71,143.3 59.48,143.53 59.34,143.53 59.29,143.48 v6(59.29,143.18)
  BOTTOM w0.114: v6(59.29,143.18) 59.29,143.25 U0300.F26
HDMID_DDI2_AUXP_C: length 8
  TOP w0.114: v1(212.5,61.21) 212.73,61.21 ; 212.73,61.21 212.73,62.71 212.47,62.98 211.86,62.98 C1315.2 ; 212.73,61.21 212.73,60.97 213.18,60.52 213.18,58.31 213.54,57.95 213.54,57.52 213.41,57.39 U1301.30
HDMID_DDI2_DATA0: length 260.2
  TOP w0.114: 205.44,57.45 204.52,56.53 204.52,55.41 204.34,55.24 204.09,55.24 v2(203.84,55.49) ; 205.44,57.45 v1(205.28,57.6) ; 205.44,57.45 205.66,57.68 206,57.68 C1309.1
  IN2 w0.095: v6(58.43,149.43) 59.26,148.61 62.71,148.61 63.93,149.83 70.47,149.83 75.75,144.54 75.75,119.13 79.06,115.83 79.06,105.59 100.58,84.06 100.58,76.8 105.65,71.74 105.65,63.3 107.28,61.67 107.28,59.17 109.95,56.5 115.61,56.5 116.49,55.62 131.87,55.62 132.71,56.46 136.04,56.46 140.49,60.9 140.49,64.63 140.95,65.09 140.95,67.09 142.54,68.68 146.84,68.68 147.49,68.03 152.02,68.03 156.81,72.82 160.07,72.82 160.63,73.38 164.24,73.38 165.94,75.08 170.5,75.08 171.62,76.21 173.53,76.21 174.5,77.18 185.78,77.18 187.57,78.96 188.26,78.96 188.85,78.38 200.95,78.38 207.3,72.03 207.3,62.28 206.53,61.52 206.53,58.97 203.64,56.08 203.64,55.69 v2(203.84,55.49)
  BOTTOM w0.114: U0300.H34 58.04,149.34 58.13,149.43 v6(58.43,149.43)
HDMID_DDI2_DATA0#: length 260.2
  TOP w0.114: 204.75,55.49 204.75,55.31 204.44,55 204.07,55 v2(203.85,54.79) ; 204.75,55.49 204.75,56.43 205.76,57.44 206.1,57.44 C1305.1 ; 204.75,55.49 v1(204.98,55.49)
  IN2 w0.095: v2(203.85,54.79) 203.43,55.21 203.43,56.16 206.32,59.05 206.32,61.6 207.09,62.37 207.09,71.94 200.86,78.17 188.77,78.17 188.18,78.75 187.65,78.75 185.87,76.97 174.59,76.97 173.62,76 171.71,76 170.58,74.87 166.02,74.87 164.33,73.17 160.72,73.17 160.16,72.61 156.9,72.61 152.1,67.82 147.4,67.82 146.75,68.47 142.62,68.47 141.16,67.01 141.16,65 140.7,64.54 140.7,60.81 136.13,56.25 132.8,56.25 131.96,55.41 116.41,55.41 115.53,56.29 109.87,56.29 107.07,59.08 107.07,61.58 105.44,63.21 105.44,71.65 100.37,76.71 100.37,83.97 78.85,105.5 78.85,115.74 75.54,119.04 75.54,144.45 70.38,149.62 64.02,149.62 62.79,148.4 59.17,148.4 58.82,148.75 v6(58.46,148.75)
  BOTTOM w0.114: v6(58.46,148.75) 58.33,148.75 U0300.H33
HDMID_DDI2_DATA0#_C: length 3.8
  TOP w0.114: C1305.2 207.55,57.47 207.79,57.47 208.1,57.16 208.1,56.66 209.02,55.75 209.26,55.75 209.5,55.75 209.64,55.61 U1301.39
HDMID_DDI2_DATA0_C: length 3.8
  TOP w0.114: U1301.38 209.63,56.11 209.5,55.98 209.12,55.98 208.34,56.76 208.34,57.26 207.89,57.71 207.59,57.71 C1309.2
HDMID_DDI2_DATA1: length 275.9
  TOP w0.114: 203.45,53.11 202.97,52.63 v2(202.97,49.85) ; 203.45,53.11 v1(203.3,53.26) ; 203.45,53.11 205.03,54.68 205.61,54.68 205.8,54.5 C1314.1
  IN2 w0.095: v2(202.97,49.85) 203.17,49.65 203.17,49.41 203.99,48.59 205.51,48.59 208.54,51.62 208.54,58.46 209.21,59.13 209.21,73.3 202.46,80.05 202.44,80.05 202.29,80.2 189.61,80.2 189.02,80.79 185.29,80.79 185.23,80.86 181.32,80.86 180.1,82.09 179.28,82.09 177.13,79.93 174.49,79.93 173.08,78.52 169.23,78.52 168.16,77.45 161.4,77.45 158.66,74.71 156.12,74.71 151.35,69.95 148.64,69.95 148.08,70.51 141.72,70.51 138.47,67.26 138.47,66.5 137.48,65.51 137.48,64.06 137.25,63.83 137.25,60.34 136.49,59.58 132.2,59.58 130.51,57.88 117.08,57.88 116.18,58.78 112.99,58.78 108.33,63.44 108.33,67.14 107.64,67.83 107.64,72.38 102.7,77.33 102.7,85.68 81.42,106.96 81.42,116.99 78.01,120.39 78.01,144.98 70.27,152.72 63.98,152.72 v2(63.55,152.29)
  BOTTOM w0.076: U0300.F37 58.82,151.27 58.98,151.43 58.98,152.26 59.8,153.08 61.58,153.08 61.77,152.89 63.46,152.89 63.55,152.8 v2(63.55,152.29)
HDMID_DDI2_DATA1#: length 275.9
  TOP w0.114: 203.21,51.48 203.21,52.53 205.13,54.45 205.51,54.45 205.68,54.28 205.68,54.06 205.63,54.01 205.37,54.01 205.21,53.84 205.21,53.71 205.28,53.64 205.69,53.64 205.72,53.61 C1307.1 ; 203.21,51.48 v1(203.43,51.48) ; 203.21,51.48 203.21,50.35 203.29,50.27 203.49,50.27 203.61,50.16 v2(203.61,49.85)
  IN2 w0.095: v2(203.61,49.85) 203.38,49.62 203.38,49.5 204.08,48.8 205.42,48.8 208.33,51.7 208.33,58.55 209,59.22 209,73.21 202.37,79.84 202.35,79.84 202.2,79.99 189.52,79.99 188.94,80.58 185.21,80.58 185.14,80.65 181.24,80.65 180.01,81.88 179.37,81.88 177.22,79.72 174.58,79.72 173.17,78.31 169.32,78.31 168.25,77.24 161.49,77.24 158.75,74.5 156.2,74.5 151.44,69.74 148.55,69.74 147.99,70.3 141.8,70.3 138.67,67.17 138.67,66.41 137.69,65.43 137.69,63.97 137.46,63.74 137.46,60.26 136.57,59.37 132.29,59.37 130.59,57.67 116.99,57.67 116.09,58.57 112.9,58.57 108.12,63.35 108.12,67.05 107.43,67.74 107.43,72.3 102.49,77.24 102.49,85.6 81.21,106.88 81.21,116.9 77.8,120.31 77.8,144.9 70.19,152.51 64.41,152.51 v2(64.19,152.29)
  BOTTOM w0.076: U0300.G38 58.78,151.95 58.78,152.35 59.72,153.28 61.66,153.28 61.85,153.09 63.54,153.09 63.75,152.88 63.75,152.73 63.8,152.67 64.08,152.67 64.19,152.57 v2(64.19,152.29)
HDMID_DDI2_DATA1#_C: length 3.4
  TOP w0.114: 207.9,53.93 208.32,53.93 208.64,54.25 209.48,54.25 209.62,54.11 U1301.42 ; 207.9,53.93 v1(207.9,53.66) ; 207.9,53.93 207.3,53.93 C1307.2
HDMID_DDI2_DATA1_C: length 3.1
  TOP w0.114: C1314.2 207.32,54.16 208.22,54.16 208.55,54.48 209.48,54.48 209.61,54.61 U1301.41
HDMID_DDI2_DATA2: length 263.7
  TOP w0.114: v7(205.16,52.21) 205.16,52.07 205,51.91 204.9,51.91 204.76,51.76 204.76,51.58 204.83,51.5 205.23,51.5 205.7,51.97 205.75,51.97 C1313.1
  IN2 w0.095: v7(205.16,52.21) 205.16,52.02 205.04,51.91 204.85,51.91 204.68,51.74 204.68,51.5 204.82,51.36 205.37,51.36 206.2,52.19 206.2,57.1 206.95,57.85 206.95,61.28 207.7,62.03 207.7,72.08 207.7,72.2 201.12,78.78 189.02,78.78 188.43,79.36 184.78,79.36 183.71,78.3 174.89,78.3 173.66,77.07 171.87,77.07 170.29,75.49 165.68,75.49 164.16,73.97 160.1,73.97 159.35,73.23 156.65,73.23 151.93,68.5 147.76,68.5 147.19,69.08 142.34,69.08 140.08,66.82 140.08,65.41 138.92,64.24 138.92,63.23 138.68,62.99 138.68,59.74 137.04,58.1 132.83,58.1 130.75,56.02 116.72,56.02 115.64,57.1 110.06,57.1 107.76,59.4 107.76,61.81 106.83,62.75 106.83,66.52 106.14,67.2 106.14,71.81 101.04,76.91 101.04,84.27 79.67,105.64 79.67,116.14 76.3,119.52 76.3,144.6 70.64,150.25 62.81,150.25 61.65,149.1 60.3,149.1 59.63,149.77 59.46,149.77 59.38,149.7 59.38,149.6 v6(59.22,149.43)
  BOTTOM w0.114: v6(59.22,149.43) 59.22,148.97 59.08,148.84 58.9,148.84 58.82,148.92 U0300.F34
