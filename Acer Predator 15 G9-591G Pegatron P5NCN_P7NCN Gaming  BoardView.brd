# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Nets (continued)
+FBVDDQ: C7500.1 C7501.1 C7502.1 C7503.1 C7504.1 C7505.1 C7506.1 C7507.1 C7524.1 C7525.1 C7526.1 C7527.1 C7528.1 C7529.1 C7530.1 C7531.1 C7532.1 C7533.1 C7534.1 C7535.1 C7536.1 C7537.1 C7548.1 C7549.1 C7550.1 C7551.1 C7552.1 C7553.1 C7554.1 C7555.1 C7556.1 C7557.1 C7568.1 C7569.1 C7570.1 C7571.1 C7572.1 C7573.1 C7574.1 C7575.1 C7576.1 C7577.1 C7578.1 C7579.1 C7606.1 C7607.1 C7608.1 C7609.1 C7610.1 C7611.1 C7612.1 C7613.1 C7614.1 C7615.1 C7616.1 C7617.1 C7618.1 C7619.1 C7620.1 C7621.1 C7622.1 C7623.1 C7624.1 C7625.1 C7626.1 C7627.1 C7628.1 C7629.1 C7630.1 C7631.1 C7632.1 C7633.1 C7634.1 C7635.1 C7636.1 C7637.1 C7706.1 C7707.1 C7708.1 C7709.1 C7710.1 C7711.1 C7712.1 C7713.1 C7714.1 C7715.1 C7716.1 C7717.1 C7718.1 C7719.1 C7720.1 C7721.1 C7722.1 C7723.1 C7724.1 C7725.1 C7726.1 C7727.1 C7728.1 C7729.1 C7730.1 C7731.1 C7732.1 C7733.1 C7734.1 C7735.1 C7736.1 C7737.1 C7806.1 C7807.1 C7808.1 C7809.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7815.1 C7816.1 C7817.1 C7818.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7824.1 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C7830.1 C7831.1 C7832.1 C7833.1 C7834.1 C7835.1 C7836.1 C7837.1 C7906.1 C7907.1 C7908.1 C7909.1 C7910.1 C7911.1 C7912.1 C7913.1 C7914.1 C7915.1 C7916.1 C7917.1 C7918.1 C7919.1 C7920.1 C7921.1 C7922.1 C7923.1 C7924.1 C7925.1 C7926.1 C7927.1 C7928.1 C7929.1 C7930.1 C7931.1 C7932.1 C7933.1 C7934.1 C7935.1 C7936.1 C7937.1 C8916.1 CE7502.1 JP8901.2 JP8902.2 R5700.1 R7100.2 R7101.2 R7103.2 R7104.2 R7108.2 R7109.2 R7110.2 R7111.2 R7112.2 R7113.2 R7115.2 R7116.2 R7120.2 R7121.2 R7122.2 R7123.2 R7501.2 R7600.2 R7610.2 R7615.1 R7617.1 R7700.2 R7710.2 R7715.1 R7717.1 R7800.2 R7810.2 R7815.1 R7817.1 R7900.2 R7910.2 R7915.1 R7917.1 U7000.AA39 U7000.AC11 U7000.AD10 U7000.AD39 U7000.AF11 U7000.AF39 U7000.AG39 U7000.AK39 U7000.AM39 U7000.AM40 U7000.AN40 U7000.B47 U7000.C45 U7000.C46 U7000.C47 U7000.D44 U7000.D45 U7000.D46 U7000.E44 U7000.E45 U7000.F42 U7000.F44 U7000.F45 U7000.G41 U7000.G42 U7000.H41 U7000.H42 U7000.H43 U7000.J38 U7000.J39 U7000.J42 U7000.J43 U7000.K24 U7000.K26 U7000.K29 U7000.K30 U7000.K32 U7000.L14 U7000.L15 U7000.L17 U7000.L18 U7000.L20 U7000.L23 U7000.L24 U7000.L27 U7000.L29 U7000.L30 U7000.L32 U7000.L33 U7000.L35 U7000.L41 U7000.P11 U7000.P39 U7000.R11 U7000.R40 U7000.U11 U7000.U39 U7000.V11 U7000.V39 U7000.V40 U7000.Y11 U7000.Y40 U7600.B1 U7600.B3 U7600.B12 U7600.B14 U7600.C5 U7600.C10 U7600.D1 U7600.D3 U7600.D11 U7600.D12 U7600.D14 U7600.E5 U7600.E10 U7600.F1 U7600.F3 U7600.F12 U7600.F14 U7600.G1 U7600.G2 U7600.G4 U7600.G11 U7600.G13 U7600.G14 U7600.H3 U7600.H12 U7600.K3 U7600.K12 U7600.L1 U7600.L2 U7600.L4 U7600.L11 U7600.L13 U7600.L14 U7600.M1 U7600.M3 U7600.M12 U7600.M14 U7600.N5 U7600.N10 U7600.P1 U7600.P3 U7600.P11 U7600.P12 U7600.P14 U7600.R5 U7600.R10 U7600.T1 U7600.T3 U7600.T12 U7600.T14 U7601.B1 U7601.B3 U7601.B12 U7601.B14 U7601.C5 U7601.C10 U7601.D1 U7601.D3 U7601.D11 U7601.D12 U7601.D14 U7601.E5 U7601.E10 U7601.F1 U7601.F3 U7601.F12 U7601.F14 U7601.G1 U7601.G2 U7601.G4 U7601.G11 U7601.G13 U7601.G14 U7601.H3 U7601.H12 U7601.K3 U7601.K12 U7601.L1 U7601.L2 U7601.L4 U7601.L11 U7601.L13 U7601.L14 U7601.M1 U7601.M3 U7601.M12 U7601.M14 U7601.N5 U7601.N10 U7601.P1 U7601.P3 U7601.P11 U7601.P12 U7601.P14 U7601.R5 U7601.R10 U7601.T1 U7601.T3 U7601.T12 U7601.T14 U7700.B1 U7700.B3 U7700.B12 U7700.B14 U7700.C5 U7700.C10 U7700.D1 U7700.D3 U7700.D11 U7700.D12 U7700.D14 U7700.E5 U7700.E10 U7700.F1 U7700.F3 U7700.F12 U7700.F14 U7700.G1 U7700.G2 U7700.G4 U7700.G11 U7700.G13 U7700.G14 U7700.H3 U7700.H12 U7700.K3 U7700.K12 U7700.L1 U7700.L2 U7700.L4 U7700.L11 U7700.L13 U7700.L14 U7700.M1 U7700.M3 U7700.M12 U7700.M14 U7700.N5 U7700.N10 U7700.P1 U7700.P3 U7700.P11 U7700.P12 U7700.P14 U7700.R5 U7700.R10 U7700.T1 U7700.T3 U7700.T12 U7700.T14 U7701.B1 U7701.B3 U7701.B12 U7701.B14 U7701.C5 U7701.C10 U7701.D1 U7701.D3 U7701.D11 U7701.D12 U7701.D14 U7701.E5 U7701.E10 U7701.F1 U7701.F3 U7701.F12 U7701.F14 U7701.G1 U7701.G2 U7701.G4 U7701.G11 U7701.G13 U7701.G14 U7701.H3 U7701.H12 U7701.K3 U7701.K12 U7701.L1 U7701.L2 U7701.L4 U7701.L11 U7701.L13 U7701.L14 U7701.M1 U7701.M3 U7701.M12 U7701.M14 U7701.N5 U7701.N10 U7701.P1 U7701.P3 U7701.P11 U7701.P12 U7701.P14 U7701.R5 U7701.R10 U7701.T1 U7701.T3 U7701.T12 U7701.T14 U7800.B1 U7800.B3 U7800.B12 U7800.B14 U7800.C5 U7800.C10 U7800.D1 U7800.D3 U7800.D11 U7800.D12 U7800.D14 U7800.E5 U7800.E10 U7800.F1 U7800.F3 U7800.F12 U7800.F14 U7800.G1 U7800.G2 U7800.G4 U7800.G11 U7800.G13 U7800.G14 U7800.H3 U7800.H12 U7800.K3 U7800.K12 U7800.L1 U7800.L2 U7800.L4 U7800.L11 U7800.L13 U7800.L14 U7800.M1 U7800.M3 U7800.M12 U7800.M14 U7800.N5 U7800.N10 U7800.P1 U7800.P3 U7800.P11 U7800.P12 U7800.P14 U7800.R5 U7800.R10 U7800.T1 U7800.T3 U7800.T12 U7800.T14 U7801.B1 U7801.B3 U7801.B12 U7801.B14 U7801.C5 U7801.C10 U7801.D1 U7801.D3 U7801.D11 U7801.D12 U7801.D14 U7801.E5 U7801.E10 U7801.F1 U7801.F3 U7801.F12 U7801.F14 U7801.G1 U7801.G2 U7801.G4 U7801.G11 U7801.G13 U7801.G14 U7801.H3 U7801.H12 U7801.K3 U7801.K12 U7801.L1 U7801.L2 U7801.L4 U7801.L11 U7801.L13 U7801.L14 U7801.M1 U7801.M3 U7801.M12 U7801.M14 U7801.N5 U7801.N10 U7801.P1 U7801.P3 U7801.P11 U7801.P12 U7801.P14 U7801.R5 U7801.R10 U7801.T1 U7801.T3 U7801.T12 U7801.T14 U7900.B1 U7900.B3 U7900.B12 U7900.B14 U7900.C5 U7900.C10 U7900.D1 U7900.D3 U7900.D11 U7900.D12 U7900.D14 U7900.E5 U7900.E10 U7900.F1 U7900.F3 U7900.F12 U7900.F14 U7900.G1 U7900.G2 U7900.G4 U7900.G11 U7900.G13 U7900.G14 U7900.H3 U7900.H12 U7900.K3 U7900.K12 U7900.L1 U7900.L2 U7900.L4 U7900.L11 U7900.L13 U7900.L14 U7900.M1 U7900.M3 U7900.M12 U7900.M14 U7900.N5 U7900.N10 U7900.P1 U7900.P3 U7900.P11 U7900.P12 U7900.P14 U7900.R5 U7900.R10 U7900.T1 U7900.T3 U7900.T12 U7900.T14 U7901.B1 U7901.B3 U7901.B12 U7901.B14 U7901.C5 U7901.C10 U7901.D1 U7901.D3 U7901.D11 U7901.D12 U7901.D14 U7901.E5 U7901.E10 U7901.F1 U7901.F3 U7901.F12 U7901.F14 U7901.G1 U7901.G2 U7901.G4 U7901.G11 U7901.G13 U7901.G14 U7901.H3 U7901.H12 U7901.K3 U7901.K12 U7901.L1 U7901.L2 U7901.L4 U7901.L11 U7901.L13 U7901.L14 U7901.M1 U7901.M3 U7901.M12 U7901.M14 U7901.N5 U7901.N10 U7901.P1 U7901.P3 U7901.P11 U7901.P12 U7901.P14 U7901.R5 U7901.R10 U7901.T1 U7901.T3 U7901.T12 U7901.T14
+FBVDDQ_DISCH_A: Q5700.3 R5700.2
+FBVDDQ_ENABLE: D7402.3 R7448.2 SR8902.1
+LX: L3300.2 U3300.40
+NVVDD: C7508.1 C7509.1 C7510.1 C7511.1 C7512.1 C7513.1 C7514.1 C7515.1 C7516.1 C7517.1 C7518.1 C7519.1 C7520.1 C7521.1 C7522.1 C7523.1 C7538.1 C7539.1 C7540.1 C7541.1 C7542.1 C7543.1 C7544.1 C7545.1 C7546.1 C7547.1 C7558.1 C7559.1 C7560.1 C7561.1 C7562.1 C7563.1 C7564.1 C7565.1 C7566.1 C7567.1 C7580.1 C7581.1 C7582.1 C7583.1 C7584.1 C7585.1 C7586.1 C7587.1 C7588.1 C7589.1 C7597.1 C7598.1 C7599.1 C8710.2 C8711.2 C8712.2 C8713.2 C8714.2 C8715.2 C8716.2 C8717.2 C8718.2 C8719.2 C8720.2 C8721.2 C8722.2 C8743.1 C8744.1 C75001.1 C75002.1 C75003.1 C75004.1 C75005.1 C75006.1 C75007.1 C75008.1 C75009.1 C75010.1 C75011.1 C75012.1 C75013.1 C75014.1 C75015.1 C75016.1 C75017.1 C75018.1 C75019.1 C75020.1 C75021.1 C75022.1 C75023.1 C75024.1 C75025.1 C75026.1 C75027.1 CE8700.1 CE8701.1 CE8702.1 CE8703.1 CE8704.1 CE8705.1 L8700.2 L8701.2 L8702.2 R5703.1 R8715.2 T8705.1 T8706.1 T8707.1 T8708.1 T8709.1 T8710.1 U7000.AA14 U7000.AA16 U7000.AA18 U7000.AA20 U7000.AA22 U7000.AA24 U7000.AA26 U7000.AA28 U7000.AA30 U7000.AA32 U7000.AB15 U7000.AB17 U7000.AB19 U7000.AB21 U7000.AB23 U7000.AB25 U7000.AB27 U7000.AB29 U7000.AB31 U7000.AC14 U7000.AC16 U7000.AC18 U7000.AC20 U7000.AC22 U7000.AC24 U7000.AC26 U7000.AC28 U7000.AC30 U7000.AC32 U7000.AD15 U7000.AD17 U7000.AD19 U7000.AD21 U7000.AD23 U7000.AD25 U7000.AD27 U7000.AD29 U7000.AD31 U7000.AE14 U7000.AE16 U7000.AE18 U7000.AE20 U7000.AE22 U7000.AE24 U7000.AE26 U7000.AE28 U7000.AE30 U7000.AE32 U7000.AF15 U7000.AF17 U7000.AF19 U7000.AF21 U7000.AF23 U7000.AF25 U7000.AF27 U7000.AF29 U7000.AF31 U7000.AG14 U7000.AG16 U7000.AG18 U7000.AG20 U7000.AG22 U7000.AG24 U7000.AG26 U7000.AG28 U7000.AG30 U7000.AG32 U7000.AH15 U7000.AH17 U7000.AH19 U7000.AH21 U7000.AH23 U7000.AH25 U7000.AH27 U7000.AH29 U7000.AH31 U7000.AJ14 U7000.AJ16 U7000.AJ18 U7000.AJ20 U7000.AJ22 U7000.AJ24 U7000.AJ26 U7000.AJ28 U7000.AJ30 U7000.AJ32 U7000.AK15 U7000.AK17 U7000.AK19 U7000.AK21 U7000.AK23 U7000.AK25 U7000.AK27 U7000.AK29 U7000.AK31 U7000.AL14 U7000.AL16 U7000.AL18 U7000.AL20 U7000.AL22 U7000.AL24 U7000.AL26 U7000.AL28 U7000.AL30 U7000.AL32 U7000.AM15 U7000.AM17 U7000.AM19 U7000.AM21 U7000.AM23 U7000.AM25 U7000.AM27 U7000.AM29 U7000.AM31 U7000.AM32 U7000.AN39 U7000.AP39 U7000.AR39 U7000.AR40 U7000.AR41 U7000.AT39 U7000.AT40 U7000.AT41 U7000.AU39 U7000.AU41 U7000.AU42 U7000.AV41 U7000.AV42 U7000.AV43 U7000.AV44 U7000.AW35 U7000.AW36 U7000.AW37 U7000.AW41 U7000.AW42 U7000.AW43 U7000.AW44 U7000.AW45 U7000.AY36 U7000.AY42 U7000.AY45 U7000.BA36 U7000.BA37 U7000.BA38 U7000.BA39 U7000.BA42 U7000.BA43 U7000.BA44 U7000.BA45 U7000.BA46 U7000.BB37 U7000.BB38 U7000.BB39 U7000.BB40 U7000.BB41 U7000.BB42 U7000.BB43 U7000.BB44 U7000.BB45 U7000.BB46 U7000.BB47 U7000.BC38 U7000.BC39 U7000.BC41 U7000.BC42 U7000.BC45 U7000.BC46 U7000.BD38 U7000.BD39 U7000.BD41 U7000.BD42 U7000.BD44 U7000.BD45 U7000.BD46 U7000.BD47 U7000.BD48 U7000.BD49 U7000.BE38 U7000.BE39 U7000.BE40 U7000.BE41 U7000.BE42 U7000.BE43 U7000.BE44 U7000.BE45 U7000.BE46 U7000.BE47 U7000.BE48 U7000.BE49 U7000.BF38 U7000.BF39 U7000.BF40 U7000.BF41 U7000.BF42 U7000.BF43 U7000.BF44 U7000.BF45 U7000.BF46 U7000.BF47 U7000.BF48 U7000.BF49 U7000.BG39 U7000.BG41 U7000.BG42 U7000.BG44 U7000.BG45 U7000.BG46 U7000.BG47 U7000.BG48 U7000.BG49 U7000.BH39 U7000.BH40 U7000.BH41 U7000.BH42 U7000.BH43 U7000.BH44 U7000.BH45 U7000.BH46 U7000.BH47 U7000.BH48 U7000.BH49 U7000.BJ39 U7000.BJ41 U7000.BJ42 U7000.BJ44 U7000.BJ45 U7000.BJ46 U7000.BJ47 U7000.BJ48 U7000.P15 U7000.P17 U7000.P19 U7000.P21 U7000.P23 U7000.P25 U7000.P27 U7000.P29 U7000.P31 U7000.R14 U7000.R16 U7000.R18 U7000.R20 U7000.R22 U7000.R24 U7000.R26 U7000.R28 U7000.R30 U7000.R32 U7000.T15 U7000.T17 U7000.T19 U7000.T21 U7000.T23 U7000.T25 U7000.T27 U7000.T29 U7000.T31 U7000.U14 U7000.U16 U7000.U18 U7000.U20 U7000.U22 U7000.U24 U7000.U26 U7000.U28 U7000.U30 U7000.U32 U7000.V15 U7000.V17 U7000.V19 U7000.V21 U7000.V23 U7000.V25 U7000.V27 U7000.V29 U7000.V31 U7000.W14 U7000.W16 U7000.W18 U7000.W20 U7000.W22 U7000.W24 U7000.W26 U7000.W28 U7000.W30 U7000.W32 U7000.Y15 U7000.Y17 U7000.Y19 U7000.Y21 U7000.Y23 U7000.Y25 U7000.Y27 U7000.Y29 U7000.Y31
+NVVDD_DISCH_A: Q5703.3 R5703.2
+RTC_POWER: C8117.1 D2801.1 JP8106.1 T8107.1 U8100.3
+V_SM_VREF_R: C8303.1 U8300.4
+VCORE: C0900.1 C0901.1 C0902.1 C0903.1 C0904.1 C0905.1 C0906.1 C0907.1 C0908.1 C0909.1 C0910.1 C0911.1 C0912.1 C0913.1 C0914.1 C0915.1 C0916.1 C0917.1 C0918.1 C0919.1 C0920.1 C0921.1 C0922.1 C0923.1 C0924.1 C0925.1 C0926.1 C0927.1 C0928.1 C0929.1 C0930.1 C0931.1 C0932.1 C0933.1 C0934.1 C0935.1 C0936.1 C0937.1 C0938.1 C0939.1 C0940.1 C0941.1 C0942.1 C0943.1 C0944.1 C0945.1 C0946.1 C0947.1 C0948.1 C0949.1 C0950.1 C0951.1 C0952.1 C0953.1 C0954.1 C0955.1 C0956.1 C0957.1 C0958.1 C0959.1 C0960.1 C0961.1 C0962.1 C8074.2 C8075.2 C8076.2 C8077.2 C8078.2 C8079.2 C8080.2 C8081.2 C8082.2 C8083.2 C8084.2 C8085.2 C8091.2 C8092.2 C8093.2 C8094.2 C8095.2 C8096.2 C8097.2 C8098.2 C8099.2 C80002.2 C80020.2 C80026.2 C80036.2 C80038.2 C80050.2 C80055.2 C80073.2 C80075.2 C80078.2 C80083.2 C80087.2 C80092.2 C80122.1 C80123.1 CE8000.1 CE8001.1 JP8051.2 JP8053.2 JP8055.2 L8000.2 L8001.2 L8002.2 R80112.1 U0300.AA13 U0300.AA31 U0300.AA32 U0300.AA33 U0300.AA34 U0300.AA35 U0300.AA36 U0300.AA37 U0300.AA38 U0300.AB29 U0300.AB30 U0300.AB31 U0300.AB32 U0300.AB35 U0300.AB36 U0300.AB37 U0300.AB38 U0300.AC13 U0300.AC14 U0300.AC29 U0300.AC30 U0300.AC31 U0300.AC32 U0300.AC33 U0300.AC34 U0300.AC35 U0300.AC36 U0300.AD13 U0300.AD14 U0300.AD31 U0300.AD32 U0300.AD33 U0300.AD34 U0300.AD35 U0300.AD36 U0300.AD37 U0300.AD38 U0300.AE13 U0300.AE14 U0300.AE30 U0300.AE31 U0300.AE32 U0300.AE35 U0300.AE36 U0300.AE37 U0300.AE38 U0300.AF35 U0300.AF36 U0300.AF37 U0300.AF38 U0300.K13 U0300.K14 U0300.L13 U0300.L14 U0300.N13 U0300.N14 U0300.N30 U0300.N31 U0300.N32 U0300.N35 U0300.N36 U0300.N37 U0300.N38 U0300.P13 U0300.P14 U0300.P29 U0300.P30 U0300.P31 U0300.P32 U0300.P33 U0300.P34 U0300.P35 U0300.P36 U0300.R13 U0300.R31 U0300.R32 U0300.R33 U0300.R34 U0300.R35 U0300.R36 U0300.R37 U0300.R38 U0300.T29 U0300.T30 U0300.T31 U0300.T32 U0300.T35 U0300.T36 U0300.T37 U0300.T38 U0300.U29 U0300.U30 U0300.U31 U0300.U32 U0300.U33 U0300.U34 U0300.U35 U0300.U36 U0300.V13 U0300.V14 U0300.V31 U0300.V32 U0300.V33 U0300.V34 U0300.V35 U0300.V36 U0300.V37 U0300.V38 U0300.W13 U0300.W14 U0300.W29 U0300.W30 U0300.W31 U0300.W32 U0300.W35 U0300.W36 U0300.W37 U0300.W38 U0300.Y29 U0300.Y30 U0300.Y31 U0300.Y32 U0300.Y33 U0300.Y34 U0300.Y35 U0300.Y36
+VTT_DDR: C1600.1 C1601.1 C1700.1 C1701.1 C1808.1 C1809.1 C1818.1 C1819.1 C1820.1 C1821.1 CON1600.258 CON1601.258 CON1700.258 CON1701.258 JP8301.1
A_DVDD: C3623.1 C3624.1 R3605.2 U3600.1
AC_IN_OC: R8806.1 R8808.2 R8815.1 U3001.120 U8800.5
ACDRV: R8803.1 R8816.2 U8800.4
ACG: C8800.2 C8801.1 Q8801.4 Q8802.4 R8803.2
ACPRESENT_EC: R3037.2 U3001.16
AD_IINP: C8815.2 C8831.1 SR8800.1 U3001.66 U8801.1
ALERT#: R8013.1 U8000.44
ALL_SYSTEM_PWRGD: D9202.2 SR9204.1 T9203.1 U3001.68 U9200.4 U9201.2
AMP_EN: CON6700.15 U3001.104
AMP_G0: CON6700.12 U3001.94
AMP_G1: CON6700.11 U3001.95
AMP_SPK_LN: C3620.1 CON3600.2 R3627.1
AMP_SPK_LP: C3619.1 CON3600.1 R3628.1
AMP_SPK_RN: C3621.1 CON3600.3 R3626.1
AMP_SPK_RP: C3622.1 CON3600.4 R3625.1
AMP_WOF_LN: C3707.1 CON3700.3 L3703.2
AMP_WOF_LN_R: L3703.1 U3700.2
AMP_WOF_LP: C3708.1 CON3700.4 L3704.2
AMP_WOF_LP_R: L3704.1 U3700.1
AMP_WOF_RN: C3705.1 CON3700.2 L3701.2
AMP_WOF_RN_R: L3701.1 U3700.5
AMP_WOF_RP: C3706.1 CON3700.1 L3702.2
AMP_WOF_RP_R: L3702.1 U3700.6
ANALOG_INL: C3710.1 U3600.24
ANALOG_INL_C: C3710.2 R3704.1
ANALOG_INL_CR: C3703.2 R3704.2 R3712.1
ANALOG_INR: C3704.1 U3600.23
ANALOG_INR_C: C3704.2 R3700.1
ANALOG_INR_CR: C3702.2 R3700.2 R3711.1
BAT: CON2800.1 R2811.1
BAT1_IN_OC#: JP9000.1 R3065.2 U3001.124
BAT_LEARN: SR8807.2 U3001.85
BATT_IN: CON6000.4 Q6001.3
BKLT_EN: D4502.3 D4503.1 R4525.2 R4527.1 R4594.2
BOOT_C: R8068.1 U8005.2
BP_PWRGD_RST#: C4401.1 R4412.2 R4415.1 XDP4400.41
BPM_N2: T0700.1 U0300.BM31
BPM_N3: T0701.1 U0300.BT30
BT_DISABLE#: CON5300.54 R2141.1 R5300.2 U2000.AC43
BVREF_CA_RC: C0502.2 R0511.1
C_CC1: C1223.1 CON1201.A5 U1201.L9 U1207.9
C_CC2: C1224.1 CON1201.B5 U1201.L10 U1207.1
C_USB_BN: L1201.4 RN1201.4 U1201.L7
C_USB_BN_CON: CON1201.B7 L1201.3 RN1201.3 U1207.4
C_USB_BP: L1201.1 RN1201.2 U1201.K7
C_USB_BP_CON: CON1201.B6 L1201.2 RN1201.1 U1207.7
C_USB_TN: L1202.1 RN1202.2 U1201.L6
C_USB_TN_CON: CON1201.A7 L1202.2 RN1202.1 U1207.6
C_USB_TP: L1202.4 RN1202.4 U1201.K6
C_USB_TP_CON: CON1201.A6 L1202.3 RN1202.3 U1207.5
CA_DET: CON4601.13 Q7201.1 R4609.1 R4628.2
CATERR#: T0745.1 U0300.BM30
CFG_RCOMP: R0742.1 U0300.BT25
CGH_SRN: SR8805.2 U8800.12
CGH_SRP: SR8804.2 U8800.13
CHA_DIMM0_EVENT#: C1619.1 CON1600.134 R1600.2
CHA_DIMM1_EVENT#: C1620.1 CON1601.134 R1601.2
CHB_DIMM0_EVENT#: C1718.1 CON1701.134 R1700.2
CHB_DIMM1_EVENT#: C1719.1 CON1700.134 R1701.2
CHG_ACN: C8807.2 C8809.2 JP8802.2 U8800.1
CHG_ACP: C8807.1 C8808.2 JP8801.2 U8800.2
CHG_BST: SR8803.2 U8800.17
CHG_BST_R: C8817.2 D8800.3 SR8803.1
CHG_HG: Q8803.4 T8800.1 U8800.18
CHG_LDO: C8821.1 D8800.1 D8800.2 R8806.2 U8800.16
CHG_LED_RED: CON5602.22 R5602.1 U3001.25
CHG_LED_RED_IO: CON402.22 PCON700.5
CHG_LED_RED_LED: CON1.4 LC801.1 LQ801.1
CHG_LED_YELLOW: CON5602.23 R5601.1 U3001.28
CHG_LED_YELLOW_IO: CON402.23 PCON700.6
CHG_LED_YELLOW_LED: CON1.3 LC802.1 LQ802.1
CHG_LG: Q8804.4 T8801.1 U8800.15
CHG_LX: C8817.1 L8800.1 Q8803.1 Q8803.2 Q8803.3 Q8804.5 Q8804.6 Q8804.7 Q8804.8 R8810.1 U8800.19
CHG_RC: C8822.1 R8810.2
CHG_SRN_R: C8823.2 C8826.2 JP8805.2 SR8805.1
CHG_SRP_R: C8823.1 C8825.2 JP8804.2 SR8804.1
CHG_VCC: C8816.2 R8812.2 U8800.20
CHG_VCC_R: D8801.3 R8812.1
CK_24M_85OHM_BCK: R2503.1 U2000.G1
CK_24M_85OHM_BCK#: R2505.1 U2000.F1
CK_24M_BCK: R2503.2 U0300.E31
CK_24M_BCK#: R2505.2 U0300.D31
CK_100M_85OHM_BCK: R2500.1 U2000.G2
CK_100M_85OHM_BCK#: R2501.1 U2000.H2
CK_100M_85OHM_CPUXDP: R2507.1 U2000.L2
CK_100M_85OHM_CPUXDP#: R2508.1 U2000.L1
CK_100M_85OHM_PCIE: R2510.1 U2000.J2
CK_100M_85OHM_PCIE#: R2511.1 U2000.J1
CK_100M_BCK: R2500.2 U0300.B31
CK_100M_BCK#: R2501.2 U0300.A32
CK_100M_CPUXDP: R2507.2 XDP4400.40
CK_100M_CPUXDP#: R2508.2 XDP4400.42
CK_100M_LAN: R2520.2 U3300.33
CK_100M_LAN#: R2521.2 U3300.32
CK_100M_LAN#_R: R2521.1 U2000.P3
CK_100M_LAN_R: R2520.1 U2000.P2
CK_100M_PCIE: R2510.2 U0300.D35
CK_100M_PCIE#: R2511.2 U0300.C36
CK_100M_PE0: CON5300.47 R2509.2
CK_100M_PE0#: CON5300.49 R2502.2
CK_100M_PE0#_R: R2502.1 U2000.N7
CK_100M_PE0_R: R2509.1 U2000.N8
CK_100M_PE8: CON5102.55 R2515.2
CK_100M_PE8#: CON5102.53 R2517.2
CK_100M_PE8#_R: R2517.1 U2000.W10
CK_100M_PE8_R: R2515.1 U2000.W11
CL_CLK: R5312.2 U2000.AV2
CL_DATA: R5311.2 U2000.AV3
CL_RST#: R5310.2 U2000.AW2
CLK_KBCPCI_DEBUG: CON4400.1 R2227.1
CLK_KBCPCI_PCH: C2203.1 C3022.1 R2265.1 U3001.13
CLKOUT_LPC0_ESPI_CLK: R2227.2 R2265.2 U2000.BC17
CLKOUT_LPC1_CLK: C2202.1 R2264.1 U6200.21
CLKOUT_LPC1_CLK_R: R2264.2 U2000.AV19
CLKREQ0_WLAN#: CON5300.53 R2421.2 R2425.1 U2000.BC24
CLKREQ#: R3304.1 U3300.4
CLKREQ#_MSATA: R2430.2 R2490.1 R5122.1 U2000.BD32
CMSRC: R8804.1 U8800.3
COMP_A: C8032.2 R8096.2 U8000.16
COMP_B: C8015.2 R8030.2 U8000.4
COMP_C: C8005.1 R8093.1 U8000.29
CPU_PECI: R0733.2 R0746.2 U0300.BT34
CPU_PM_DOWN: R0731.2 U0300.BP31
CPU_THERM#: R5011.2 R5018.2 SR9205.2 U5000.4 U5003.3
CPU_VIDALERT#: R0717.1 U0300.BH31
CPU_VRON: R0750.2 R80151.2
CPU_VRON_PWR: JP9300.2 R8017.2 T9300.1
CPU_VTT_CNTL: R0728.1 U0300.BT13
CPU_XDP_HOOK0: R4404.1 R4405.1 R4406.1 XDP4400.39
CPU_XDP_HOOK2: R4409.2 R4416.1 XDP4400.45
CPUFAN_PWM_C_L: CON5000.1 D5000.2 R5006.2
CPUFAN_PWM_C_R: CON5001.1 D5002.2 R5010.2
CPUFAN_TACH_C_L: CON5000.3 D5000.1 D5001.1 D5001.2 R5005.2
CPUFAN_TACH_C_R: CON5001.3 D5002.1 D5003.1 D5003.2 R5009.2
CPUPWRGD: R2462.2 R4404.2 U0300.BT31
CRITICAL: R8737.1 T8715.1 U8702.9
CSBU_1_R: R1219.1 U1201.K8
CSBU_2_R: R1220.1 U1201.L8
DCPRTC: C2623.1 U2000.BA26
DDI1_BKLT_CTL: CON4500.26 R2140.2 R4587.1
DDI1_BKLT_EN: D4502.1 R2150.2 R4518.2
DDI1_VDD_EN: R4590.1 U2000.W42
DDR0_DQ_RC: C0500.2 R0509.1
DDR_BST: SR8301.2 U8300.18
DDR_BST_R: C8309.1 SR8301.1
DDR_CS: R8302.1 U8300.13
DDR_FB: C8320.2 R8306.2 R8308.1 U8300.6
DDR_FB_R: C8320.1 C8321.1 JP8304.2 R8306.1
DDR_HG: Q8300.4 U8300.17
DDR_LG: Q8301.4 U8300.15
DDR_LX: C8309.2 L8300.1 Q8300.1 Q8300.2 Q8300.3 Q8301.5 R8301.1 T8301.1 U8300.16
DDR_PWRGD: R9211.1 T8300.1 T9202.1 U8300.10
DDR_RC: C8314.1 R8301.2
DDR_VDD: C8318.1 SR8302.2 SR8303.1 U8300.12
DDR_VDDQ: JP8303.2 U8300.5
DDR_VID: R8303.1 SR8303.2 U8300.11
DDR_VTT_CNTL_R: R0728.2 U0701.2
DDR_VTT_CNTRL: D8300.2 R0704.2 R8304.2 R8305.1 U0701.4
DDR_VTTSNS: JP8300.2 U8300.2
DDRA_VREF_CA_R: R1610.2 R1612.1 R1620.1 R1621.1
DDRA_VREF_CA_R_W10S12: C0501.1 R0505.1 U0300.BN13
DDRA_VREF_CA_W10S12: C1612.1 C1613.2 C1614.1 C1615.2 CON1600.164 CON1601.164 R0505.2 R1620.2 R1621.2
DDRB_VREF_CA_R: R1710.2 R1714.1 R1720.1 R1721.1
DDRB_VREF_CA_R_W10S12: C0502.1 R0508.1 U0300.BR13
DDRB_VREF_CA_W10S12: C1712.1 C1713.1 C1714.1 C80135.1 CON1700.164 CON1701.164 R0508.2 R1720.2 R1721.2
DEBUG1: R1234.1 U1201.L2
DEBUG2: R1233.1 U1201.K2
DEBUG3: R1236.1 U1201.L3
DEBUG4: R1235.1 U1201.K3
DEBUGMODE: R3301.1 U3300.5
DELAY_ALL_SYSTEM_PWRGD: R0748.1 R2494.1 U2402.2 U3001.84
DGPU_EN_PWR: D8700.2 D9600.2 R8710.1 R9602.1 SR9100.1 SR9102.2 T9109.1
DGPU_PWROK: D7402.2 R7411.2 R9206.1 SR8702.1 T9204.1
DISPA_BCLK_L200MIL: R2311.2 U2000.AM2
DISPA_SDO_L200MIL: R2307.2 U2000.AM1
DMI_RXN0: U0300.E8 U2000.C27
DMI_RXN1: U0300.F6 U2000.B28
DMI_RXN2: U0300.E5 U2000.B29
DMI_RXN3: U0300.J9 U2000.B30
DMI_RXP0: U0300.D8 U2000.B27
DMI_RXP1: U0300.E6 U2000.A28
DMI_RXP2: U0300.D5 U2000.C29
DMI_RXP3: U0300.J8 U2000.A30
DMI_TXN0: U0300.A8 U2000.L27
DMI_TXN1: U0300.B6 U2000.E24
DMI_TXN2: U0300.A5 U2000.G27
DMI_TXN3: U0300.B4 U2000.L29
DMI_TXP0: U0300.B8 U2000.N27
DMI_TXP1: U0300.C6 U2000.G24
DMI_TXP2: U0300.B5 U2000.E26
DMI_TXP3: U0300.D4 U2000.K29
DMIC_0_SELECT_LEFT: R300.1 R301.2 U300.2
DMIC_0_SELECT_RIGHT: R400.1 R401.2 U400.2
DMIC_CLK: C3627.1 CON4500.28 R2376.1 R3611.1
DMIC_CLK_L: C302.1 CON300.3 CON302.4 D302.1 T300.1 U300.4
DMIC_CLK_R: C402.1 CON400.3 D402.1 U400.4
DMIC_DATA: C3628.1 CON4500.30 R2375.2 R3610.1
DMIC_DATA_L: CON300.2 CON302.5 D301.1 U300.5
DMIC_DATA_R: CON400.2 D401.1 T400.1 U400.5
DP2_CEXT: C4637.1 U4601.2
DP2_CFG0: R4623.2 R4624.1 U4601.5
DP2_CFG1: R4601.2 R4602.1 U4601.40
DP2_PD#: R4627.2 U4601.26
DP2_REQ: R4625.2 R4626.1 U4601.4
DP2_REXT: R4604.1 U4601.7
DP2_TXN0_C: C1401.2 U1401.39
DP2_TXN1_C: C1402.2 U1401.42
DP2_TXN2_C: C1403.2 U1401.45
DP2_TXN3_C: C1406.2 U1401.48
DP2_TXP0_C: C1405.2 U1401.38
DP2_TXP1_C: C1410.2 U1401.41
DP2_TXP2_C: C1409.2 U1401.44
DP2_TXP3_C: C1404.2 U1401.47
DP_AUXN: C1146.1 R1415.2 U1401.27
DP_AUXP: C1147.1 R1416.1 U1401.28
DP_CEXT: C1411.1 U1401.2
DP_CFG0: R1403.2 R1406.1 U1401.5
DP_CFG1: R1402.2 R1404.1 U1401.40
DP_DATA0: C1138.1 U1401.23
DP_DATA0#: C1139.1 U1401.22
DP_DATA1: C1140.1 U1401.20
DP_DATA1#: C1141.1 U1401.19
DP_DATA2: C1142.1 U1401.17
DP_DATA2#: C1143.1 U1401.16
DP_DATA3: C1144.1 U1401.14
DP_DATA3#: C1145.1 U1401.13
DP_DDI3_AUXN: C1408.1 R0301.2 U0300.B27
DP_DDI3_AUXN_C: C1408.2 U1401.29
DP_DDI3_AUXP: C1407.1 R0305.1 U0300.A27
DP_DDI3_AUXP_C: C1407.2 U1401.30
DP_DDI3_DATA0: C1405.1 U0300.C34
DP_DDI3_DATA0#: C1401.1 U0300.D34
DP_DDI3_DATA1: C1410.1 U0300.B36
DP_DDI3_DATA1#: C1402.1 U0300.B34
DP_DDI3_DATA2: C1409.1 U0300.F33
DP_DDI3_DATA2#: C1403.1 U0300.E33
DP_DDI3_DATA3: C1404.1 U0300.C33
DP_DDI3_DATA3#: C1406.1 U0300.B33
DP_IFPC_DATA0: C4622.1 U7000.BC14
DP_IFPC_DATA0#: C4623.1 U7000.BD14
DP_IFPC_DATA0#_C: C4623.2 U4601.39
DP_IFPC_DATA0_C: C4622.2 U4601.38
DP_IFPC_DATA1: C4624.1 U7000.BF14
DP_IFPC_DATA1#: C4625.1 U7000.BE14
DP_IFPC_DATA1#_C: C4625.2 U4601.42
DP_IFPC_DATA1_C: C4624.2 U4601.41
DP_IFPC_DATA2: C4618.1 U7000.BD12
DP_IFPC_DATA2#: C4620.1 U7000.BC12
DP_IFPC_DATA2#_C: C4620.2 U4601.45
DP_IFPC_DATA2_C: C4618.2 U4601.44
DP_IFPC_DATA3: C4619.1 U7000.BD11
DP_IFPC_DATA3#: C4621.1 U7000.BE11
DP_IFPC_DATA3#_C: C4621.2 U4601.48
DP_IFPC_DATA3_C: C4619.2 U4601.47
DP_IFRC_AUXN: C4627.1 R7213.1 R7220.1 U7000.BF2
DP_IFRC_AUXN_C: C4627.2 U4601.29
DP_IFRC_AUXP: C4626.1 R7214.1 R7219.1 U7000.BG2
DP_IFRC_AUXP_C: C4626.2 U4601.30
DP_IFRC_CLK: Q7202.3 R7219.2 U4601.33
DP_IFRC_DATA: Q7203.3 R7220.2 U4601.34
DP_OUT_DATA0: C4629.1 U4601.23
DP_OUT_DATA0#: C4631.1 U4601.22
DP_OUT_DATA0#_CON: C4631.2 CON4601.3
DP_OUT_DATA0_CON: C4629.2 CON4601.1
DP_OUT_DATA1: C4628.1 U4601.20
DP_OUT_DATA1#: C4630.1 U4601.19
DP_OUT_DATA1#_CON: C4630.2 CON4601.6
DP_OUT_DATA1_CON: C4628.2 CON4601.4
DP_OUT_DATA2: C4632.1 U4601.17
DP_OUT_DATA2#: C4633.1 U4601.16
DP_OUT_DATA2#_CON: C4633.2 CON4601.9
DP_OUT_DATA2_CON: C4632.2 CON4601.7
DP_OUT_DATA3: C4634.1 U4601.14
DP_OUT_DATA3#: C4635.1 U4601.13
DP_OUT_DATA3#_CON: C4635.2 CON4601.12
DP_OUT_DATA3_CON: C4634.2 CON4601.10
DP_PD#: Q1302.6 R1414.2 U1401.26
DP_REQ: R1401.1 R1405.2 U1401.4
DP_REXT: R1411.1 U1401.7
DPSRC0_ML0_N: C1120.2 U1101.AC7
DPSRC0_ML0_P: C1119.2 U1101.AB7
DPSRC0_ML1_N: C1122.2 U1101.AC9
DPSRC0_ML1_P: C1121.2 U1101.AB9
DPSRC0_ML2_N: C1124.2 U1101.AC11
DPSRC0_ML2_P: C1123.2 U1101.AB11
DPSRC0_ML3_N: C1126.2 U1101.AC13
DPSRC0_ML3_P: C1125.2 U1101.AB13
DPSRC1_AUX_N: C1146.2 U1101.W12
DPSRC1_AUX_P: C1147.2 U1101.Y12
DPSRC1_ML0_N: C1139.2 U1101.AC15
DPSRC1_ML0_P: C1138.2 U1101.AB15
DPSRC1_ML1_N: C1141.2 U1101.AC17
DPSRC1_ML1_P: C1140.2 U1101.AB17
DPSRC1_ML2_N: C1143.2 U1101.AC19
DPSRC1_ML2_P: C1142.2 U1101.AB19
DPSRC1_ML3_N: C1145.2 U1101.AC21
DPSRC1_ML3_P: C1144.2 U1101.AB21
DRAMRST_R#: C1602.2 C1603.2 C1702.2 C1703.2 CON1600.108 CON1601.108 CON1700.108 CON1701.108 R2485.1
EC_AGND: C3021.2 R3048.2 U3001.75
EC_KBL_LED1_CON: Q3108.1 R3094.2
EC_KBL_LED1_CON_M: CON3110.3 Q3108.3 U3102.6
EC_KBL_LED2_CON: Q3109.1 R3095.2
EC_KBL_LED2_CON_M: CON3110.4 Q3109.3 U3102.7
EC_KBL_LED3_CON: Q3110.1 R3096.2
EC_KBL_LED3_CON_M: CON3110.5 Q3110.3 U3102.8
EC_KBL_LED4_CON: Q3111.1 R3097.2
EC_KBL_LED4_CON_M: CON3110.6 Q3111.3 U3102.11
EC_RST#: C3011.1 C5002.1 D5004.3 R5004.2 U3001.14
EDP_AUX_DN_C: C4530.2 L4505.1 RN4505.3
EDP_AUX_DN_R: CON4500.15 L4505.2 R4523.2 RN4505.4
EDP_AUX_DP_C: C4529.2 L4505.4 RN4505.1
EDP_AUX_DP_R: CON4500.14 L4505.3 R4524.2 RN4505.2
EDP_AUXN: C4530.1 U0300.B26
EDP_AUXP: C4529.1 U0300.C26
EDP_HPD: C4526.2 CON4500.20 R4501.2 R4586.2 T4505.1 U2000.BD7
EDP_TX0_DN_C: C4533.2 L4504.4 RN4504.1
EDP_TX0_DN_R: CON4500.11 L4504.3 RN4504.2
EDP_TX0_DP_C: C4531.2 L4504.1 RN4504.3
EDP_TX0_DP_R: CON4500.12 L4504.2 RN4504.4
EDP_TX1_DN_C: C4534.2 L4503.4 RN4503.1
EDP_TX1_DN_R: CON4500.8 L4503.3 RN4503.2
EDP_TX1_DP_C: C4535.2 L4503.1 RN4503.3
EDP_TX1_DP_R: CON4500.9 L4503.2 RN4503.4
EDP_TX2_DN_C: C4519.2 L4502.4 RN4502.1
EDP_TX2_DN_R: CON4500.5 L4502.3 RN4502.2
EDP_TX2_DP_C: C4520.2 L4502.1 RN4502.3
EDP_TX2_DP_R: CON4500.6 L4502.2 RN4502.4
EDP_TX3_DN_C: C4522.2 L4501.4 RN4501.1
EDP_TX3_DN_R: CON4500.2 L4501.3 RN4501.2
EDP_TX3_DP_C: C4521.2 L4501.1 RN4501.3
EDP_TX3_DP_R: CON4500.3 L4501.2 RN4501.4
EDP_TXN_0: C4533.1 U0300.E29
EDP_TXN_1: C4534.1 U0300.E28
EDP_TXN_2: C4519.1 U0300.B29
EDP_TXN_3: C4522.1 U0300.B28
EDP_TXP_0: C4531.1 U0300.D29
EDP_TXP_1: C4535.1 U0300.F28
EDP_TXP_2: C4520.1 U0300.A29
EDP_TXP_3: C4521.1 U0300.C28
ENABLE1: R8111.1 SR8102.1 U8100.20
ENABLE2: SR8103.2 U8100.6
ESPI_ALERT0#: R2225.1 R3013.1
EXP_RXN0: C0631.1 U7000.BD21
EXP_RXN1: C0629.1 U7000.BE23
EXP_RXN2: C0627.1 U7000.BC23
EXP_RXN3: C0625.1 U7000.BD24
EXP_RXN4: C0623.1 U7000.BE25
EXP_RXN5: C0621.1 U7000.BC26
EXP_RXN6: C0619.1 U7000.BD27
EXP_RXN7: C0617.1 U7000.BE29
EXP_RXN8: C0615.1 U7000.BC29
EXP_RXN9: C0613.1 U7000.BD30
EXP_RXN10: C0611.1 U7000.BE32
EXP_RXN11: C0605.1 U7000.BC32
EXP_RXN12: C0609.1 U7000.BD33
EXP_RXN13: C0608.1 U7000.BE35
EXP_RXN14: C0602.1 U7000.BC35
EXP_RXN15: C0600.1 U7000.BD36
EXP_RXP0: C0630.1 U7000.BC21
EXP_RXP1: C0628.1 U7000.BE22
EXP_RXP2: C0626.1 U7000.BD23
EXP_RXP3: C0624.1 U7000.BC24
EXP_RXP4: C0622.1 U7000.BE26
EXP_RXP5: C0620.1 U7000.BD26
EXP_RXP6: C0618.1 U7000.BC27
EXP_RXP7: C0616.1 U7000.BE28
EXP_RXP8: C0614.1 U7000.BD29
EXP_RXP9: C0612.1 U7000.BC30
EXP_RXP10: C0606.1 U7000.BE31
EXP_RXP11: C0610.1 U7000.BD32
EXP_RXP12: C0604.1 U7000.BC33
EXP_RXP13: C0603.1 U7000.BE34
EXP_RXP14: C0601.1 U7000.BD35
EXP_RXP15: C0607.1 U7000.BC36
EXP_TXN0: C7014.2 U0300.B10
EXP_TXN0_C: C7014.1 U7000.BG21
EXP_TXN1: C7005.2 U0300.B11
EXP_TXN1_C: C7005.1 U7000.BH23
EXP_TXN2: C7010.2 U0300.B12
EXP_TXN2_C: C7010.1 U7000.BJ24
EXP_TXN3: C7021.2 U0300.B13
EXP_TXN3_C: C7021.1 U7000.BG24
EXP_TXN4: C7023.2 U0300.B14
EXP_TXN4_C: C7023.1 U7000.BH26
EXP_TXN5: C7025.2 U0300.B15
EXP_TXN5_C: C7025.1 U7000.BJ27
EXP_TXN6: C7030.2 U0300.B16
EXP_TXN6_C: C7030.1 U7000.BG27
EXP_TXN7: C7032.2 U0300.B17
EXP_TXN7_C: C7032.1 U7000.BH29
EXP_TXN8: C7034.2 U0300.C18
EXP_TXN8_C: C7034.1 U7000.BJ30
EXP_TXN9: C7036.2 U0300.A19
EXP_TXN9_C: C7036.1 U7000.BG30
EXP_TXN10: C7038.2 U0300.C20
EXP_TXN10_C: C7038.1 U7000.BH32
EXP_TXN11: C7040.2 U0300.A21
EXP_TXN11_C: C7040.1 U7000.BJ33
EXP_TXN12: C7042.2 U0300.C22
EXP_TXN12_C: C7042.1 U7000.BG33
EXP_TXN13: C7044.2 U0300.A23
EXP_TXN13_C: C7044.1 U7000.BH35
EXP_TXN14: C7050.2 U0300.C24
EXP_TXN14_C: C7050.1 U7000.BJ36
EXP_TXN15: C7052.2 U0300.A25
EXP_TXN15_C: C7052.1 U7000.BG36
EXP_TXP0: C7004.2 U0300.C10
EXP_TXP0_C: C7004.1 U7000.BH21
EXP_TXP1: C7015.2 U0300.A11
EXP_TXP1_C: C7015.1 U7000.BG23
EXP_TXP2: C7009.2 U0300.C12
EXP_TXP2_C: C7009.1 U7000.BJ23
EXP_TXP3: C7020.2 U0300.A13
EXP_TXP3_C: C7020.1 U7000.BH24
EXP_TXP4: C7022.2 U0300.C14
EXP_TXP4_C: C7022.1 U7000.BG26
EXP_TXP5: C7024.2 U0300.A15
EXP_TXP5_C: C7024.1 U7000.BJ26
EXP_TXP6: C7029.2 U0300.C16
EXP_TXP6_C: C7029.1 U7000.BH27
EXP_TXP7: C7031.2 U0300.A17
EXP_TXP7_C: C7031.1 U7000.BG29
EXP_TXP8: C7033.2 U0300.B18
EXP_TXP8_C: C7033.1 U7000.BJ29
EXP_TXP9: C7035.2 U0300.B19
EXP_TXP9_C: C7035.1 U7000.BH30
EXP_TXP10: C7037.2 U0300.B20
EXP_TXP10_C: C7037.1 U7000.BG32
EXP_TXP11: C7039.2 U0300.B21
EXP_TXP11_C: C7039.1 U7000.BJ32
EXP_TXP12: C7041.2 U0300.B22
EXP_TXP12_C: C7041.1 U7000.BH33
EXP_TXP13: C7043.2 U0300.B23
EXP_TXP13_C: C7043.1 U7000.BG35
EXP_TXP14: C7049.2 U0300.B24
EXP_TXP14_C: C7049.1 U7000.BJ35
EXP_TXP15: C7051.2 U0300.B25
EXP_TXP15_C: C7051.1 U7000.BH36
EXT_SCI#: R2210.2 R3082.1 U2000.M44
EXT_SCI#_D: R3082.2 U3001.23
EXT_SMI#: R2365.2 R3069.1 U2000.AN43
F_CS#_EC: R3041.2 U3001.101
F_SCK_EC: R3043.2 U3001.105
F_SDI_EC: R3044.2 U3001.102
FAN0_PWM: R5000.2 R5006.1 U3001.30
FAN0_TACH: D5001.3 R5003.2 R5005.1 U3001.47
FAN1_PWM: R5007.2 R5010.1 U3001.31
FAN1_TACH: D5003.3 R5008.2 R5009.1 U3001.48
FAN2_DETECT: R5124.2 U3001.69
FAN2_PWM: R5139.1 U3001.32
FAN2_TACH: R5125.2 U3001.79
FAN_REVERSE: R5015.1 R5016.1 U3001.29
FB_A: R8049.2 R8080.2 R80100.2 U8000.17
FB_B: R8015.2 R8023.2 R8037.2 U8000.5
FB_C: R8047.1 R8079.1 R8099.1 U8000.30
FBA_CLK0: R7602.1 U7000.AF41 U7600.J12
FBA_CLK0#: R7602.2 U7000.AF40 U7600.J11
FBA_CLK1: R7603.1 U7000.AJ44 U7601.J12
FBA_CLK1#: R7603.2 U7000.AJ45 U7601.J11
FBA_CMD0: U7000.U47 U7600.G3
FBA_CMD1: R7100.1 U7000.U48 U7600.J3
FBA_CMD2: R7102.2 U7000.U49 U7600.J2
FBA_CMD3: U7000.V48 U7600.L3
FBA_CMD4: U7000.V49 U7600.K5
FBA_CMD5: U7000.V47 U7600.K4
FBA_CMD6: U7000.AA49 U7600.J5
FBA_CMD7: U7000.AA48 U7600.J4
FBA_CMD8: U7000.AC48 U7600.H5
FBA_CMD9: U7000.AC49 U7600.H4
FBA_CMD10: U7000.AC47 U7600.G12
FBA_CMD11: U7000.AD49 U7600.H10
FBA_CMD12: U7000.AD48 U7600.H11
FBA_CMD13: U7000.AD47 U7600.K11
FBA_CMD14: U7000.AF47 U7600.K10
FBA_CMD15: U7000.AF48 U7600.L12
FBA_CMD16: U7000.BB49 U7601.L3
FBA_CMD17: R7101.1 U7000.BA48 U7601.J3
FBA_CMD18: R7105.2 U7000.BA49 U7601.J2
FBA_CMD19: U7000.AW49 U7601.G3
FBA_CMD20: U7000.AV48 U7601.H5
FBA_CMD21: U7000.AV49 U7601.H4
FBA_CMD22: U7000.AN48 U7601.J5
FBA_CMD23: U7000.AN49 U7601.J4
FBA_CMD24: U7000.AM47 U7601.K5
FBA_CMD25: U7000.AM49 U7601.K4
FBA_CMD26: U7000.AM48 U7601.L12
FBA_CMD27: U7000.AJ47 U7601.K10
FBA_CMD28: U7000.AJ49 U7601.K11
FBA_CMD29: U7000.AJ48 U7601.H11
FBA_CMD30: U7000.AG48 U7601.H10
FBA_CMD31: U7000.AG49 U7601.G12
FBA_D0: U7000.V43 U7600.F2
FBA_D1: U7000.V41 U7600.A2
FBA_D2: U7000.V44 U7600.F4
FBA_D3: U7000.V42 U7600.E2
FBA_D4: U7000.U43 U7600.E4
FBA_D5: U7000.U44 U7600.B4
FBA_D6: U7000.U41 U7600.A4
FBA_D7: U7000.U42 U7600.B2
FBA_D8: U7000.AA46 U7600.E11
FBA_D9: U7000.AC46 U7600.F13
FBA_D10: U7000.AA45 U7600.E13
FBA_D11: U7000.AA47 U7600.F11
FBA_D12: U7000.Y46 U7600.A11
FBA_D13: U7000.Y49 U7600.B11
FBA_D14: U7000.Y45 U7600.A13
FBA_D15: U7000.Y48 U7600.B13
FBA_D16: U7000.AJ46 U7600.M13
FBA_D17: U7000.AG47 U7600.U13
FBA_D18: U7000.AG46 U7600.N13
FBA_D19: U7000.AG45 U7600.T13
FBA_D20: U7000.AF44 U7600.N11
FBA_D21: U7000.AF45 U7600.T11
FBA_D22: U7000.AD46 U7600.U11
FBA_D23: U7000.AD45 U7600.M11
FBA_D24: U7000.AD44 U7600.M4
FBA_D25: U7000.AD43 U7600.N4
FBA_D26: U7000.AD42 U7600.M2
FBA_D27: U7000.AC42 U7600.N2
FBA_D28: U7000.AA44 U7600.U4
FBA_D29: U7000.AA43 U7600.T4
FBA_D30: U7000.AA42 U7600.U2
FBA_D31: U7000.AA40 U7600.T2
FBA_D32: U7000.AT48 U7601.A4
FBA_D33: U7000.AT46 U7601.F4
FBA_D34: U7000.AT49 U7601.E4
FBA_D35: U7000.AT47 U7601.B4
FBA_D36: U7000.AW47 U7601.E2
FBA_D37: U7000.AW48 U7601.B2
FBA_D38: U7000.BA47 U7601.F2
FBA_D39: U7000.AW46 U7601.A2
FBA_D40: U7000.AR46 U7601.A11
FBA_D41: U7000.AN45 U7601.A13
FBA_D42: U7000.AR49 U7601.F11
FBA_D43: U7000.AR48 U7601.B11
FBA_D44: U7000.AT45 U7601.E11
FBA_D45: U7000.AR44 U7601.B13
FBA_D46: U7000.AN41 U7601.F13
FBA_D47: U7000.AN42 U7601.E13
FBA_D48: U7000.AG40 U7601.U13
FBA_D49: U7000.AG43 U7601.N13
FBA_D50: U7000.AG41 U7601.T13
FBA_D51: U7000.AJ43 U7601.N11
FBA_D52: U7000.AJ40 U7601.M11
FBA_D53: U7000.AK40 U7601.M13
FBA_D54: U7000.AK42 U7601.U11
FBA_D55: U7000.AK41 U7601.T11
FBA_D56: U7000.AK45 U7601.T4
FBA_D57: U7000.AK43 U7601.N4
FBA_D58: U7000.AK48 U7601.N2
FBA_D59: U7000.AK49 U7601.M4
FBA_D60: U7000.AM45 U7601.M2
FBA_D61: U7000.AM44 U7601.T2
FBA_D62: U7000.AK44 U7601.U4
FBA_D63: U7000.AM43 U7601.U2
FBA_DEBUG0: R7108.1 U7000.Y47
FBA_DEBUG1: R7109.1 U7000.AR47
FBA_DQM0: U7000.U40 U7600.D2
FBA_DQM1: U7000.AC45 U7600.D13
FBA_DQM2: U7000.AG44 U7600.P13
FBA_DQM3: U7000.AA41 U7600.P2
FBA_DQM4: U7000.AV45 U7601.D2
FBA_DQM5: U7000.AR45 U7601.D13
FBA_DQM6: U7000.AG42 U7601.P13
FBA_DQM7: U7000.AM46 U7601.P2
FBA_DQS_WP0: U7000.U45 U7600.C2
FBA_DQS_WP1: U7000.Y43 U7600.C13
FBA_DQS_WP2: U7000.AF42 U7600.R13
FBA_DQS_WP3: U7000.AC44 U7600.R2
FBA_DQS_WP4: U7000.AV47 U7601.C2
FBA_DQS_WP5: U7000.AN43 U7601.C13
FBA_DQS_WP6: U7000.AJ42 U7601.R13
FBA_DQS_WP7: U7000.AK47 U7601.R2
FBA_MF1: R7615.2 R7616.1 U7600.J1
FBA_MF2: R7617.2 R7618.1 U7601.J1
FBA_VREF_CA1: C7603.1 C7605.2 R7609.2 R7610.1 R7611.2 U7600.J14 U7601.J14
FBA_VREF_DQ1: C7600.1 C7604.1 R7600.1 R7601.2 R7608.2 U7600.A10 U7600.U10 U7601.A10 U7601.U10
FBA_WCK01: U7000.V46 U7600.D4
FBA_WCK01#: U7000.V45 U7600.D5
FBA_WCK23: U7000.AD41 U7600.P4
FBA_WCK23#: U7000.AD40 U7600.P5
FBA_WCK45: U7000.AT44 U7601.D4
FBA_WCK45#: U7000.AT43 U7601.D5
FBA_WCK67: U7000.AM42 U7601.P4
FBA_WCK67#: U7000.AM41 U7601.P5
FBA_ZQ0: R7612.2 U7600.J13
FBA_ZQ1: R7613.2 U7601.J13
FBB_CLK0: R7704.1 U7000.E41 U7700.J12
FBB_CLK0#: R7704.2 U7000.F41 U7700.J11
FBB_CLK1: R7702.1 U7000.E42 U7701.J12
FBB_CLK1#: R7702.2 U7000.D42 U7701.J11
FBB_CMD0: U7000.C29 U7700.G3
FBB_CMD1: R7103.1 U7000.B29 U7700.J3
FBB_CMD2: R7106.2 U7000.A29 U7700.J2
FBB_CMD3: U7000.A30 U7700.L3
FBB_CMD4: U7000.B30 U7700.K5
FBB_CMD5: U7000.B32 U7700.K4
FBB_CMD6: U7000.A32 U7700.J5
FBB_CMD7: U7000.C32 U7700.J4
FBB_CMD8: U7000.A33 U7700.H5
FBB_CMD9: U7000.B33 U7700.H4
FBB_CMD10: U7000.B35 U7700.G12
FBB_CMD11: U7000.A35 U7700.H10
FBB_CMD12: U7000.C35 U7700.H11
FBB_CMD13: U7000.A36 U7700.K11
FBB_CMD14: U7000.B36 U7700.K10
FBB_CMD15: U7000.B38 U7700.L12
FBB_CMD16: U7000.D49 U7701.L3
FBB_CMD17: R7104.1 U7000.C48 U7701.J3
FBB_CMD18: R7107.2 U7000.B46 U7701.J2
FBB_CMD19: U7000.A46 U7701.G3
FBB_CMD20: U7000.A45 U7701.H5
FBB_CMD21: U7000.C44 U7701.H4
FBB_CMD22: U7000.A44 U7701.J5
FBB_CMD23: U7000.B44 U7701.J4
FBB_CMD24: U7000.C42 U7701.K5
FBB_CMD25: U7000.B42 U7701.K4
FBB_CMD26: U7000.A42 U7701.L12
FBB_CMD27: U7000.A41 U7701.K10
FBB_CMD28: U7000.B41 U7701.K11
FBB_CMD29: U7000.C39 U7701.H11
FBB_CMD30: U7000.B39 U7701.H10
FBB_CMD31: U7000.A39 U7701.G12
FBB_D0: U7000.D30 U7700.E2
FBB_D1: U7000.G30 U7700.F4
FBB_D2: U7000.E30 U7700.F2
FBB_D3: U7000.F30 U7700.E4
FBB_D4: U7000.G29 U7700.B2
FBB_D5: U7000.F29 U7700.A2
FBB_D6: U7000.J29 U7700.B4
FBB_D7: U7000.H29 U7700.A4
FBB_D8: U7000.C33 U7700.E11
FBB_D9: U7000.E33 U7700.F13
FBB_D10: U7000.F33 U7700.E13
FBB_D11: U7000.D33 U7700.F11
FBB_D12: U7000.C30 U7700.A11
FBB_D13: U7000.K33 U7700.A13
FBB_D14: U7000.E32 U7700.B11
FBB_D15: U7000.D32 U7700.B13
FBB_D16: U7000.H39 U7700.T13
FBB_D17: U7000.G39 U7700.N13
FBB_D18: U7000.F39 U7700.T11
FBB_D19: U7000.D41 U7700.N11
FBB_D20: U7000.F38 U7700.M13
FBB_D21: U7000.G38 U7700.U13
FBB_D22: U7000.D38 U7700.M11
FBB_D23: U7000.E38 U7700.U11
FBB_D24: U7000.F36 U7700.N4
FBB_D25: U7000.K35 U7700.T4
FBB_D26: U7000.E36 U7700.M4
FBB_D27: U7000.D36 U7700.U4
FBB_D28: U7000.G35 U7700.U2
FBB_D29: U7000.F35 U7700.T2
FBB_D30: U7000.D35 U7700.M2
FBB_D31: U7000.E35 U7700.N2
FBB_D32: U7000.M44 U7701.F4
FBB_D33: U7000.P42 U7701.F2
FBB_D34: U7000.M43 U7701.E2
FBB_D35: U7000.P43 U7701.E4
FBB_D36: U7000.R45 U7701.B2
FBB_D37: U7000.R46 U7701.A2
FBB_D38: U7000.R43 U7701.B4
FBB_D39: U7000.R44 U7701.A4
FBB_D40: U7000.M47 U7701.A11
FBB_D41: U7000.P44 U7701.E13
FBB_D42: U7000.M46 U7701.B13
FBB_D43: U7000.M45 U7701.B11
FBB_D44: U7000.P47 U7701.E11
FBB_D45: U7000.P49 U7701.F11
FBB_D46: U7000.P45 U7701.F13
FBB_D47: U7000.P46 U7701.A13
FBB_D48: U7000.F46 U7701.M13
FBB_D49: U7000.E47 U7701.N13
FBB_D50: U7000.D47 U7701.U13
FBB_D51: U7000.D48 U7701.T13
FBB_D52: U7000.F48 U7701.T11
FBB_D53: U7000.H46 U7701.U11
FBB_D54: U7000.H47 U7701.M11
FBB_D55: U7000.H48 U7701.N11
FBB_D56: U7000.L45 U7701.T4
FBB_D57: U7000.L44 U7701.U4
FBB_D58: U7000.J46 U7701.U2
FBB_D59: U7000.H49 U7701.M4
FBB_D60: U7000.L47 U7701.T2
FBB_D61: U7000.J49 U7701.N4
FBB_D62: U7000.L48 U7701.M2
FBB_D63: U7000.L49 U7701.N2
FBB_DEBUG0: R7110.1 U7000.D29
FBB_DEBUG1: R7111.1 U7000.C41
FBB_DQM0: U7000.E29 U7700.D2
FBB_DQM1: U7000.G33 U7700.D13
FBB_DQM2: U7000.H38 U7700.P13
FBB_DQM3: U7000.C36 U7700.P2
FBB_DQM4: U7000.P41 U7701.D2
FBB_DQM5: U7000.P48 U7701.D13
FBB_DQM6: U7000.F47 U7701.P13
FBB_DQM7: U7000.L46 U7701.P2
FBB_DQS_WP0: U7000.J30 U7700.C2
FBB_DQS_WP1: U7000.H33 U7700.C13
FBB_DQS_WP2: U7000.D39 U7700.R13
FBB_DQS_WP3: U7000.J35 U7700.R2
FBB_DQS_WP4: U7000.R42 U7701.C2
FBB_DQS_WP5: U7000.M48 U7701.C13
FBB_DQS_WP6: U7000.F49 U7701.R13
FBB_DQS_WP7: U7000.J47 U7701.R2
FBB_MF1: R7715.2 R7716.1 U7700.J1
FBB_MF2: R7717.2 R7718.1 U7701.J1
FBB_VREF_CA1: C7703.1 C7705.1 R7709.2 R7710.1 R7711.2 U7700.J14 U7701.J14
FBB_VREF_DQ1: C7700.1 C7704.1 R7700.1 R7701.2 R7708.2 U7700.A10 U7700.U10 U7701.A10 U7701.U10
FBB_WCK01: U7000.F32 U7700.D4
FBB_WCK01#: U7000.G32 U7700.D5
FBB_WCK23: U7000.G36 U7700.P4
FBB_WCK23#: U7000.H36 U7700.P5
FBB_WCK45: U7000.M42 U7701.D4
FBB_WCK45#: U7000.M41 U7701.D5
FBB_WCK67: U7000.H45 U7701.P4
FBB_WCK67#: U7000.H44 U7701.P5
FBB_ZQ0: R7712.2 U7700.J13
FBB_ZQ1: R7713.2 U7701.J13
FBC_CLK0: R7803.1 U7000.F15 U7800.J12
FBC_CLK0#: R7803.2 U7000.E15 U7800.J11
FBC_CLK1: R7802.1 U7000.J18 U7801.J12
FBC_CLK1#: R7802.2 U7000.K18 U7801.J11
FBC_CMD0: U7000.B3 U7800.G3
FBC_CMD1: R7112.1 U7000.A4 U7800.J3
FBC_CMD2: R7117.2 U7000.B4 U7800.J2
FBC_CMD3: U7000.A5 U7800.L3
FBC_CMD4: U7000.A6 U7800.K5
FBC_CMD5: U7000.B6 U7800.K4
FBC_CMD6: U7000.B11 U7800.J5
FBC_CMD7: U7000.A11 U7800.J4
FBC_CMD8: U7000.C12 U7800.H5
FBC_CMD9: U7000.A12 U7800.H4
FBC_CMD10: U7000.B12 U7800.G12
FBC_CMD11: U7000.C15 U7800.H10
FBC_CMD12: U7000.A15 U7800.H11
FBC_CMD13: U7000.B15 U7800.K11
FBC_CMD14: U7000.B17 U7800.K10
FBC_CMD15: U7000.A17 U7800.L12
FBC_CMD16: U7000.C27 U7801.L3
FBC_CMD17: R7113.1 U7000.B27 U7801.J3
FBC_CMD18: R7114.2 U7000.A27 U7801.J2
FBC_CMD19: U7000.C26 U7801.G3
FBC_CMD20: U7000.A26 U7801.H5
FBC_CMD21: U7000.B26 U7801.H4
FBC_CMD22: U7000.A23 U7801.J5
FBC_CMD23: U7000.B23 U7801.J4
FBC_CMD24: U7000.B21 U7801.K5
FBC_CMD25: U7000.A21 U7801.K4
FBC_CMD26: U7000.C21 U7801.L12
FBC_CMD27: U7000.A20 U7801.K10
FBC_CMD28: U7000.B20 U7801.K11
FBC_CMD29: U7000.C20 U7801.H11
FBC_CMD30: U7000.C18 U7801.H10
FBC_CMD31: U7000.B18 U7801.G12
FBC_D0: U7000.A8 U7800.A4
FBC_D1: U7000.D8 U7800.B2
FBC_D2: U7000.B8 U7800.B4
FBC_D3: U7000.C8 U7800.A2
FBC_D4: U7000.C5 U7800.F4
FBC_D5: U7000.B5 U7800.E4
FBC_D6: U7000.D5 U7800.E2
FBC_D7: U7000.C4 U7800.F2
FBC_D8: U7000.B9 U7800.F11
FBC_D9: U7000.E11 U7800.F13
FBC_D10: U7000.D9 U7800.B11
FBC_D11: U7000.A9 U7800.E11
FBC_D12: U7000.H11 U7800.B13
FBC_D13: U7000.F9 U7800.E13
FBC_D14: U7000.J11 U7800.A13
FBC_D15: U7000.E8 U7800.A11
FBC_D16: U7000.K17 U7800.N11
FBC_D17: U7000.G17 U7800.N13
FBC_D18: U7000.J17 U7800.U13
FBC_D19: U7000.G15 U7800.M13
FBC_D20: U7000.K15 U7800.T13
FBC_D21: U7000.K14 U7800.M11
FBC_D22: U7000.H14 U7800.T11
FBC_D23: U7000.J14 U7800.U11
FBC_D24: U7000.E14 U7800.T4
FBC_D25: U7000.F14 U7800.N4
FBC_D26: U7000.A14 U7800.U4
FBC_D27: U7000.B14 U7800.U2
FBC_D28: U7000.E12 U7800.T2
FBC_D29: U7000.F12 U7800.N2
FBC_D30: U7000.G12 U7800.M2
FBC_D31: U7000.G14 U7800.M4
FBC_D32: U7000.G26 U7801.B4
FBC_D33: U7000.J26 U7801.E4
FBC_D34: U7000.F26 U7801.F4
FBC_D35: U7000.H26 U7801.A4
FBC_D36: U7000.G27 U7801.B2
FBC_D37: U7000.F27 U7801.A2
FBC_D38: U7000.J27 U7801.F2
FBC_D39: U7000.H27 U7801.E2
FBC_D40: U7000.E23 U7801.B11
FBC_D41: U7000.D21 U7801.B13
FBC_D42: U7000.D23 U7801.A11
FBC_D43: U7000.C23 U7801.F13
FBC_D44: U7000.A24 U7801.E13
FBC_D45: U7000.B24 U7801.A13
FBC_D46: U7000.E24 U7801.F11
FBC_D47: U7000.D24 U7801.E11
FBC_D48: U7000.D15 U7801.U11
FBC_D49: U7000.C17 U7801.U13
FBC_D50: U7000.D17 U7801.T11
FBC_D51: U7000.E17 U7801.T13
FBC_D52: U7000.F18 U7801.N11
FBC_D53: U7000.E18 U7801.N13
FBC_D54: U7000.D20 U7801.M13
FBC_D55: U7000.E20 U7801.M11
FBC_D56: U7000.G20 U7801.U4
FBC_D57: U7000.H20 U7801.U2
FBC_D58: U7000.F20 U7801.T4
FBC_D59: U7000.H21 U7801.N2
FBC_D60: U7000.F23 U7801.N4
FBC_D61: U7000.G23 U7801.T2
FBC_D62: U7000.H23 U7801.M4
FBC_D63: U7000.K23 U7801.M2
FBC_DEBUG0: R7120.1 U7000.C9
FBC_DEBUG1: R7121.1 U7000.C24
FBC_DQM0: U7000.E6 U7800.D2
FBC_DQM1: U7000.E9 U7800.D13
FBC_DQM2: U7000.H17 U7800.P13
FBC_DQM3: U7000.D12 U7800.P2
FBC_DQM4: U7000.K27 U7801.D2
FBC_DQM5: U7000.E21 U7801.D13
FBC_DQM6: U7000.F17 U7801.P13
FBC_DQM7: U7000.J23 U7801.P2
FBC_DQS_WP0: U7000.D6 U7800.C2
FBC_DQS_WP1: U7000.F11 U7800.C13
FBC_DQS_WP2: U7000.H15 U7800.R13
FBC_DQS_WP3: U7000.C14 U7800.R2
FBC_DQS_WP4: U7000.E27 U7801.C2
FBC_DQS_WP5: U7000.F24 U7801.C13
FBC_DQS_WP6: U7000.H18 U7801.R13
FBC_DQS_WP7: U7000.G21 U7801.R2
FBC_MF1: R7815.2 R7816.1 U7800.J1
FBC_MF2: R7817.2 R7818.1 U7801.J1
FBC_VREF_CA1: C7803.1 C7805.1 R7809.2 R7810.1 R7811.2 U7800.J14 U7801.J14
FBC_VREF_DQ1: C7800.1 C7804.1 R7800.1 R7801.2 R7808.2 U7800.A10 U7800.U10 U7801.A10 U7801.U10
FBC_WCK01: U7000.F8 U7800.D4
FBC_WCK01#: U7000.G8 U7800.D5
FBC_WCK23: U7000.H12 U7800.P4
FBC_WCK23#: U7000.J12 U7800.P5
FBC_WCK45: U7000.D26 U7801.D4
FBC_WCK45#: U7000.E26 U7801.D5
FBC_WCK67: U7000.J20 U7801.P4
FBC_WCK67#: U7000.K20 U7801.P5
FBC_ZQ0: R7812.2 U7800.J13
FBC_ZQ1: R7813.2 U7801.J13
FBD_CLK0: R7903.1 U7000.V9 U7900.J12
FBD_CLK0#: R7903.2 U7000.V10 U7900.J11
FBD_CLK1: R7902.1 U7000.R6 U7901.J12
FBD_CLK1#: R7902.2 U7000.R5 U7901.J11
FBD_CMD0: U7000.AG3 U7900.G3
FBD_CMD1: R7115.1 U7000.AG2 U7900.J3
FBD_CMD2: R7118.2 U7000.AG1 U7900.J2
FBD_CMD3: U7000.AF3 U7900.L3
FBD_CMD4: U7000.AF1 U7900.K5
FBD_CMD5: U7000.AF2 U7900.K4
FBD_CMD6: U7000.AC1 U7900.J5
FBD_CMD7: U7000.AC2 U7900.J4
FBD_CMD8: U7000.AA2 U7900.H5
FBD_CMD9: U7000.AA1 U7900.H4
FBD_CMD10: U7000.AA3 U7900.G12
FBD_CMD11: U7000.Y1 U7900.H10
FBD_CMD12: U7000.Y2 U7900.H11
FBD_CMD13: U7000.Y3 U7900.K11
FBD_CMD14: U7000.V3 U7900.K10
FBD_CMD15: U7000.V2 U7900.L12
FBD_CMD16: U7000.C2 U7901.L3
FBD_CMD17: R7116.1 U7000.D1 U7901.J3
FBD_CMD18: R7119.2 U7000.D2 U7901.J2
FBD_CMD19: U7000.E1 U7901.G3
FBD_CMD20: U7000.F2 U7901.H5
FBD_CMD21: U7000.F1 U7901.H4
FBD_CMD22: U7000.L2 U7901.J5
FBD_CMD23: U7000.L1 U7901.J4
FBD_CMD24: U7000.M3 U7901.K5
FBD_CMD25: U7000.M1 U7901.K4
FBD_CMD26: U7000.M2 U7901.L12
FBD_CMD27: U7000.R3 U7901.K10
FBD_CMD28: U7000.R1 U7901.K11
FBD_CMD29: U7000.R2 U7901.H11
FBD_CMD30: U7000.U2 U7901.H10
FBD_CMD31: U7000.U1 U7901.G12
FBD_D0: U7000.AF7 U7900.F2
FBD_D1: U7000.AF9 U7900.B4
FBD_D2: U7000.AF6 U7900.E4
FBD_D3: U7000.AF8 U7900.F4
FBD_D4: U7000.AG7 U7900.A4
FBD_D5: U7000.AG6 U7900.A2
FBD_D6: U7000.AG9 U7900.E2
FBD_D7: U7000.AG8 U7900.B2
FBD_D8: U7000.AC5 U7900.E13
FBD_D9: U7000.AA4 U7900.F13
FBD_D10: U7000.AC4 U7900.F11
FBD_D11: U7000.AC3 U7900.E11
FBD_D12: U7000.AD4 U7900.B11
FBD_D13: U7000.AD2 U7900.A11
FBD_D14: U7000.AD5 U7900.B13
FBD_D15: U7000.AD1 U7900.A13
FBD_D16: U7000.R4 U7900.U13
FBD_D17: U7000.U3 U7900.T11
FBD_D18: U7000.U4 U7900.T13
FBD_D19: U7000.U5 U7900.U11
FBD_D20: U7000.V6 U7900.N13
FBD_D21: U7000.V5 U7900.M13
FBD_D22: U7000.Y4 U7900.M11
FBD_D23: U7000.Y5 U7900.N11
FBD_D24: U7000.Y6 U7900.U4
FBD_D25: U7000.Y7 U7900.M4
FBD_D26: U7000.Y8 U7900.U2
FBD_D27: U7000.AC9 U7900.N2
FBD_D28: U7000.AC7 U7900.N4
FBD_D29: U7000.AC6 U7900.T2
FBD_D30: U7000.AC8 U7900.M2
FBD_D31: U7000.AC10 U7900.T4
FBD_D32: U7000.H2 U7901.F4
FBD_D33: U7000.H4 U7901.A4
FBD_D34: U7000.H1 U7901.E4
FBD_D35: U7000.H3 U7901.B4
FBD_D36: U7000.F5 U7901.F2
FBD_D37: U7000.E2 U7901.B2
FBD_D38: U7000.E4 U7901.A2
FBD_D39: U7000.D3 U7901.E2
FBD_D40: U7000.J4 U7901.A11
FBD_D41: U7000.L5 U7901.A13
FBD_D42: U7000.J2 U7901.B13
FBD_D43: U7000.J1 U7901.E11
FBD_D44: U7000.J6 U7901.B11
FBD_D45: U7000.H5 U7901.F11
FBD_D46: U7000.L9 U7901.F13
FBD_D47: U7000.L8 U7901.E13
FBD_D48: U7000.U10 U7901.N13
FBD_D49: U7000.U7 U7901.U13
FBD_D50: U7000.U9 U7901.M13
FBD_D51: U7000.R7 U7901.T13
FBD_D52: U7000.R10 U7901.M11
FBD_D53: U7000.P10 U7901.U11
FBD_D54: U7000.P8 U7901.N11
FBD_D55: U7000.P9 U7901.T11
FBD_D56: U7000.P5 U7901.N4
FBD_D57: U7000.P6 U7901.T2
FBD_D58: U7000.P2 U7901.U2
FBD_D59: U7000.P1 U7901.U4
FBD_D60: U7000.M5 U7901.M4
FBD_D61: U7000.M6 U7901.N2
FBD_D62: U7000.M7 U7901.M2
FBD_D63: U7000.P7 U7901.T4
FBD_DEBUG0: R7122.1 U7000.AD3
FBD_DEBUG1: R7123.1 U7000.J3
FBD_DQM0: U7000.AG10 U7900.D2
FBD_DQM1: U7000.AA5 U7900.D13
FBD_DQM2: U7000.U6 U7900.P13
FBD_DQM3: U7000.AA8 U7900.P2
FBD_DQM4: U7000.E3 U7901.D2
FBD_DQM5: U7000.J5 U7901.D13
FBD_DQM6: U7000.U8 U7901.P13
FBD_DQM7: U7000.M4 U7901.P2
FBD_DQS_WP0: U7000.AG5 U7900.C2
FBD_DQS_WP1: U7000.AD7 U7900.C13
FBD_DQS_WP2: U7000.V8 U7900.R13
FBD_DQS_WP3: U7000.AA7 U7900.R2
FBD_DQS_WP4: U7000.F4 U7901.C2
FBD_DQS_WP5: U7000.L7 U7901.C13
FBD_DQS_WP6: U7000.R8 U7901.R13
FBD_DQS_WP7: U7000.P3 U7901.R2
FBD_MF1: R7915.2 R7916.1 U7900.J1
FBD_MF2: R7917.2 R7918.1 U7901.J1
FBD_VREF_CA1: C7903.1 C7905.1 R7909.2 R7910.1 R7911.2 U7900.J14 U7901.J14
FBD_VREF_DQ1: C7900.1 C7904.1 R7900.1 R7901.2 R7908.2 U7900.A10 U7900.U10 U7901.A10 U7901.U10
FBD_WCK01: U7000.AF4 U7900.D4
FBD_WCK01#: U7000.AF5 U7900.D5
FBD_WCK23: U7000.Y9 U7900.P4
FBD_WCK23#: U7000.Y10 U7900.P5
FBD_WCK45: U7000.H6 U7901.D4
FBD_WCK45#: U7000.H7 U7901.D5
FBD_WCK67: U7000.M8 U7901.P4
FBD_WCK67#: U7000.M9 U7901.P5
FBD_ZQ0: R7912.2 U7900.J13
FBD_ZQ1: R7913.2 U7901.J13
FBVDDQ_SENSE: C8907.2 R7503.2 R8909.1 U8900.12
FBX_PLL_AVDD: C7100.1 C7101.1 C7102.1 C7105.1 C7106.1 C7107.1 L7100.1 U7000.AA11 U7000.AJ39 U7000.L26 U7000.L36
FCCM_A: U8000.24 U8001.2 U8002.2 U8003.2
FCCM_B: U8000.11 U8004.2 U8006.2
FCCM_C: U8000.34 U8005.7
FORCE_OFF#: D5004.2 Q9200.6 R5014.1 T9206.1
FORCE_OFF_PWR: C9200.1 Q8106.2 Q8106.5 Q9200.2 Q9200.3 R9204.2 R9205.1
FP_RST_DBR_N_CPUXDP: C4402.1 R4419.1 XDP4400.48
G1: R3707.1 R3709.2 U3700.11
G2: R3708.1 R3710.2 U3700.12
GATE_SQ14: Q3100.1 Q3102.1 R3112.1 R3114.1
GC6_FB_EN: D7402.1 R2357.2 R7436.1 U2000.AV43 U7000.AT7
GEN1_I2C_SCL: R5803.2 U5800.12
GEN1_I2C_SDA: R5804.2 U5800.2
GPD8_SUSCLK: R2458.1 T2411.1 U2000.AN15
GPG2_EC: R3001.2 R3084.1 U3001.100
GPIO0: R1227.1 U1201.B2
GPIO2: T1208.1 U1201.D10
GPIO2_GPU_EVENT#: Q7400.2 R7437.1 R7450.1 U7000.AV1
GPIO3: T1207.1 U1201.G11
GPIO3_OC_WARN: R7447.1 U7000.AW4
GPIO5_FRAMELOCK#: T7404.1 U7000.AT4
GPIO6: R1229.1 U1201.G10
GPIO7: R1228.1 U1201.D7
GPIO7_BL_PWM: T7405.1 U7000.AT10
GPIO8_THERM_SHDWN#: Q7404.2 R7444.1 U7000.AV7
GPIO10_ALT_MEM_VREF: Q7600.1 Q7700.1 Q7800.1 Q7900.1 R7429.2 U7000.AT6
GPIO12_AC_BATT#: Q7405.3 R7423.1 R8821.2 U7000.AV4
GPIO23_GPU_PEX_RST_HOLD: D7001.2 R7445.2 U7000.AV3
GPP_A6_SERIRQ: R2203.2 R2224.2 U2000.BA17
GPP_A14_SUS_STAT#_ESPI_RST#: R2226.2 U2000.BC18
GPP_A18_ISH_GP0: R2239.2 U2000.BB22
GPP_A19_ISH_GP1: R2238.2 U2000.BD21
GPP_A21_ISH_GP3: R2237.2 U2000.BE21
GPP_A22_ISH_GP4: R2236.2 U2000.BD18
GPP_D5: R2316.2 U2000.AJ33
GPP_D6: R2317.2 U2000.AM43
GPP_D7: R2318.2 U2000.AN42
GPP_D8: R2319.2 U2000.AL42
GPP_H23: R2463.2 U2000.BD36
GPP_H_16_SML4CLK: R2466.2 U2000.BD39
GPP_H_17_SML4DATA: R2469.2 U2000.BE34
GPP_I5: R2158.2 U2000.BA5
GPP_I6: R2159.2 U2000.BC4
GPP_I7: R2156.2 U2000.BB3
GPP_I8: R2101.2 U2000.BD6
GPP_I9: R2160.2 U2000.BE5
GPP_I10: R2161.2 U2000.BE6
GPU MAINPOWER_DISCH_G: Q5700.1 Q5701.1 Q5702.1 Q5703.1 Q5704.3 Q5705.1 R5704.2
GPU_ALERT#: Q7403.3 R2371.2 U2000.AT44
GPU_BAT_THRO: Q7405.1 R2409.2 U2000.BC23
GPU_EVENT#: Q7400.3 R2358.2 R7450.2 U2000.AU44
GPU_ID0: R6113.2 R6114.1 U2000.U39
GPU_ID1: R6115.2 R6116.1 U2000.N42
GPU_IPC_SCL: R7405.2 U7000.BD2 U8702.6
GPU_IPC_SDA: R7406.2 U7000.BD1 U8702.7
GPU_OVERT#: R2364.2 R7446.1 U2000.AR45
GPU_PLLVDD: C7103.1 C7104.1 C7211.1 C7212.1 C7213.1 C7214.1 L7202.2 U7000.AC39 U7000.AD11 U7000.AT11 U7000.L21 U7000.Y39
GPU_THERM_ALERT#: Q7403.2 R7414.2 U7000.AW7
GSEN_INT_1: R5805.2 U5800.5
GSEN_INT_2: R5807.2 U5800.6
GSENSOR_INT1_PCH: R2246.2 R5805.1 U2000.R35
GSENSOR_INT2: R5131.2 R5807.1
GSPI0_CLK_50MHZ: R2403.2 U2000.AW27
GSPI0_CS#: R2419.2 U2000.AR24
GSPI0_MISO: R2404.2 U2000.BD27
GSPI1_CLK: R2418.2 U2000.AV29
GSPI1_CS#: R2400.2 U2000.BC27
GSPI1_MISO: R2401.2 U2000.AR29
GSPI1_MOSI: R2402.2 R2424.2 U2000.AT29
H_BPM_N0: R4407.2 U0300.BR27
H_BPM_N0_R: R4407.1 XDP4400.21
H_BPM_N1: R4408.2 U0300.BT27
H_BPM_N1_R: R4408.1 XDP4400.23
H_CFG0: R0702.1 R4416.2 U0300.BN25 XDP4400.9
H_CFG1: R0701.1 U0300.BN27 XDP4400.11
H_CFG2: R0723.1 U0300.BN26 XDP4400.15
H_CFG3: R0725.1 R4422.2 U0300.BN28 XDP4400.17
H_CFG4: R0724.1 U0300.BR20 XDP4400.27
H_CFG5: R0703.1 R0745.2 U0300.BM20 XDP4400.29
H_CFG6: R0705.1 R0744.2 U0300.BT20 XDP4400.33
H_CFG7: R0709.1 U0300.BP20 XDP4400.35
H_CFG8: R0726.1 U0300.BR23 XDP4400.10
H_CFG9: R0700.2 R0710.1 U0300.BR22 XDP4400.12
H_CFG10: R0712.1 U0300.BT23 XDP4400.16
H_CFG11: R0714.1 U0300.BT22 XDP4400.18
H_CFG12: R0713.1 U0300.BM19 XDP4400.28
H_CFG13: R0715.1 U0300.BR19 XDP4400.30
H_CFG14: R0719.1 U0300.BP19 XDP4400.34
H_CFG15: R0718.1 U0300.BT19 XDP4400.36
H_CFG16: U0300.BP23 XDP4400.6
H_CFG17: U0300.BN23 XDP4400.4
H_CFG18: U0300.BN22 XDP4400.24
H_CFG19: U0300.BP22 XDP4400.22
H_PECI_EC: R0733.1 U3001.117
H_PRDY#: R2325.2 U0300.BP27 XDP4400.5
H_PREQ#: R0738.2 R4403.1 U0300.BL30 XDP4400.3
H_TCK: R0741.1 R2346.2 U0300.BR28 XDP4400.57
H_TDI: R0737.2 R2345.1 U0300.BL32 XDP4400.56
H_TDO: R0739.2 R2344.2 U0300.BT28 XDP4400.52
H_THMTRIP#: R2450.2 R2454.2 U0300.J31
H_TMS: R0736.2 R2343.1 U0300.BP28 XDP4400.58
H_TRIGIN: R2326.2 U0300.H23
H_TRIGOUT: R0743.1 U2000.AK1
H_TRST#: R0740.1 R2322.1 U0300.BP30 XDP4400.54
HDA_AZRST#_L500MIL: R2306.2 U2000.BD8
HDA_BCLK: C2301.1 R2301.1 R3616.2
HDA_BCLK_R: C3629.1 R3616.1 U3600.6
HDA_BITCLK_24MHZ_L500MIL: R2301.2 U2000.BA9
HDA_RST#: C2300.1 C3626.1 Q3601.5 R2306.1 U3600.11
HDA_SDI0: C2310.1 R3613.1 U2000.BE7
HDA_SDO: C2303.1 R2308.1 U3600.5
HDA_SDO_L500MIL: D2301.2 R2308.2 R2378.2 U2000.BB7
HDA_SPKR_LN: R3627.2 U3600.43
HDA_SPKR_LP: R3628.2 U3600.42
HDA_SPKR_RN: R3626.2 U3600.44
HDA_SPKR_RP: R3625.2 U3600.45
HDA_SYNC: C2302.1 R2300.1 U3600.10
HDA_SYNC_L500MIL: R2300.2 U2000.BD9
HDMI_CEXT: C1304.1 U1301.2
HDMI_CFG0: R1304.2 R1305.1 U1301.5
HDMI_CFG1: R1306.2 R1307.1 U1301.40
HDMI_HOTPLUG_DET: CON4800.19 Q4801.3 R4803.1
HDMI_OUT_5V_L1: D4800.1 R4806.1
HDMI_OUT_5V_L2: D4800.2 R4807.1
HDMI_OUT_CLK_N: CON4800.12 L4803.3 RN4803.1
HDMI_OUT_CLK_P: CON4800.10 L4803.4 RN4803.3
HDMI_OUT_DATA0_N: CON4800.9 L4800.3 RN4800.1
HDMI_OUT_DATA0_P: CON4800.7 L4800.4 RN4800.3
