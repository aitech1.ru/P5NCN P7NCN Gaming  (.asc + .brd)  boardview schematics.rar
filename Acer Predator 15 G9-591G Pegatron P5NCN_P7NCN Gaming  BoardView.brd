# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_DQS_WP7: length 26.2
  IN2 w0.146: v6(105.11,159.1) 105.11,160.19 105.44,160.52 105.44,161.03 105.14,161.33 104.97,161.33 104.66,161.64 104.66,162.3 104.86,162.51 104.86,164.04 108.44,167.61 108.44,171.28 108.43,171.29 108.43,176.75 107.44,177.74 107.44,178.96 107.65,179.16 107.65,179.84 v6(106.4,181.09)
  BOTTOM w0.133: v6(105.11,159.1) U7000.AK47 ; U7601.R2 v6(106.4,181.09)
FBA_MF1: length 3.5
  TOP w0.381: R7616.1 131.39,176.32 v1(131.57,176.13) ; R7616.1 130.18,176.32 129.97,176.52 v6(129.97,176.67) ; R7616.1 R7615.2
  BOTTOM w0.254: U7600.J1 v6(129.97,176.67)
FBA_MF2: length 5.2
  TOP w0.254: v1(102.01,178.66) 102.24,178.43 R7617.2 102.25,177.7 102.63,177.7 R7618.1 103.18,177.16 v2(103.18,176.37)
  BOTTOM w0.254: U7601.J1 104.32,176.67 104.02,176.37 v2(103.18,176.37)
FBA_VREF_CA1: length 38.6
  TOP w0.305: R7609.2 133.01,172.61 132.75,172.35 v1(132.75,171.8)
  TOP w0.381: v6(116.13,177.31) 116.51,177.31 116.64,177.18 C7605.2 C7603.1 ; R7609.2 133.6,172.92 132.89,173.63 v2(132.89,173.7) ; C7603.1 v6(118.34,176.8) ; C7603.1 117.53,177.48 117.72,177.68 R7611.2 R7610.1 117.73,179.14 118.08,179.49 v6(118.29,179.49)
  IN1 w0.381: v6(118.29,179.49) 118.81,180.01 118.81,180.72 118.34,181.19 118.34,183.46 119.11,184.23 129.56,184.23 130.1,183.69 130.91,183.69 132.89,181.7 v2(132.89,173.7)
  BOTTOM w0.254: v6(118.34,176.8) 118.47,176.67 U7600.J14
  BOTTOM w0.305: U7601.J14 115.85,176.67 116.13,176.95 v6(116.13,177.31)
FBA_VREF_DQ1: length 77
  TOP w0.381: R7608.2 137.19,175.02 v1(137.19,176.5) 136.03,177.66 131.53,177.66 131.29,177.89 131.29,181.37 129.76,182.91 129.76,183.52 129.1,184.18 124.63,184.18 123.6,183.15 R7600.1 R7601.2 C7600.1 123.28,181.22 122.74,181.76 v6(122.74,182.34) 121.81,183.26 121.81,184.11 121.58,184.34 118.67,184.34 117.84,183.52 116.14,183.52 115.97,183.69 115.45,183.69 115.34,183.58 112.53,183.58 112.03,183.07 v6(111.91,183.07)
  TOP w0.406: C7604.1 v6(111.91,183.07)
  BOTTOM w0.254: v6(122.74,182.34) 122.42,182.66 122.42,182.79 U7600.A10
  BOTTOM w0.305: 119.69,169.83 118.26,169.83 117.63,170.46 117.63,183.02 117.14,183.5 112.85,183.5 U7601.U10 v6(111.91,183.07) ; 119.69,169.83 121.69,169.83 U7600.U10 ; 119.69,169.83 119.69,169.36 118.16,167.84 116.06,167.84 115.37,167.15 112.29,167.15 111.86,167.58 111.86,169.72 U7601.A10
FBA_WCK01: length 34.2
  TOP w0.133: v6(126.56,180.25) 126.72,180.41 127.09,180.41 128.08,179.42 128.08,179.22 128.96,178.34 128.96,175.97 128.36,175.37 126.17,175.37 125.01,174.21 125.01,173.46 124.21,172.66 124.21,170.78 120.04,166.62 120.04,164.29 115.14,159.39 115.14,157.57 115.04,157.48 v6(114.71,157.48)
  BOTTOM w0.133: v6(114.71,157.48) 114.71,158 114.56,158.16 114.56,158.26 114.64,158.35 114.97,158.35 115.1,158.22 U7000.V46 ; v6(126.56,180.25) 126.82,180.25 126.93,180.36 U7600.D4
FBA_WCK01#: length 34
  TOP w0.133: v6(126.57,181.03) 126.94,180.67 127.19,180.67 128.33,179.52 128.33,179.32 129.21,178.45 129.21,175.86 128.47,175.12 126.28,175.12 125.26,174.11 125.26,173.35 124.46,172.55 124.46,170.68 120.29,166.51 120.29,164.19 115.39,159.29 115.39,157.39 v6(114.7,156.7)
  BOTTOM w0.133: U7000.V45 v6(114.7,156.7) ; v6(126.57,181.03) 126.4,180.87 126.33,180.87 U7600.D5
FBA_WCK23: length 29.9
  TOP w0.133: v6(126.53,172.29) 126.37,172.29 125.92,172.74 125.53,172.74 125,172.21 125,170.13 121.32,166.45 121.32,164.34 115.64,158.65 115.64,156.98 113.74,155.09 113.74,154.19 113.36,153.81 110.88,153.81 110.51,154.18 110.08,154.18 109.98,154.27 v6(109.93,154.27)
  BOTTOM w0.133: U7600.P4 126.73,172.48 126.71,172.48 v6(126.53,172.29) ; v6(109.93,154.27) U7000.AD41
FBA_WCK23#: length 29.8
  TOP w0.133: v6(109.93,153.47) 109.93,153.71 110.15,153.92 110.41,153.92 110.77,153.56 113.47,153.56 114,154.09 114,154.98 115.89,156.88 115.89,158.55 121.57,164.23 121.57,166.35 125.25,170.03 125.25,172.11 125.48,172.33 v6(125.73,172.33)
  BOTTOM w0.133: U7000.AD40 110.53,153.1 110.64,153.21 110.64,153.32 110.49,153.47 v6(109.93,153.47) ; v6(125.73,172.33) 125.91,172.5 125.96,172.5 U7600.P5
FBA_WCK45: length 25.7
  IN1 w0.102: v6(108.03,172.28) 108.44,172.69 108.44,172.75 108.65,172.96 109.3,172.96 109.63,172.64 109.63,171.05 109.23,170.65 109.23,170.29 109.56,169.96 109.56,169.52 105.53,165.5 103.56,165.5 101.78,163.71 101.78,162.42 101.36,162 101.36,160.21 100.9,159.76 100.9,158.05 100.39,157.54 100.39,156.18 100.67,155.9 v6(101.1,155.9)
  BOTTOM w0.133: U7000.AT44 v6(101.1,155.9) ; v6(108.03,172.28) 107.87,172.43 107.86,172.43 U7601.D4
FBA_WCK45#: length 25.6
  IN1 w0.102: v6(108.84,172.28) 108.84,172.28 108.64,172.48 108.64,172.68 108.73,172.77 109.23,172.77 109.44,172.56 109.44,171.12 109.04,170.73 109.04,170.21 109.37,169.88 109.37,169.6 105.45,165.69 103.48,165.69 101.59,163.79 101.59,162.5 101.17,162.08 101.17,160.29 100.71,159.83 100.71,158.13 100.2,157.62 100.2,156.1 101.1,155.2 v6(101.1,155.16)
  BOTTOM w0.133: U7601.D5 108.61,172.48 108.64,172.48 v6(108.84,172.28) ; v6(101.1,155.16) 100.89,155.16 100.7,155.35 U7000.AT43
FBA_WCK67: length 30.1
  IN4 w0.102: v6(104.26,155.1) 103.91,155.1 103.81,155.2 103.81,162.65 104.32,163.16 104.32,164.59 106.41,166.69 106.41,179.39 107.4,180.37 107.72,180.7 107.89,180.7 107.98,180.61 v7(107.98,180.28)
  BOTTOM w0.133: v7(107.98,180.28) 107.45,180.28 107.32,180.41 107.32,180.56 107.42,180.67 U7601.P4 ; U7000.AM42 104.17,154.7 104.26,154.79 v6(104.26,155.1)
FBA_WCK67#: length 30.1
  IN4 w0.102: v6(108.04,181.05) 107.88,180.89 107.64,180.89 107.26,180.51 106.22,179.47 106.22,166.77 104.13,164.67 104.13,163.24 103.62,162.73 103.62,154.98 v7(104.3,154.3)
  BOTTOM w0.133: v6(108.04,181.05) 108.3,180.8 108.3,180.79 U7601.P5 ; U7000.AM41 v7(104.3,154.3)
FBA_ZQ0: length 3
  TOP w0.102: R7612.2 119.56,178.66 v1(119.94,178.66)
  TOP w0.203: v6(119.28,177.05) 118.92,177.41 R7612.2
  BOTTOM w0.203: U7600.J13 119.51,176.89 119.45,176.89 v6(119.28,177.05)
FBA_ZQ1: length 2.2
  TOP w0.254: v1(115.67,176.62) 115.67,176.62 v6(115.21,177.08)
  TOP w0.381: R7613.2 114.63,176.49 v6(115.21,177.08)
  BOTTOM w0.305: U7601.J13 114.81,176.68 v6(115.21,177.08)
FBB_CLK0: length 44.1
  TOP w0.133: R7704.1 147.37,165.88 147.37,165.33 v6(147.56,165.14)
  IN1 w0.102: v6(147.56,165.14) 147.12,164.7 146.39,164.7 145.52,165.56 144.75,165.56 144.54,165.78 144.54,166.02 144.43,166.12 144.16,166.12 144.05,166.02 144.05,165.78 143.84,165.56 143.33,165.56 143.12,165.35 142.55,165.35 142.13,165.77 141.27,165.77 138.99,163.49 138.99,161.43 138.34,160.79 138.34,160.64 138.66,160.33 138.66,160.03 138.35,159.72 138.04,159.72 137.73,160.03 137.59,160.03 137.39,159.83 137.39,159.69 137.7,159.38 137.7,159.08 137.39,158.77 137.09,158.77 136.78,159.08 136.64,159.08 136.44,158.88 136.44,158.74 136.75,158.43 136.75,158.12 136.44,157.81 136.14,157.81 135.83,158.13 135.68,158.13 135.49,157.93 135.49,157.78 135.8,157.47 135.8,157.17 135.49,156.86 135.19,156.86 134.87,157.17 134.73,157.17 134.13,156.57 133.25,156.57 131.42,154.74 131.42,154.59 132.09,153.92 132.09,153.58 131.73,153.22 131.39,153.22 130.72,153.89 130.57,153.89 130.21,153.52 129.54,153.52 129.44,153.42 129.44,152.19 129.2,151.95 127.45,151.95 127.22,152.19 127.22,152.65 127.45,152.89 127.91,152.89 128.08,153.06 128.08,153.56 127.7,153.95 126.55,153.95 126.07,153.47 v7(125.07,153.47)
  BOTTOM w0.133: v6(147.56,165.14) 147.56,165.14 147.37,165.33 147.37,165.41 U7700.J12 ; U7000.E41 v7(125.07,153.47)
FBB_CLK0#: length 44.3
  TOP w0.133: v7(146.84,165.14) 147.12,165.41 147.12,165.83 R7704.2
  IN1 w0.102: v6(125.12,154.32) 125.4,154.32 125.53,154.19 125.53,153.94 125.81,153.66 125.99,153.66 126.47,154.14 127.78,154.14 128.27,153.64 128.27,152.98 127.99,152.7 127.53,152.7 127.41,152.57 127.41,152.27 127.53,152.14 129.12,152.14 129.25,152.27 129.25,153.5 129.46,153.72 130.13,153.72 130.49,154.08 130.79,154.08 131.47,153.41 131.65,153.41 131.9,153.66 131.9,153.84 131.23,154.51 131.23,154.81 133.17,156.76 134.05,156.76 134.65,157.36 134.95,157.36 135.26,157.05 135.41,157.05 135.61,157.25 135.61,157.39 135.3,157.71 135.3,158.01 135.6,158.32 135.91,158.32 136.22,158.01 136.36,158.01 136.56,158.2 136.56,158.35 136.25,158.66 136.25,158.96 136.56,159.27 136.86,159.27 137.17,158.96 137.31,158.96 137.51,159.16 137.51,159.3 137.2,159.61 137.2,159.91 137.51,160.22 137.81,160.22 138.12,159.91 138.27,159.91 138.47,160.11 138.47,160.25 138.15,160.56 138.15,160.87 138.8,161.51 138.8,163.57 141.19,165.96 142.21,165.96 142.63,165.54 143.04,165.54 143.25,165.75 143.76,165.75 143.86,165.85 143.86,166.1 144.08,166.31 144.51,166.31 144.73,166.1 144.73,165.85 144.83,165.75 145.6,165.75 146.46,164.89 146.59,164.89 v7(146.84,165.14)
  BOTTOM w0.133: U7000.F41 124.98,153.9 125.12,154.04 v6(125.12,154.32) ; v7(146.84,165.14) 146.84,164.72 146.96,164.61 147.12,164.61 147.24,164.73 U7700.J11
FBB_CLK1: length 45.3
  TOP w0.133: v6(148.4,172.17) 148.64,172.4 148.64,172.66 148.36,172.94 R7702.1
  IN1 w0.102: v7(125.91,155.08) 126.15,154.83 128.97,154.83 129.2,154.6 129.71,154.6 131.31,156.2 131.31,156.34 131.1,156.55 131.1,156.85 131.41,157.16 131.71,157.16 131.92,156.95 132.06,156.95 132.61,157.51 133.6,157.51 137.81,161.71 137.81,163.77 138.7,164.67 138.7,164.81 138.48,165.03 138.48,165.33 138.79,165.64 139.09,165.64 139.31,165.42 139.46,165.42 140.56,166.53 140.56,167.98 140.96,168.37 144.2,168.37 144.5,168.68 144.95,168.68 145.25,168.37 145.79,168.37 146,168.16 146,167.47 146.1,167.37 146.51,167.37 146.61,167.47 146.61,168.16 146.82,168.37 147.89,168.37 148.35,167.91 148.35,167.68 148.48,167.56 149.05,167.56 149.17,167.68 149.17,168.17 149.5,168.5 149.5,168.92 149.38,169.04 148.09,169.04 147.64,169.5 147.64,170.71 148.59,171.66 148.59,171.98 v6(148.4,172.17)
  BOTTOM w0.133: v6(148.4,172.17) 148.4,171.89 148.49,171.8 U7701.J12 ; U7000.E42 125.33,154.7 125.2,154.83 125.2,155 125.33,155.13 125.53,155.13 125.58,155.08 v7(125.91,155.08)
FBB_CLK1#: length 44.9
  TOP w0.133: v7(149.18,172.19) 148.9,172.47 148.9,172.62 149.23,172.94 R7702.2
  IN1 w0.102: v7(149.18,172.19) 148.78,171.78 148.78,171.58 147.83,170.63 147.83,169.58 148.17,169.23 149.46,169.23 149.7,168.99 149.7,168.42 149.36,168.09 149.36,167.6 149.13,167.37 148.4,167.37 148.16,167.6 148.16,167.84 147.81,168.18 146.9,168.18 146.8,168.08 146.8,167.39 146.59,167.18 146.02,167.18 145.81,167.39 145.81,168.08 145.71,168.18 145.18,168.18 144.87,168.49 144.58,168.49 144.28,168.18 141.04,168.18 140.75,167.9 140.75,166.45 139.54,165.23 139.24,165.23 139.01,165.45 138.87,165.45 138.67,165.25 138.67,165.11 138.89,164.89 138.89,164.59 138,163.69 138,161.64 133.68,157.31 132.69,157.31 132.14,156.76 131.84,156.76 131.63,156.97 131.49,156.97 131.29,156.77 131.29,156.63 131.5,156.42 131.5,156.12 129.79,154.41 129.12,154.41 128.89,154.64 126.19,154.64 v6(125.9,154.35)
  BOTTOM w0.133: U7000.D42 126.15,154.55 126.1,154.55 v6(125.9,154.35) ; v7(149.18,172.19) U7701.J11
FBB_CMD0: length 34.2
  TOP w0.133: v6(148.48,157.98) 148.02,157.52 147.01,157.52 146.86,157.37 146.86,157.22 146.71,157.07 146,157.07 144.78,155.84 144.78,154.75 144.48,154.45 143.56,154.45 143.29,154.72 138.6,154.72 138.28,154.4 138.28,154.06 139.11,153.23 139.11,153.04 138.85,152.77 138.66,152.77 138.3,153.13 138.11,153.13 137.71,152.73 137.71,152.54 138.55,151.7 138.55,151.52 138.28,151.25 138.1,151.25 137.31,152.04 136.3,152.04 135.66,151.4 135.36,151.4 133.02,149.05 v1(132.84,149.05) 132.1,149.05 131.57,148.53 131.57,147.09 v6(130.2,145.72)
  BOTTOM w0.133: v6(148.48,157.98) 148.49,157.98 U7700.G3 ; U7000.C29 127.52,144.72 129.2,144.72 v6(130.2,145.72)
FBB_CMD1: length 28.3
  BOTTOM w0.089: U7000.B29 128.08,144.3 128.42,143.96 129.6,143.96 129.98,144.34
  BOTTOM w0.133: U7700.J3 147.59,157.99 147.59,156.24 146.28,154.93 140.05,154.93 135.61,150.49 135.61,149.76 133.66,147.81 133.04,147.81 132.79,147.56 R7103.1 131.95,146.9 v1(131.7,146.65) 131.14,146.09 131.14,145.5 129.98,144.34
FBB_CMD2: length 30.4
  BOTTOM w0.133: U7700.J2 146.81,157.11 146.81,156.61 146.36,156.15 146.36,155.59 146.02,155.26 145.85,155.26 145.72,155.39 145.72,156.08 145.59,156.2 145.26,156.2 145.14,156.08 145.14,155.36 145.01,155.24 144.65,155.24 144.53,155.36 144.53,156.2 144.4,156.33 143.94,156.33 143.82,156.2 143.82,155.39 143.69,155.26 141.22,155.26 141.05,155.44 141.05,155.9 140.92,156.02 140.54,156.02 140.41,155.9 140.41,155.46 140.21,155.26 139.14,155.26 138.79,154.91 v1(138.79,154.55) 138.79,154.23 133.53,148.97 R7106.2 133.53,148.53 133.21,148.21 132.5,148.21 130.68,146.4 130.68,145.61 129.37,144.3 U7000.A29
FBB_CMD3: length 30.2
  TOP w0.133: v6(146.08,157.98) 145.63,157.53 145.04,157.53 144.85,157.33 144.85,156.6 143.39,155.14 v1(138.15,155.14) 137.54,155.14 136.93,154.52 136.93,154.33 137.64,153.61 137.64,153.44 137.37,153.16 137.19,153.16 136.47,153.88 136.29,153.88 136,153.59 136,153.4 136.31,153.1 136.31,152.91 136.04,152.64 135.86,152.64 135.55,152.95 135.36,152.95 135.09,152.69 135.09,152.5 135.4,152.19 135.4,152 135.14,151.74 134.95,151.74 134.64,152.04 134.45,152.04 134.19,151.78 134.19,151.59 134.5,151.28 134.5,151.09 134.23,150.83 134.04,150.83 133.73,151.14 133.55,151.14 131.17,148.76 131.17,147.27 v6(129.63,145.73)
  BOTTOM w0.133: v6(129.63,145.73) 129.44,145.54 129.44,145.38 129.16,145.1 U7000.A30 ; U7700.L3 145.8,158.18 145.87,158.18 v6(146.08,157.98)
FBB_CMD4: length 34.3
  TOP w0.133: v6(146.02,160.37) 145.52,160.87 144.22,160.87 143.1,159.76 142.07,159.76 141.94,159.89 v1(141.94,160.34) 141.94,160.8 141.81,160.93 141.43,160.93 141.3,160.8 141.3,159.89 141.17,159.76 140.77,159.76 139.95,158.94 139.76,158.94 139.56,159.14 139.37,159.14 139.1,158.88 139.1,158.69 139.31,158.49 139.31,158.3 139.04,158.03 138.85,158.03 138.65,158.24 138.46,158.24 138.2,157.97 138.2,157.78 138.89,157.09 138.89,156.91 138.61,156.64 138.43,156.64 137.74,157.33 137.55,157.33 137.29,157.06 137.29,156.87 137.49,156.67 137.49,156.48 130.23,149.22 130.23,147.44 129.4,146.61 129.09,146.61 128.55,147.16 128.37,147.16 127.6,146.39 127.6,146.21 v6(128.3,145.5)
  BOTTOM w0.133: U7700.K5 146.44,159.95 v6(146.02,160.37) ; v6(128.3,145.5) 127.9,145.1 U7000.B30
FBB_CMD5: length 31.7
  TOP w0.133: v6(129.06,145.71) 129.06,145.89 130.72,147.55 130.72,148.87 137.53,155.68 139,155.68 139.29,155.97 139.29,156.86 139.86,157.43 140.11,157.43 v1(140.73,158.04) 140.84,158.16 140.84,158.9 141.1,159.16 145.65,159.16 145.98,159.48 146.25,159.48 146.38,159.61 146.38,159.94 146.51,160.06 146.91,160.06 147.04,159.94 147.04,159.35 147.97,158.43 147.97,158.25 147.74,158.02 147.56,158.02 v6(146.82,158.76)
  BOTTOM w0.133: U7700.K4 v6(146.82,158.76) ; v6(129.06,145.71) 128.48,146.29 128.31,146.29 U7000.B32
FBB_CMD6: length 31
  BOTTOM w0.133: U7700.J5 147.55,159.94 147.68,160.07 147.68,160.64 147.55,160.76 145,160.76 144.2,161.56 141.75,161.56 141.38,161.19 141.38,160.7 141.2,160.52 140.71,160.52 140.23,160.04 140.23,159.7 139.91,159.38 139.57,159.38 139.43,159.24 139.43,157.07 v1(138.91,156.56) 138.66,156.56 138.48,156.38 138.48,155.75 138.07,155.34 138.07,154.08 133.2,149.21 132.05,149.21 131.1,148.26 131.1,148.07 131.29,147.88 131.29,147.69 131.02,147.43 130.84,147.43 130.65,147.62 130.46,147.62 130.18,147.33 130.18,146.45 130.02,146.3 129.11,146.3 U7000.A32
FBB_CMD7: length 36.9
  TOP w0.133: v6(129.34,147.18) 129.34,148.97 136.63,156.25 136.63,156.97 v1(139.72,160.07) 141.01,161.36 146.43,161.36 146.57,161.22 146.57,160.7 146.7,160.57 147.08,160.57 147.21,160.7 147.21,161.61 147.34,161.74 149,161.74 149.12,161.61 149.12,161.21 149,161.08 147.99,161.08 147.85,160.95 147.85,160.57 147.99,160.44 148.69,160.44 148.82,160.3 148.82,159.63 148.69,159.5 v6(147.61,159.5)
  BOTTOM w0.133: U7000.C32 127.46,147.06 129.22,147.06 v6(129.34,147.18) ; U7700.J4 v6(147.61,159.5)
FBB_CMD8: length 34.2
  BOTTOM w0.133: U7000.A33 129.07,147.87 130.1,147.87 131.85,149.61 133.04,149.61 137.52,154.09 137.52,155.77 137.62,155.87 137.92,155.87 138.05,156 138.05,156.27 137.92,156.4 137.64,156.4 137.52,156.52 137.52,156.91 137.64,157.04 138.82,157.04 138.96,157.17 138.96,157.55 138.82,157.68 138.21,157.68 138.07,157.81 138.07,158.19 138.21,158.32 v1(138.56,158.32) 138.82,158.32 138.96,158.45 138.96,159.33 141.54,161.91 144.38,161.91 145.24,161.05 148.06,161.05 148.69,161.69 148.87,161.69 149.06,161.5 149.06,161.32 148.04,160.3 U7700.H5
FBB_CMD9: length 35.7
  BOTTOM w0.133: U7000.B33 128.75,148.35 130.02,148.35 131.68,150.01 132.87,150.01 136.98,154.12 v1(136.98,157.35) 136.98,157.93 141.32,162.27 144.53,162.27 145.44,161.36 147.83,161.36 148.41,161.94 150.22,161.94 150.34,161.82 150.34,160.95 150.22,160.83 149.12,160.83 148.46,160.16 148.46,159.56 U7700.H4
FBB_CMD10: length 38.2
  BOTTOM w0.133: U7700.G12 148.45,165.15 148.45,163.56 148.82,163.19 148.82,162.88 147.6,161.66 145.59,161.66 144.64,162.61 141.07,162.61 140.52,162.06 140.34,162.06 140.06,162.34 139.87,162.34 139.61,162.08 139.61,161.89 139.88,161.61 139.88,161.42 138.98,160.51 135.92,157.45 135.92,157.12 136,157.04 136.35,157.04 136.47,156.91 136.47,156.44 136.35,156.32 135.34,156.32 135.2,156.18 135.2,155.81 135.34,155.68 136.3,155.68 136.42,155.55 136.42,155.11 136.3,154.98 135.33,154.98 135.2,154.86 135.2,154.55 135.33,154.42 135.69,154.42 v1(135.92,154.19) 135.92,153.63 132.71,150.41 131.51,150.41 129.71,148.61 128.39,148.61 U7000.B35
FBB_CMD11: length 35.2
  BOTTOM w0.133: U7000.A35 129.63,149.1 v1(131.53,151) 132.72,151 133.06,151.34 133.06,151.53 132.57,152.02 132.57,152.2 132.76,152.38 132.94,152.38 133.43,151.89 133.62,151.89 133.79,152.07 133.79,152.25 133.29,152.76 133.29,152.94 133.47,153.12 133.65,153.12 134.16,152.62 134.34,152.62 134.52,152.79 134.52,152.98 134.09,153.41 134.09,153.59 134.28,153.77 134.45,153.77 134.88,153.35 135.07,153.35 135.36,153.63 135.36,153.82 134.8,154.38 134.8,156.9 138.58,160.67 138.58,160.68 139.01,161.12 139.01,162.45 139.49,162.93 144.96,162.93 145.9,161.99 147.37,161.99 148.04,162.67 U7700.H10
FBB_CMD12: length 40.2
  TOP w0.133: v6(147.65,164.35) 146.31,164.35 145.63,163.67 139.62,163.67 139.49,163.8 139.49,164.48 139.36,164.61 138.97,164.61 138.85,164.48 138.85,163.77 138.72,163.64 138.23,163.64 138.1,163.77 138.1,164.41 137.97,164.53 136.82,164.53 136.7,164.41 136.7,163.47 136.56,163.34 136.19,163.34 136.05,163.47 136.05,164.33 135.93,164.46 135.52,164.46 135.39,164.33 135.39,162.73 135.52,162.6 136.6,162.6 136.73,162.48 136.73,161.97 136.6,161.84 135.52,161.84 135.39,161.71 135.39,159.95 135.76,159.58 135.76,159.1 135.64,158.97 135.03,158.97 134.16,158.1 v1(134.16,157.3) v2(134.16,156.16)
  BOTTOM w0.133: v6(147.65,164.35) U7700.H11 ; v2(134.16,156.16) 134.16,154.48 129.2,149.52 127.52,149.52 U7000.C35
FBB_CMD13: length 35.1
  TOP w0.133: v6(146.81,163.56) 146.16,163.56 145.76,163.16 140.54,163.16 140.15,162.77 139.96,162.77 139.52,163.21 139.34,163.21 139.07,162.94 139.07,162.76 139.51,162.32 139.51,162.13 139.24,161.86 139.05,161.86 138.51,162.4 138.14,162.77 137.96,162.77 137.69,162.5 137.69,162.32 138.6,161.41 138.6,161.22 138.33,160.96 138.15,160.96 137.44,161.66 137.26,161.66 136.99,161.39 136.99,161.21 137.69,160.5 137.69,160.31 137.37,159.99 137.18,159.99 136.47,160.69 v1(136.29,160.69) 136.02,160.42 136.02,160.24 136.72,159.53 136.72,159.34 135.41,158.03 135.41,156.77 134.31,155.67 v2(133.69,155.67)
  BOTTOM w0.133: U7700.K11 146.45,164.74 146.81,164.38 v6(146.81,163.56) ; v2(133.69,155.67) 133.69,154.7 129.15,150.16 128.96,150.16 U7000.A36
FBB_CMD14: length 36
  TOP w0.133: v6(146.81,162.93) 146.1,162.93 145.72,162.55 140.51,162.55 135.81,157.85 135.81,156.61 135.71,156.5 135.71,156.49 135.29,156.08 130.86,151.64 130.68,151.64 v1(130.42,151.89) 130.21,152.1 130.21,152.28 132.31,154.37 132.79,154.37 133.22,154.8 v2(133.22,155.26)
  BOTTOM w0.133: U7700.K10 146.34,163.83 146.34,163.41 v6(146.81,162.93) ; v2(133.22,155.26) 133.22,154.8 128.93,150.51 128.51,150.51 U7000.B36
FBB_CMD15: length 39.6
  TOP w0.133: v2(132.7,154.87) 131.97,154.87 128.73,151.63 128.73,150.61 v1(128.92,150.42) 129.48,149.86 129.66,149.86 130.73,150.94 135.87,156.08 136.22,156.43 136.22,157.67 140.69,162.14 145.92,162.14 v6(146.18,162.4)
  BOTTOM w0.133: v2(132.7,154.87) 129.69,151.86 128.26,151.86 U7000.B38 ; U7700.L12 145.99,165.19 145.99,162.58 v6(146.18,162.4)
FBB_CMD16: length 41.2
  TOP w0.133: v6(149.97,178.6) 149.38,179.19 149.38,181.4 147.91,182.86 142.92,182.86 141.03,180.98 141.03,178.48 139.55,177 139.55,175.63 v1(132.19,168.28) 129.97,166.05 129.97,164.97 129.14,164.14 127.29,164.14 127.08,163.92 v2(127.08,163.39)
  BOTTOM w0.133: U7701.L3 v6(149.97,178.6) ; U7000.D49 126.3,160.3 127.08,161.08 v2(127.08,163.39)
FBB_CMD17: length 41.1
  TOP w0.133: v6(148.39,179.42) 148.92,179.95 148.92,181.14 147.65,182.41 143.35,182.41 141.93,180.99 141.93,176.98 140.53,175.57 140.23,175.57 v1(133.93,169.28) 130.45,165.8 130.45,164.89 129.28,163.71 v2(127.59,163.71)
  BOTTOM w0.133: U7000.C48 127.52,159.92 127.52,161.47 127.59,161.54 v2(127.59,163.71) 128.75,163.71 R7104.1 ; U7701.J3 148.56,179.21 148.56,179.25 v6(148.39,179.42)
FBB_CMD18: length 39.1
  TOP w0.133: v2(131.29,164.53) 131.29,165.78 v1(135.54,170.03) 142.33,176.81 142.33,180.83 143.33,181.83 147.4,181.83 148.43,180.79 v6(148.43,180.18)
  BOTTOM w0.133: v6(148.43,180.18) 148.64,179.98 148.64,179.93 U7701.J2 ; U7000.B46 128.31,158.31 129.26,158.31 130.33,159.38 130.33,161.13 132.46,163.26 R7107.2 131.5,164.33 v2(131.29,164.53)
FBB_CMD19: length 37
  TOP w0.133: v2(133.28,162.03) 132.95,162.36 v1(132.95,166.26) 132.95,166.6 143.2,176.84 143.2,177.39 143.05,177.53 143.05,178.88 143.2,179.03 143.2,180.05 143.2,180.05 143.2,180.92 143.65,181.37 147.14,181.37 147.95,180.56 147.95,179.79 v6(147.57,179.42)
  BOTTOM w0.133: U7000.A46 129.4,157.9 131.83,160.33 131.83,160.58 v2(133.28,162.03) ; v6(147.57,179.42) 147.4,179.24 147.4,179.23 U7701.G3
FBB_CMD20: length 32.3
  TOP w0.133: v6(148.36,177.08) 148.36,176.93 146.72,175.29 143.76,175.29 135.6,167.13 135.6,166.53 136.09,166.04 136.09,165.85 135.83,165.59 135.64,165.59 135.15,166.08 134.96,166.08 134.69,165.81 v1(134.69,163.64) 134.69,163.15 v2(134.52,162.98)
  BOTTOM w0.133: U7701.H5 148.14,177.23 148.21,177.23 v6(148.36,177.08) ; v2(134.52,162.98) 133.78,162.24 133.78,161.72 129.17,157.1 U7000.A45
FBB_CMD21: length 36.9
  BOTTOM w0.133: U7000.C44 127.33,156.3 127.71,156.68 129.31,156.68 134.21,161.58 134.21,162.02 134.95,162.75 134.95,167.06 134.83,167.17 134.29,167.17 134.14,167.32 v1(134.14,167.51) 134.14,169.48 134.26,169.61 134.81,169.61 134.95,169.74 134.95,170.93 140.67,176.65 147.37,176.65 147.57,176.85 147.57,177.8 U7701.H4
FBB_CMD22: length 34.2
  BOTTOM w0.133: U7701.J5 148.77,176.92 148.09,176.25 140.83,176.25 135.35,170.76 135.35,162.21 v1(134.9,161.76) 134.9,161.63 129.57,156.3 U7000.A44
FBB_CMD23: length 36.7
  BOTTOM w0.133: U7000.B44 128.26,155.94 129.77,155.94 135.75,161.91 135.75,170.36 v1(135.97,170.58) 135.97,170.82 141,175.85 148.3,175.85 149.11,176.67 149.11,177.86 U7701.J4
FBB_CMD24: length 39
  TOP w0.133: v6(126.84,155.21) 127.33,154.73 128.97,154.73 129.22,154.98 129.22,155.3 129.54,155.62 130.66,155.62 134.33,159.3 v1(134.33,159.99) 134.33,162.31 134.09,162.55 134.09,166.25 143.58,175.74 146.59,175.74 147.93,177.08 147.93,177.21 148.3,177.59 149.38,177.59 v2(149.99,176.98)
  BOTTOM w0.133: v6(126.84,155.21) 127,155.06 127,154.8 U7000.C42 ; U7701.K5 149.99,176.98 v2(149.99,176.98)
FBB_CMD25: length 38.3
  TOP w0.133: v6(149.99,177.81) 149.82,177.99 148.1,177.99 147.5,177.38 147.5,177.21 146.47,176.19 143.39,176.19 133.44,166.25 133.44,162.51 133.83,162.13 133.83,159.45 130.73,156.35 v1(130.3,156.35) 129.84,156.35 128.89,155.4 128.89,155.16 128.72,155 127.68,155 v6(127.45,155.23)
  BOTTOM w0.133: v6(149.99,177.81) 149.78,178.02 149.75,178.02 U7701.K4 ; v6(127.45,155.23) 127.71,154.97 127.71,154.89 U7000.B42
FBB_CMD26: length 38.2
  BOTTOM w0.133: U7000.A42 128.7,154.9 129.39,155.59 129.99,155.59 136.15,161.75 136.15,170 136.47,170.32 136.47,170.76 140.15,174.44 v1(140.44,174.44) 140.61,174.44 141.62,175.45 148.77,175.45 149.73,174.49 149.73,173.99 150.02,173.7 150.02,172.15 U7701.L12
FBB_CMD27: length 36
  BOTTOM w0.133: U7000.A41 129.03,153.9 130.33,155.2 130.33,155.37 136.55,161.58 136.55,169.79 137.77,171.01 v1(137.77,171.16) 137.77,171.47 140.21,173.91 140.67,173.91 141.88,175.13 148.59,175.13 149.45,174.26 149.45,173.52 U7701.K10
FBB_CMD28: length 36.9
  BOTTOM w0.133: U7000.B41 128.26,153.54 129.07,153.54 136.98,161.45 136.98,168.64 v1(137.72,169.38) 137.72,170.38 142.13,174.8 148.3,174.8 149.15,173.94 149.15,173.02 U7701.K11
FBB_CMD29: length 37.2
  BOTTOM w0.133: U7000.C39 127.34,152.3 127.71,152.67 128.1,152.67 128.61,153.19 129.28,153.19 137.38,161.28 137.38,168.29 138.23,169.14 138.23,170.32 140.22,172.31 v1(140.41,172.31) 140.41,172.46 142.44,174.49 147.93,174.49 148.08,174.34 148.08,173.78 148.31,173.55 148.31,172.73 148.19,172.6 U7701.H11
FBB_CMD30: length 36.7
  BOTTOM w0.133: U7000.B39 128.12,152.3 128.48,152.66 129.32,152.66 137.78,161.12 137.78,168.13 v1(139.8,170.15) 140.04,170.39 140.04,171.47 140.28,171.72 140.51,171.72 140.86,171.36 141.04,171.36 141.27,171.59 141.27,171.77 140.9,172.15 140.9,172.33 141.17,172.61 141.28,172.61 141.43,172.46 141.73,172.46 141.92,172.64 141.92,173.44 142.28,173.8 142.91,173.8 143.25,174.14 146.46,174.14 146.53,174.07 146.53,173.91 146.67,173.78 147.04,173.78 147.19,173.93 147.19,174.06 147.27,174.14 147.65,174.14 147.78,174.01 147.78,173.59 U7701.H10
FBB_CMD31: length 35.7
  BOTTOM w0.133: U7701.G12 147.46,171.8 147.6,171.66 147.6,169.5 146.95,168.85 139.55,168.85 139.4,168.7 139.4,168.08 139.29,167.98 138.34,167.98 138.2,167.85 138.2,164.36 138.34,164.22 139.27,164.22 139.4,164.1 139.4,163.82 139.27,163.7 v1(138.62,163.7) 138.32,163.7 138.2,163.58 138.2,162.58 138.34,162.44 138.48,162.44 138.61,162.31 138.61,162.04 138.48,161.91 138.34,161.91 138.2,161.78 138.2,160.97 129.53,152.3 U7000.A39
FBB_D0: length 30.5
  IN1 w0.095: v6(149.96,157.14) 149.56,156.73 148.89,156.73 148.48,156.32 147.72,156.32 147.14,155.74 146.92,155.74 146.91,155.74 144.9,155.74 144.5,156.14 141.19,156.14 140.79,155.74 139.34,155.74 132.54,148.93 131.74,148.93 129.39,146.58 128.48,146.58 127.79,145.89 126.26,145.89 v6(125.88,145.51)
  BOTTOM w0.133: U7700.E2 150.26,157.35 150.17,157.35 v6(149.96,157.14) ; v6(125.88,145.51) 126.09,145.3 126.1,145.3 U7000.D30
FBB_D1: length 33
  IN1 w0.095: v6(123.5,145.5) 123.5,145.52 124.63,146.65 126.95,146.65 128.6,148.31 129.77,148.31 131.27,149.8 132.19,149.8 139.46,157.07 139.87,157.07 140.34,157.53 146.95,157.53 147.78,158.36 147.78,158.87 148.41,159.5 v6(149.28,159.5)
  BOTTOM w0.133: U7700.F4 v6(149.28,159.5) ; U7000.G30 v6(123.5,145.5)
FBB_D2: length 31.6
  IN1 w0.095: v6(125.1,145.51) 125.7,146.12 127.48,146.12 129.08,147.71 130,147.71 131.5,149.22 132.42,149.22 139.23,156.02 140.39,156.02 140.79,156.42 144.84,156.42 145.23,156.02 146.18,156.02 146.94,156.78 148.54,156.78 148.82,157.07 148.82,157.27 149.22,157.67 149.78,157.67 v6(150.01,157.9)
  BOTTOM w0.133: v6(125.1,145.51) 125.5,145.1 U7000.E30 ; U7700.F2 v6(150.01,157.9)
FBB_D3: length 33.4
  IN1 w0.095: v6(150.03,159.55) 149.63,159.15 149.63,158.48 148.69,157.55 147.37,157.55 147.04,157.22 146.28,157.22 145.77,156.71 140.61,156.71 140.22,156.31 139.11,156.31 132.3,149.5 131.37,149.5 129.83,147.96 128.82,147.96 127.23,146.37 124.61,146.37 124.3,146.06 v6(124.3,145.5)
  BOTTOM w0.133: U7000.F30 v6(124.3,145.5) ; U7700.E4 v6(150.03,159.55)
FBB_D4: length 35.6
  IN1 w0.095: v6(152.48,157.11) 151.87,156.51 151.87,156.09 149.9,154.12 148.09,154.12 147.6,153.63 146.12,153.63 145.59,154.16 140.05,154.16 130.46,144.57 128.17,144.57 128.06,144.46 125.08,144.46 v6(124.41,143.8)
  BOTTOM w0.133: U7000.G29 124.08,144.13 124.08,144.13 v6(124.41,143.8) ; U7700.B2 152.68,157.37 152.68,157.31 v6(152.48,157.11)
FBB_D5: length 35.5
  IN1 w0.095: v6(125.1,143.9) 125.48,144.28 130.68,144.28 140.27,153.88 145.48,153.88 146,153.35 147.72,153.35 148.21,153.84 150.09,153.84 152.16,155.91 152.16,156.39 152.41,156.64 152.56,156.64 153.07,157.14 v6(153.24,157.14)
  BOTTOM w0.133: v6(153.24,157.14) 153.24,157.14 U7700.A2 ; U7000.F29 v6(125.1,143.9)
FBB_D6: length 38.2
  IN1 w0.095: v6(122.71,144.72) 122.82,144.83 127.74,144.83 127.99,145.08 130.15,145.08 139.81,154.73 148.32,154.73 148.87,155.28 150.25,155.28 151.29,156.31 151.29,156.86 152.09,157.67 152.09,159.16 v6(152.46,159.53)
  BOTTOM w0.133: U7700.B4 v6(152.46,159.53) ; U7000.J29 122.47,144.47 122.47,144.49 v6(122.71,144.72)
FBB_D7: length 38.3
  IN1 w0.095: v6(123.46,143.88) 124.23,144.65 127.92,144.65 128.07,144.8 130.28,144.8 139.93,154.45 149.82,154.45 151.57,156.2 151.57,156.75 152.86,158.03 152.86,159.08 v6(153.28,159.5)
  BOTTOM w0.133: v6(123.46,143.88) 123.24,144.11 123.24,144.16 U7000.H29 ; U7700.A4 v6(153.28,159.5)
FBB_D8: length 31.1
  IN4 w0.095: v6(150.06,164.35) 149.68,163.97 149.15,163.97 147.12,161.94 143.46,161.94 143.04,161.52 140.94,161.52 136.73,157.31 136.73,156.21 129.81,149.29 129.03,149.29 127.61,147.87 v6(127.52,147.87)
  BOTTOM w0.133: U7000.C33 127.27,147.67 127.32,147.67 v6(127.52,147.87) ; U7700.E11 150.44,164.73 v6(150.06,164.35)
FBB_D9: length 33.9
  IN4 w0.095: v6(125.88,147.88) 125.88,148.35 126.88,149.34 127.76,149.34 128.45,150.03 129.73,150.03 136.15,156.45 136.15,157.54 140.7,162.09 142.64,162.09 143.15,162.6 145.24,162.6 146.61,163.97 147.82,163.97 148.56,164.71 148.56,165.07 149.04,165.55 149.71,165.55 v6(150.04,165.88)
  BOTTOM w0.133: U7700.F13 149.78,166.2 149.78,166.13 v6(150.04,165.88) ; U7000.E33 v6(125.88,147.88)
FBB_D10: length 37.1
  IN4 w0.095: v6(124.28,147.92) 124.61,147.59 125.63,147.59 125.76,147.46 127.66,147.46 129.08,148.89 129.8,148.89 137.01,156.09 137.01,157.19 141.05,161.23 143.26,161.23 143.66,161.64 147.24,161.64 148.59,162.98 149.4,162.98 150.44,164.02 150.44,165.54 v6(150.84,165.94)
  BOTTOM w0.133: U7700.E13 v6(150.84,165.94) ; U7000.F33 124.7,147.5 v6(124.28,147.92)
FBB_D11: length 32.1
  IN4 w0.095: v6(149.22,165.17) 149.22,164.93 148.17,163.88 148.17,163.5 147.19,162.52 146.61,162.52 146.36,162.78 145.89,162.78 145.36,162.24 143.31,162.24 142.86,161.8 140.82,161.8 136.44,157.42 136.44,156.33 129.76,149.65 129.01,149.65 127.66,148.3 127.05,148.3 v6(126.64,147.89)
  BOTTOM w0.133: v6(126.64,147.89) 126.45,147.7 126.45,147.65 U7000.D33 ; U7700.F11 149.64,164.74 v6(149.22,165.17)
FBB_D12: length 36.8
  IN4 w0.095: v6(127.5,145.5) 128.88,146.88 128.88,147.32 129.15,147.59 130.13,147.59 138.18,155.65 138.18,156.74 139.81,158.37 140.65,158.37 140.79,158.51 140.79,158.99 141.12,159.32 142.85,159.32 143.27,158.9 144,158.9 144.25,159.15 145.34,159.15 145.86,159.67 146.32,159.67 146.85,160.2 147.51,160.2 148.97,161.66 151.61,161.66 153.28,163.33 v6(153.28,164.37)
  BOTTOM w0.133: U7000.C30 v6(127.5,145.5) ; U7700.A11 153.28,164.37 v6(153.28,164.37)
FBB_D13: length 43.4
  IN4 w0.095: v6(121.89,147.9) 123.42,146.37 127.64,146.37 129.14,147.87 130,147.87 137.9,155.77 137.9,156.86 140.64,159.6 143.11,159.6 143.51,159.2 143.82,159.2 144.04,159.42 144.04,159.71 144.28,159.95 146.2,159.95 146.81,160.57 147.47,160.57 148.87,161.97 151.11,161.97 152.42,163.28 152.42,163.54 152.88,164.01 152.88,165.58 v6(153.24,165.93)
  BOTTOM w0.133: v6(121.89,147.9) 121.89,147.89 U7000.K33 ; U7700.A13 v6(153.24,165.93)
FBB_D14: length 35.8
  IN4 w0.095: v6(152.43,164.35) 150.34,162.27 148.74,162.27 147.5,161.03 144.57,161.03 143.46,159.91 140.54,159.91 137.58,156.95 137.58,155.86 129.85,148.13 129.01,148.13 127.56,146.67 126.29,146.67 v6(125.88,147.08)
  BOTTOM w0.133: U7700.B11 152.69,164.58 152.65,164.58 v6(152.43,164.35) ; U7000.E32 v6(125.88,147.08)
FBB_D15: length 35.9
  IN4 w0.095: v6(152.46,165.96) 152.04,165.54 152.04,164.91 151.03,163.9 151.03,163.49 150.12,162.57 148.62,162.57 147.37,161.33 144.42,161.33 143.35,160.26 140.49,160.26 137.3,157.07 137.3,155.98 129.78,148.46 129.01,148.46 127.63,147.08 v6(126.68,147.08)
  BOTTOM w0.133: U7700.B13 v6(152.46,165.96) ; U7000.D32 v6(126.68,147.08)
FBB_D16: length 26.9
  IN4 w0.095: v6(123.5,151.91) 123.5,152.48 123.62,152.61 123.62,152.96 123.9,153.24 123.9,154.5 124.61,155.21 124.61,155.39 125.96,156.74 129.29,156.74 138.45,165.9 138.45,166.01 139.26,166.82 139.61,166.82 140.03,167.25 140.51,167.25 140.95,166.81 v6(141.23,166.81)
  BOTTOM w0.133: v6(141.23,166.81) 141.48,166.57 141.48,166.51 U7700.T13 ; U7000.H39 v6(123.5,151.91)
FBB_D17: length 29
  IN4 w0.089: v6(124.3,151.89) 124.3,152.04 125.5,153.24 125.5,155.49
  IN4 w0.095: 125.5,155.49 125.62,155.62 126.54,155.62 126.77,155.84 130.22,155.84 139.56,165.19 140,165.19 140.62,165.81 141.84,165.81 142.41,166.37 143.28,166.37 143.48,166.17 143.86,166.17 v6(144.42,166.74)
  BOTTOM w0.133: U7700.N13 144.21,166.51 144.21,166.53 v6(144.42,166.74) ; U7000.G39 124.05,152.15 124.05,152.14 v6(124.3,151.89)
FBB_D18: length 26.2
  IN4 w0.095: v6(125.07,151.93) 125.07,152.19 125.27,152.39 125.98,152.39 126.1,152.5 126.1,153.56 126.96,154.42 127.58,154.42 128.04,153.96 128.04,153.19 128.33,152.9 128.5,152.9 129.16,153.56 129.16,153.64 128.75,154.04 128.75,154.25 128.94,154.44 130.04,154.44 130.45,154.85 130.45,154.95 139.97,164.48 140.59,164.48 v6(141.22,165.11)
  BOTTOM w0.133: v6(141.22,165.11) 141.47,164.87 141.51,164.87 U7700.T11 ; U7000.F39 v6(125.07,151.93)
FBB_D19: length 24.6
  IN4 w0.095: v6(126.77,153.44) 126.77,152.39 126.99,152.17 128.56,152.17 140.07,163.69 141.43,163.69 142.47,164.73 143.18,164.73 v6(143.61,164.3)
  BOTTOM w0.133: v6(143.61,164.3) 143.61,164.31 U7700.N11 ; U7000.D41 v6(126.77,153.44)
FBB_D20: length 29.4
  IN4 w0.089: 130.35,155.58 130.2,155.43 130.2,155.04 129.91,154.74 126.74,154.74 126.37,154.37 126.37,154.09 125.8,153.53 125.8,153.22 124.67,152.09 124.67,151.54 v6(125.1,151.12)
  IN4 w0.095: v6(145.23,166.73) 144.17,165.67 143.1,165.67 142.95,165.52 141.03,165.52 140.41,164.91 139.68,164.91 130.35,155.58
  BOTTOM w0.133: v6(145.23,166.73) 145.23,166.73 U7700.M13 ; U7000.F38 124.88,151.32 124.89,151.32 v6(125.1,151.12)
FBB_D21: length 26.5
  IN4 w0.095: v6(140.16,166.79) 139.9,166.54 139.38,166.54 138.73,165.89 138.73,165.78 129.38,156.43 125.92,156.43 124.85,155.36 124.85,155.09 124.18,154.42 124.18,153.19 123.89,152.9 123.89,151.39 v6(124.26,151.02)
  BOTTOM w0.133: U7000.G38 124.08,151.32 124.08,151.2 v6(124.26,151.02) ; U7700.U13 140.39,166.79 v6(140.16,166.79)
FBB_D22: length 24.8
  IN4 w0.095: v6(144.42,165.17) 144.02,164.77 144.02,164.12 143.82,163.92 142.39,163.92 141.88,163.41 140.19,163.41 128.67,151.88 v6(126.72,151.88)
  BOTTOM w0.133: U7700.M11 v6(144.42,165.17) ; v6(126.72,151.88) 126.54,151.7 126.5,151.7 U7000.D38
FBB_D23: length 26.6
  IN4 w0.095: v6(140.28,164.07) 140.05,164.07 130.1,154.12 129.31,154.12 129.18,153.99 129.18,153.92 129.41,153.69 129.41,153.43 128.51,152.53 127.15,152.53 127.03,152.66 127.03,152.87 127.15,153 127.71,153 127.81,153.1 127.81,153.76 127.43,154.14 126.94,154.14 126.32,153.52 126.32,151.6 126.2,151.48 126.02,151.48 125.9,151.6 v6(125.9,151.9)
  BOTTOM w0.133: U7000.E38 v6(125.9,151.9) ; U7700.U11 140.54,164.44 140.54,164.33 v6(140.28,164.07)
FBB_D24: length 24.3
  IN2 w0.089: v6(125.1,150.3) 125.52,150.72 126.14,150.72 126.38,150.96
  IN2 w0.146: 126.38,150.96 126.44,150.96 128.99,153.52 132.45,153.52 139.15,160.22 143.03,160.22 v6(143.66,159.58)
  BOTTOM w0.133: U7700.N4 143.88,159.3 143.88,159.36 v6(143.66,159.58) ; U7000.F36 125.03,149.9 125.1,149.98 v6(125.1,150.3)
FBB_D25: length 24.3
  IN2 w0.089: v6(121.89,149.49) 122.1,149.7 124.71,149.7 124.93,149.92 128.08,149.92
  IN2 w0.146: 128.08,149.92 128.8,150.64 129.51,150.64 130.36,151.49 133.04,151.49 139.81,158.25 140.76,158.25 v6(141.26,158.76)
  BOTTOM w0.133: v6(141.26,158.76) 141.26,158.76 U7700.T4 ; v6(121.89,149.49) 121.5,149.1 U7000.K35
FBB_D26: length 24
  IN2 w0.089: 126.71,150.71 126.48,150.71 126.06,150.3 v6(125.9,150.3)
  IN2 w0.146: v6(144.42,159.56) 144.01,159.14 143.22,159.14 142.67,159.69 139.3,159.69 132.58,152.97 128.97,152.97 126.71,150.71
  BOTTOM w0.133: U7700.M4 v6(144.42,159.56) ; U7000.E36 v6(125.9,150.3)
FBB_D27: length 18.4
  IN2 w0.146: v6(126.7,150.3) 127.08,150.3 127.17,150.22 128,150.22 129.71,151.92 132.82,151.92 139.66,158.77 v6(140.36,158.77)
  BOTTOM w0.133: U7700.U4 140.7,158.99 140.59,158.99 v6(140.36,158.77) ; U7000.D36 126.3,149.9 v6(126.7,150.3)
FBB_D28: length 21.9
  IN2 w0.089: 128.6,149.49 128.57,149.46 125.06,149.46 124.68,149.08 123.88,149.08 v6(123.49,148.69)
  IN2 w0.146: v6(139.93,156.69) 133.62,150.38 130.51,150.38 129.82,149.69 128.8,149.69 128.6,149.49
  BOTTOM w0.133: v6(139.93,156.69) 139.93,157.24 140.23,157.54 U7700.U2 ; U7000.G35 v6(123.49,148.69)
FBB_D29: length 21.6
  IN2 w0.089: v6(124.3,148.7) 124.57,148.7 125.14,149.27 128.79,149.27 128.81,149.25
  IN2 w0.146: 128.81,149.25 130.11,149.25 130.78,149.92 134.02,149.92 v6(141.22,157.12)
  BOTTOM w0.133: U7700.T2 v6(141.22,157.12) ; U7000.F35 v6(124.3,148.7)
FBB_D30: length 23.9
  IN2 w0.146: v6(144.4,157.95) 144.02,157.57 144.02,156.28 142.9,155.16 141.47,155.16 135.3,148.99 131.53,148.99 130.83,148.28 127.05,148.28 v6(126.7,148.63)
  BOTTOM w0.133: v6(144.4,157.95) 144.66,157.7 144.68,157.7 144.84,157.54 U7700.M2 ; U7000.D35 126.47,148.94 126.47,148.87 v6(126.7,148.63)
FBB_D31: length 23.5
  IN2 w0.089: 128.21,148.8 127.93,149.08 125.48,149.08 v6(125.08,148.68)
  IN2 w0.146: v6(143.56,157.14) 142.91,156.49 141.78,156.49 134.77,149.48 131.12,149.48 130.44,148.8 128.21,148.8
  BOTTOM w0.133: U7700.N2 143.83,157.33 143.75,157.33 v6(143.56,157.14) ; U7000.E35 v6(125.08,148.68)
FBB_D32: length 41.2
  IN2 w0.146: v6(146.75,177.78) 146.62,177.78 146.23,177.39 146.23,175.65 145.58,174.99 142.79,174.99 133.6,165.81 131.42,165.81 128.44,162.82 123.01,162.82 122.58,162.39 122.42,162.39 119.96,159.93 119.96,156.35 v6(119.28,155.67)
  BOTTOM w0.133: v6(119.28,155.67) 119.63,156.02 119.63,156.03 U7000.M44 ; v6(146.75,177.78) 146.55,177.98 146.55,178.02 146.37,178.2 U7701.F4
FBB_D33: length 45.7
  IN2 w0.089: v6(118.7,154.3) 119.26,154.3 119.89,154.93 119.89,155.29
  IN2 w0.146: v6(146.69,179.41) 147.24,178.85 147.24,178.53 147.75,178.02 147.75,175.07 146.64,173.95 143.13,173.95 130.99,161.81 124.35,161.81 122.09,159.55 120.88,159.55 120.6,159.27 120.6,155.99 119.89,155.29
  BOTTOM w0.133: U7701.F2 146.51,179.66 146.51,179.59 v6(146.69,179.41) ; U7000.P42 v6(118.7,154.3)
FBB_D34: length 44.4
  IN2 w0.146: v6(119.49,155.1) 119.49,155.31 120.27,156.09 120.27,159.79 122.62,162.14 122.68,162.14 122.79,162.25 130.67,162.25 142.9,174.48 146.35,174.48 147.31,175.44 147.31,177.85 146.93,178.22 146.64,178.22 146.36,178.5 146.36,179.01 v6(145.95,179.42)
  BOTTOM w0.133: U7701.E2 145.95,179.42 v6(145.95,179.42) ; U7000.M43 119.74,155.34 119.73,155.34 v6(119.49,155.1)
FBB_D35: length 42.1
  IN2 w0.089: 118.77,160.52 118.28,160.03 118.28,155.83 118.33,155.78 118.33,155.75 118.55,155.53 118.58,155.53 118.72,155.39 v6(118.72,155.08)
  IN2 w0.146: v6(145.9,177.79) 145.72,177.61 145.72,176.16 145.14,175.58 142.75,175.58 133.42,166.24 131.24,166.24 129.25,164.25 123.82,164.25 120.29,160.72 118.97,160.72 118.77,160.52
  BOTTOM w0.133: U7000.P43 v6(118.72,155.08) ; v6(145.9,177.79) 145.57,178.12 U7701.E4
FBB_D36: length 42.6
  IN2 w0.146: v6(116.32,155.92) 115.88,156.37 115.88,160.79 123.38,168.29 129.11,168.29 129.99,169.17 131.27,169.17 131.62,169.52 131.62,169.83 132.17,170.38 132.48,170.38 140.43,178.33 140.92,178.33 141.07,178.48 141.07,178.91 141.33,179.16 141.79,179.16 v6(142.8,180.17)
  BOTTOM w0.133: v6(116.32,155.92) U7000.R45 ; U7701.B2 v6(142.8,180.17)
FBB_D37: length 37.4
  IN2 w0.146: v6(117.1,158.37) 117.1,160.52 118.97,162.39 119.16,162.39 123.65,166.88 129.03,166.88 130.37,168.23 132.19,168.23 141.38,177.41 141.68,177.41 141.96,177.69 141.96,178.58 v6(142.8,179.42)
  BOTTOM w0.133: U7000.R46 117.32,158.08 117.32,158.15 v6(117.1,158.37) ; U7701.A2 142.54,179.63 142.58,179.63 v6(142.8,179.42)
FBB_D38: length 40.9
  IN2 w0.146: v6(143.56,178.6) 143.16,178.19 143.16,177.51 143.28,177.39 143.28,176.68 143.08,176.48 142.41,176.48 133.05,167.12 130.83,167.12 129.49,165.78 124.11,165.78 119.65,161.32 118.68,161.32 117.81,160.46 117.81,155.13 v6(117.87,155.07)
  BOTTOM w0.133: v6(117.87,155.07) 117.65,155.3 117.65,155.35 U7000.R43 ; v6(143.56,178.6) U7701.B4
FBB_D39: length 38.7
  IN2 w0.089: v6(117.16,155.9) 116.71,156.35 116.71,157.87
  IN2 w0.146: 116.71,157.87 116.23,158.35 116.23,160.08 123.47,167.32 128.85,167.32 130.26,168.73 131.45,168.73 140.6,177.87 v6(141.51,177.87)
  BOTTOM w0.133: U7701.A4 142.04,177.87 v6(141.51,177.87) ; U7000.R44 117.35,156.15 117.35,156.09 v6(117.16,155.9)
FBB_D40: length 36.3
  IN1 w0.089: v6(119.53,158.33) 120.02,157.84 120.02,157.03
  IN1 w0.095: 120.02,157.03 121.44,155.62 123.85,155.62 125.32,157.09 128.43,157.09 130.81,159.47 132.71,159.47 135.49,162.25 135.49,165.08 137.46,167.04 137.46,169.78 139.38,171.71 140.05,171.71 140.69,172.35 141.81,172.35 142.11,172.05 142.66,172.05 v6(142.76,172.15)
  BOTTOM w0.133: U7701.A11 142.57,172.4 142.57,172.34 v6(142.76,172.15) ; v6(119.53,158.33) 119.9,158.7 U7000.M47
FBB_D41: length 39.6
  IN1 w0.095: v6(118.7,155.9) 118.7,155.68 119.1,155.29 119.1,154.93 120.15,153.88 120.6,153.88 120.84,154.12 122.46,154.12 122.85,154.51 124.19,154.51 125.76,156.08 129.04,156.08 131.29,158.32 133.18,158.32 136.64,161.78 136.64,164.6 138.6,166.57 138.6,169.18 138.81,169.39 143.79,169.39 145.25,170.84 v6(145.25,171.4)
  BOTTOM w0.133: v6(145.25,171.4) 145.49,171.16 145.49,171.08 145.57,171 U7701.E13 ; U7000.P44 v6(118.7,155.9)
FBB_D42: length 36.4
  IN1 w0.095: v6(119.49,157.49) 119.49,157.3 121.16,155.63 121.16,155.11 121.52,154.75 121.8,154.75 122.4,155.35 123.93,155.35 125.49,156.9 128.65,156.9 130.93,159.18 132.83,159.18 135.78,162.14 135.78,164.96 137.74,166.92 137.74,169.53 139.62,171.41 141.96,171.41 v2(142.77,170.6)
  BOTTOM w0.133: U7701.B13 142.8,170.63 142.8,170.63 v2(142.77,170.6) ; U7000.M46 v6(119.49,157.49)
FBB_D43: length 38.3
  IN1 w0.089: v6(119.26,156.49) 119.63,156.49 120.68,155.45 120.68,154.93 121.26,154.35
  IN1 w0.095: 121.26,154.35 122.2,154.35 122.61,154.76 124.04,154.76 125.61,156.33 128.89,156.33 131.17,158.61 133.06,158.61 136.35,161.9 136.35,164.72 138.32,166.69 138.32,169.3 139.22,170.2 142.94,170.2 143.18,170.43 143.18,171.73 v6(143.57,172.12)
  BOTTOM w0.133: U7701.B11 143.33,172.44 143.33,172.36 v6(143.57,172.12) ; v6(119.26,156.49) 119.57,156.8 119.6,156.8 U7000.M45
FBB_D44: length 42.1
  IN1 w0.089: 122.77,156.01 121.55,156.01 120.38,157.18 120.38,158.5 119.58,159.29 118.89,159.29 v6(118.7,159.1)
  IN1 w0.095: 122.77,156.01 123.61,156.01 124.9,157.3 124.9,157.81 125.77,158.68 126.94,158.68 127.17,158.46 127.7,158.46 128.27,159.03 128.27,159.71 128.43,159.86 129.95,159.86 130.56,160.47 131.44,160.47 132.6,161.63 133.45,161.63 133.69,161.86 133.69,162.72 134.49,163.52 134.49,165.49 136.46,167.46 136.46,170.21 138.96,172.71 139.63,172.71 140.34,173.42 145.56,173.42 v6(145.97,173.01)
  BOTTOM w0.133: U7701.E11 v6(145.97,173.01) ; U7000.P47 v6(118.7,159.1)
FBB_D45: length 44.8
  IN1 w0.089: v6(119.15,160.3) 119.59,160.3 120.17,159.73 120.17,159.43 120.73,158.86 120.73,158.86 120.73,157.33 121.69,156.37 122.05,156.37 122.33,156.65 122.33,156.91
  IN1 w0.095: 122.33,156.91 122.5,157.08 123.74,157.08 123.9,157.24 123.9,158.07 123.94,158.11 123.94,158.47 124.16,158.69 124.57,158.69 124.92,159.04 124.92,159.65 125.6,160.34 129.89,160.34 130.59,161.04 131.2,161.04 131.66,161.5 133.92,163.76 133.92,165.73 135.88,167.7 135.88,170.44 138.72,173.28 139.39,173.28 140.11,174 146.31,174 147.15,173.15 147.15,172.6 v6(146.76,172.21)
  BOTTOM w0.133: U7000.P49 v6(119.15,160.3) ; U7701.F11 v6(146.76,172.21)
FBB_D46: length 42
  IN1 w0.095: v6(145.97,171.4) 145.97,171.16 143.81,169 139.19,169 138.89,168.7 138.89,166.45 137.02,164.58 137.02,161.75 133.3,158.04 131.4,158.04 129.16,155.8 125.83,155.8 124.18,154.15 123.56,154.15 122.72,153.31 121.23,153.31 120.9,153.64 120.01,153.64 118.95,154.7 118.57,154.7 118.32,154.94 118.32,156.32 v6(118.7,156.7)
  BOTTOM w0.133: U7000.P45 v6(118.7,156.7) ; U7701.F13 v6(145.97,171.4)
FBB_D47: length 36.4
  IN1 w0.089: 119.66,156.87 119.58,156.87 119.09,157.36 119.09,157.88 v6(118.69,158.28)
  IN1 w0.095: v6(141.94,170.63) 139.25,170.63 138.03,169.42 138.03,166.81 136.07,164.84 136.07,162.02 132.94,158.9 131.05,158.9 128.77,156.62 125.54,156.62 123.98,155.06 122.52,155.06 122.03,154.57 121.44,154.57 120.9,155.1 120.9,155.63 119.66,156.87
  BOTTOM w0.133: U7701.A13 142.17,170.8 142.11,170.8 v6(141.94,170.63) ; v6(118.69,158.28) 118.52,158.1 118.51,158.1 U7000.P46
FBB_D48: length 35.3
  IN4 w0.095: v6(151.54,171.37) 150.97,171.37 149.82,170.22 144.65,170.22 143.76,169.33 141.2,169.33 140.64,169.89 138.68,169.89 130.31,161.52 127.95,161.52 126.74,160.31 125.01,160.31 123.93,159.24 123.93,158.7 v6(124.32,158.32)
  BOTTOM w0.133: v6(124.32,158.32) 124.51,158.13 124.51,158.1 U7000.F46 ; U7701.M13 151.54,171.38 v6(151.54,171.37)
FBB_D49: length 32.7
  IN4 w0.095: v6(152.36,170.61) 152.2,170.45 150.86,170.45 149.12,168.72 140.93,168.72 140.46,169.18 138.86,169.18 129.97,160.29 127.35,160.29 126.13,159.07 v6(125.91,159.07)
  BOTTOM w0.133: v6(125.91,159.07) 125.72,158.88 125.68,158.88 U7000.E47 ; U7701.N13 152.36,170.61 v6(152.36,170.61)
FBB_D50: length 34.9
  IN4 w0.095: v6(154.77,170.6) 154.39,170.22 153.72,170.22 152.51,169.01 150.23,169.01 149.3,168.09 140.69,168.09 140.44,168.34 138.96,168.34 130.34,159.71 128.11,159.71 127.91,159.51 127.91,158.83 127.39,158.3 v6(126.7,158.3)
  BOTTOM w0.133: U7701.U13 v6(154.77,170.6) ; U7000.D47 v6(126.7,158.3)
FBB_D51: length 33.5
  IN4 w0.095: v6(153.96,170.6) 153.7,170.6 152.45,169.36 150.17,169.36 149.18,168.37 140.81,168.37 140.44,168.75 138.83,168.75 130.1,160.02 127.61,160.02 v6(126.7,159.11)
  BOTTOM w0.133: v6(153.96,170.6) 154.36,171 U7701.T13 ; U7000.D48 126.46,159.34 126.47,159.34 v6(126.7,159.11)
FBB_D52: length 38.3
  IN4 w0.095: v6(125.93,161.38) 126.48,161.38 131.28,166.18 132.66,166.18 138.41,171.93 139.43,171.93 142.03,174.53 147.85,174.53 148.34,175.02 152.55,175.02 154.56,173.01 v6(154.78,173.01)
  BOTTOM w0.133: v6(125.93,161.38) 125.1,160.54 125.1,159.89 U7000.F48 ; U7701.T11 v6(154.78,173.01)
FBB_D53: length 43.9
  IN4 w0.095: v6(155.58,173.01) 154.99,173.6 154.38,173.6 152.67,175.31 148.22,175.31 147.73,174.81 141.91,174.81 139.35,172.25 138.33,172.25 134.23,168.15 132.85,168.15 126.45,161.76 125.19,161.76 124.76,161.33 124.28,161.33 122.89,159.94 122.89,158.65 123.04,158.5 123.04,157.96 v6(123.51,157.49)
  BOTTOM w0.133: U7701.U11 v6(155.58,173.01) ; U7000.H46 v6(123.51,157.49)
FBB_D54: length 36
  IN4 w0.095: v6(123.44,158.3) 123.44,158.48 123.07,158.85 123.07,159.25 123.32,159.5 123.65,159.5 124.92,160.77 126.54,160.77 127.91,162.14 130.12,162.14 138.77,170.79 139.71,170.79 142.44,173.52 150.25,173.52 v6(150.76,173.01)
  BOTTOM w0.133: U7701.M11 v6(150.76,173.01) ; v6(123.44,158.3) 123.26,158.48 123.26,158.54 U7000.H47
FBB_D55: length 35.3
  IN4 w0.095: v6(151.56,173.01) 151.13,172.59 150.44,172.59 150.06,172.97 148.23,172.97 147.85,172.59 146.92,172.59 146.92,172.59 146.6,172.59 141.94,172.59 139.85,170.5 138.89,170.5 130.22,161.83 127.92,161.83 126.63,160.54 124.95,160.54 123.71,159.31 123.67,159.31 v6(123.45,159.09)
  BOTTOM w0.133: v6(123.45,159.09) 123.3,159.25 123.3,159.3 U7000.H48 ; v6(151.56,173.01) 151.97,172.61 U7701.N11
FBB_D56: length 45.8
  IN1 w0.095: v6(121.11,157.52) 121.13,157.52 121.81,158.2 121.81,158.2 122.03,158.42 122.03,158.42 122.05,158.44 122.05,158.64 122.4,158.99 122.4,159.65 124.51,161.76 126.19,161.76 126.55,162.13 127.99,162.13 128.06,162.2 129.82,162.2 132.13,164.5 132.13,166.47 134.09,168.44 134.09,171.32 137.84,175.07 138.65,175.07 139.38,175.81 151.89,175.81 v6(153.9,177.81)
  BOTTOM w0.133: v6(153.9,177.81) 154.05,177.97 154.13,177.97 U7701.T4 ; v6(121.11,157.52) 121.11,157.52 120.91,157.32 120.91,157.31 U7000.L45
FBB_D57: length 48.6
  IN1 w0.095: v6(121.9,156.74) 121.9,156.95 122.24,157.29 122.24,158.42 123.31,159.5 123.72,159.5 125.04,160.82 126.17,160.82 127.11,161.76 128.15,161.76 128.21,161.83 130.87,161.83 133.13,164.09 133.13,166.06 135.1,168.02 135.1,170.9 138.26,174.07 139.07,174.07 139.8,174.8 153.61,174.8 155.07,176.27 155.07,177.29 v6(155.58,177.79)
  BOTTOM w0.133: U7000.L44 120.95,156.55 121.7,156.55 v6(121.9,156.74) ; U7701.U4 v6(155.58,177.79)
FBB_D58: length 48
  IN1 w0.095: v6(122.64,158.3) 122.77,158.3 123.16,158.69 123.7,158.69 123.9,158.89 123.9,159.32 125.21,160.63 125.94,160.63 126.24,160.63 126.24,160.63 127.15,161.54 130.99,161.54 131.16,161.71 133.42,163.97 133.42,165.94 135.38,167.9 135.38,170.65 138.51,173.78 139.18,173.78 139.92,174.52 147.41,174.52 147.41,174.52 153.95,174.52 155.45,176.01 155.45,177.13 155.95,177.64 155.95,179.02 v6(155.58,179.39)
  BOTTOM w0.133: U7701.U2 v6(155.58,179.39) ; U7000.J46 122.45,158.05 122.45,158.1 v6(122.64,158.3)
FBB_D59: length 39.1
  IN1 w0.095: v6(123.06,161.21) 123.34,161.21 124.28,162.14 126.03,162.14 126.39,162.5 127.84,162.5 129.66,164.32 129.66,164.81 133.48,168.63 133.48,171.52 137.61,175.64 138.41,175.64 139.15,176.38 150.6,176.38 151.13,176.91 151.13,177.42 v6(150.76,177.79)
  BOTTOM w0.133: v6(123.06,161.21) 123.06,160.97 123.1,160.94 U7000.H49 ; U7701.M4 v6(150.76,177.79)
FBB_D60: length 47.9
  IN1 w0.095: v6(121.08,159.08) 121.08,160.84 122.52,162.28 123.2,162.28 124,163.08 125.48,163.08 125.73,163.32 125.73,163.66 126.12,164.05 126.46,164.05 127.91,165.5 128.59,165.5 132.34,169.24 132.34,171.99 137.15,176.8 137.93,176.8 142.43,181.3 153.45,181.3 154.38,180.37 154.38,179.79 v6(154.75,179.42)
  BOTTOM w0.133: U7701.T2 v6(154.75,179.42) ; v6(121.08,159.08) U7000.L47
FBB_D61: length 40.5
  IN1 w0.095: v6(122.68,160.8) 123.25,160.8 124.4,161.95 126.11,161.95 126.47,162.31 127.92,162.31 127.99,162.38 128.13,162.38 129.94,164.2 129.94,164.69 133.81,168.56 133.81,171.44 137.73,175.36 138.53,175.36 139.27,176.09 151.62,176.09 151.97,176.45 151.97,177.03 151.56,177.44 v6(151.56,177.8)
  BOTTOM w0.133: v6(122.68,160.8) 122.55,160.68 122.55,160.55 U7000.J49 ; U7701.N4 v6(151.56,177.8)
