# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP1: length 96.1
  TOP w0.114: U5200.3 250.5,58.49 250.62,58.61 250.62,58.86 250.31,59.17 244.75,59.17 243.63,58.05 243.15,58.05 ; v1(243.15,57.81) 243.15,58.05 ; 243.15,58.05 242.8,58.05 242.31,57.56 242.27,57.56 v2(241.96,57.25)
  IN4 w0.089: v2(172.9,60.56) 173.26,60.56 173.43,60.72 173.43,61.13 177.44,65.14 177.78,65.14 178.26,64.66 180.9,64.66 181.28,64.28 181.28,63.16 181.74,62.7 181.86,62.7 183.32,61.25 183.32,60.03 184.46,58.89 185.62,58.89 186.66,57.85 187.2,57.85 188.73,56.32 190.77,56.32 191.7,55.39 192.71,55.39 193.13,54.97 193.13,53.57 197.11,49.6 198.87,49.6 200.57,47.89 204.62,47.89 204.94,47.57 206.6,47.57 208.26,49.23 211.47,49.23 212.61,50.36 216.69,50.36 218.18,51.86 231.42,51.86 235.61,56.04 240.14,56.04 241.35,57.25 v2(241.96,57.25)
  BOTTOM w0.114: v2(172.9,60.56) 172.52,60.56 172.38,60.42 U2000.AG7
USBP1_CHARGE: length 14.9
  TOP w0.114: 253.99,50.11 253.99,51.01 252.42,52.58 252.42,52.85 250.63,54.63 250.63,54.86 250.5,54.99 U5200.10 ; 253.99,50.11 v1(253.75,50.11) ; 253.99,50.11 253.99,49.25 254.53,48.71 256.4,48.71 v2(256.78,48.33)
  BOTTOM w0.114: RN5501.3 256.27,45.73 255.93,46.08 255.93,48.18 256.35,48.6 256.51,48.6 v2(256.78,48.33)
USBP2: length 113.9
  IN4 w0.089: v2(171.78,59.96) 171.98,60.16 172.26,60.16 172.42,60.32 172.42,61.38 176.84,65.81 182.09,65.81 182.61,65.28 182.61,64.34 183.24,63.72 183.24,62.53 185.78,59.99 186.18,59.99 188.67,57.49 190.6,57.49 191.31,56.78 192.64,56.78 193.78,55.64 193.78,53.88 197.06,50.6 199.12,50.6 201.15,48.57 206.33,48.57 208.33,50.56 211.69,50.56 212.19,51.06 216.39,51.06 217.86,52.53 225.72,52.53 227.07,53.89 232.52,53.89 235.34,56.71 237.45,56.71 238.45,57.7 238.73,57.7 239.05,57.38 240.47,57.38 241.54,58.45 242.99,58.45 245.45,60.91 245.45,64.91 246.3,65.75 246.3,68.76 246.82,69.29 246.82,72.95 v2(246.42,73.35)
  BOTTOM w0.114: v2(171.78,59.96) 171.61,60.13 U2000.AD7 ; v1(250.93,75.25) 250.93,74.97 ; 250.93,74.97 250.52,74.97 248.89,73.35 v2(246.42,73.35) ; 250.93,74.97 251.21,74.97 251.51,74.67 251.51,73.48 251.64,73.35 251.81,73.35 252.04,73.12 RN5504.3
USBP3: length 204.4
  IN1 w0.089: v2(8.32,79.06) 8.59,79.34 8.97,79.34 9.27,79.04 9.27,75.02 7.39,73.14 7.39,68.73 8.28,67.85 9.29,67.85 13.71,63.43 21.54,63.43 27.05,57.91 27.05,56.54 28.88,54.71 28.88,49.38 30.23,48.03 37.33,48.03 37.97,47.39 48.92,47.39 49.54,48 50.82,48 51.39,47.44 54.21,47.44 54.71,47.94 60.28,47.94 61.24,46.98 65.07,46.98 66.86,48.78 74.25,48.78 101.49,48.78 101.64,48.78 103.45,50.59 108.09,50.59 109.24,51.74 116.48,51.74 116.98,52.24 124.57,52.24 124.93,51.88 142.09,51.88 143.51,53.3 143.51,53.53 144.83,54.85 144.83,56.23 145.35,56.74 147.56,56.74 147.92,57.11 151.36,57.11 154.65,60.39 156.26,60.39 156.77,60.9 159.57,60.9 160.47,60 164.27,60 165.96,61.69 170.59,61.69 171.07,61.21 171.07,58.92 171.43,58.56 172.53,58.56 v2(172.84,58.25)
  BOTTOM w0.102: U2000.AG10 172.39,58.61 172.74,58.25 v2(172.84,58.25)
  BOTTOM w0.114: CON6700.36 8.5,79.25 v2(8.32,79.06)
USBP4: length 195.2
  IN1 w0.089: v2(170.49,63.9) 170.33,64.05 170.13,64.05 170.05,63.97 170.05,63.58 169.7,63.22 169,63.22 168.55,63.67 161.8,63.67 160.9,62.78 156.57,62.78 155.77,61.98 154.34,61.98 151.01,58.64 147.62,58.64 147.02,58.04 144.73,58.04 142.7,56 142.7,54.76 142.14,54.2 142.14,53.83 141.52,53.2 127.24,53.2 126.91,53.54 116.43,53.54 115.92,53.03 107.94,53.03 107.27,52.36 103.27,52.36 100.99,50.08 100.84,50.08 66.34,50.08 64.99,48.74 61.62,48.74 60.66,49.7 49.19,49.7 48.6,49.12 40.01,49.12 39.38,49.74 35.03,49.74 28.7,56.07 28.7,57.18 24.51,61.37 24.51,65.15 23.5,66.16 23.5,70.55 22.89,71.16 22.89,74.54 22.25,75.17 22.25,76.5 21.83,76.93 21.83,77.87 20.74,78.96 20.58,79.12 14.69,79.12 12.12,76.55 12.12,76.25 v2(11.06,75.2)
  BOTTOM w0.102: U2000.AE2 171.4,62.52 171.4,62.74 170.91,63.23 170.91,63.82 170.83,63.9 v2(170.49,63.9)
  BOTTOM w0.114: v2(11.06,75.2) 10.61,74.75 CON6700.27
USBP7: length 122.6
  IN4 w0.089: v2(245.14,79.42) 245.34,79.62 245.59,79.62 245.75,79.47 245.75,78.41 245.38,78.04 245.38,71.98 245.87,71.49 245.87,69.93 244.25,68.31 244.25,64.82 242.73,63.3 242.73,59.61 242.4,59.28 240.47,59.28 239.75,58.56 238.13,58.56 237.15,57.59 234.98,57.59 233.19,55.8 227.72,55.8 226.62,54.7 222.21,54.7 221.02,53.52 217.57,53.52 215.94,51.89 208.39,51.89 205.9,49.39 202.01,49.39 199.63,51.77 198,51.77 195.49,54.28 195.49,56.42 193.52,58.39 188.95,58.39 186.23,61.1 186.23,62.2 183.64,64.79 183.64,65.47 182.45,66.67 170.49,66.67 169.9,66.08 169.9,64.35 169.83,64.28 169.76,64.28 169.47,64.57 v2(169.47,64.57)
  BOTTOM w0.114: v2(169.47,64.57) 169.9,64.14 169.9,62.5 170,62.4 U2000.AB2 ; v2(245.14,79.42) 244.91,79.64 242.85,79.64 241.77,78.56 238.49,78.56 238.05,79.01 238.05,79.64 L5301.3
USBP7_C: length 9.1
  BOTTOM w0.114: 235.04,81.75 235.04,81.54 235.5,81.07 236.58,81.07 237.02,81.51 237.02,82.02 237.37,82.37 237.92,82.37 238.05,82.24 238.05,81.93 L5301.4 ; 235.04,81.75 v1(234.8,81.75) ; 235.04,81.75 235.04,82.51 235.51,82.99 235.98,82.99 236.42,83.43 236.42,83.67 236.25,83.84 CON5300.3
USBP8: length 327.1
  TOP w0.114: v2(99.62,182.47) 99.77,182.32 CON4301.19
  IN2 w0.095: v2(205.59,45.66) 205.27,45.98 205.27,47.37 209.24,51.34 209.24,56.94 209.9,57.59 209.9,59.42 210.41,59.93 210.41,60.64 209.94,61.11 209.94,73.54 202.59,80.89 189.9,80.89 189.31,81.48 185.61,81.48 185.54,81.55 181.84,81.55 180.6,82.79 179.48,82.79 178.7,83.57 177.11,83.57 176.57,83.02 175.18,83.02 172.06,86.15 170.87,86.15 170.1,86.92 170.1,88.51 169.77,88.84 161.24,88.84 160.55,88.15 160.55,84.55 159.37,83.36 158.42,83.36 157.04,81.97 157.04,80.5 156.06,79.52 152.79,79.52 151.93,78.66 151.93,78.18 151.62,77.87 151.62,77.44 150.81,76.62 150.29,76.62 148.74,75.08 146.98,75.08 145.02,77.04 142.49,77.04 142.06,76.61 140.3,76.61 136.85,73.15 124.93,73.15 121.83,76.24 115.75,76.24 112.8,79.2 112.8,81.82 111.79,82.82 109.7,82.82 106.58,85.94 106.58,87.34 85.99,107.93 85.99,121.51 84.16,123.34 83.37,123.34 82.68,124.03 82.68,149.66 80.73,151.62 80.73,154.03 79.25,155.51 79.25,157.39 81.33,159.47 81.33,161.59 82.21,162.47 82.21,172.71 83.33,173.82 83.33,177.4 83.6,177.67 85.23,177.67 86.47,178.91 89.12,178.91 91.2,180.99 97.5,180.99 97.92,181.4 97.92,182.64 98.33,183.05 98.88,183.05 99.41,183.05 99.62,182.85 v2(99.62,182.47)
  IN4 w0.089: v2(205.59,45.66) 205.14,46.11 204.09,46.11 203.96,46.24 196.3,46.24 195.33,47.22 193.64,47.22 192.24,48.61 185.77,48.61 184.99,49.39 184.99,53.79 183.39,55.39 181.73,55.39 180.95,56.17 180.95,57.57 180.41,58.11 176.08,58.11 175.79,58.4 175.79,59.83 175.62,60.01 175.41,60.01 v2(175.11,60.31)
  BOTTOM w0.114: v2(175.11,60.31) 174.83,60.03 U2000.AL7
USBP9: length 243.5
  IN2 w0.095: v2(156.82,77.61) 156.97,77.46 156.97,76.87 156.75,76.65 155.85,76.65 153.06,73.86 149.88,73.86 149.06,73.04 140.44,73.04 137.62,70.22 137.62,68.66 135.31,66.35 135.31,64.05 134.47,63.21 133.8,63.21 132.41,61.82 131.63,61.82 130.38,60.57 121.6,60.57 121.1,61.07 113.04,61.07 109.88,64.23 109.88,72.76 108.8,73.84 108.8,77.72 107.22,79.3 107.22,82.03 104.27,84.98 104.27,86.31 83.46,107.12 83.46,119.42 79.93,122.95 79.93,147.02 76.03,150.93 76.03,159.33 77.7,161.01 77.7,164.89 79.02,166.21 79.02,174.19 77.25,175.96 75.29,175.96 74.37,175.05 65.75,175.05 64.97,174.27 64.97,173.4 v2(64.69,173.11)
  BOTTOM w0.114: v2(156.82,77.61) 157.01,77.43 157.01,77.05 157.31,76.74 159.86,76.74 160.75,77.63 166.2,77.63 168.65,75.18 168.65,69.2 167.96,68.51 167.96,64.31 169.06,63.21 169.06,62.35 169.15,62.26 U2000.AA2 ; L4500.4 54.7,173.95 54.4,173.64 54.4,172.19 56.57,170.02 56.97,170.02 ; 56.97,170.02 v1(56.97,170.25) ; 56.97,170.02 58.67,170.02 60.17,171.52 62.05,171.52 62.73,172.19 64.37,172.19 64.9,172.73 64.9,172.9 v2(64.69,173.11)
USBP10: length 183.5
  IN1 w0.089: v2(174.09,60.14) 173.91,59.96 173.6,59.96 173.53,60.03 173.53,61.86 172.67,62.72 165.8,62.72 165.39,62.31 156.81,62.31 155.99,61.49 154.52,61.49 151.21,58.17 147.82,58.17 147.22,57.57 144.95,57.57 143.17,55.79 143.17,54.51 142.65,53.99 142.65,53.6 141.77,52.73 125.27,52.73 124.93,53.07 116.64,53.07 116.13,52.56 108.66,52.56 107.99,51.89 103.59,51.89 101.3,49.6 75.24,49.6 75.24,49.6 73.91,49.6 73.91,49.6 66.52,49.6 65.17,48.26 61.44,48.26 60.5,49.2 49.57,49.2 48.58,48.21 39.94,48.21 39.29,48.86 32.09,48.86 31.37,49.58 31.37,50.76 31.09,51.05 30.92,51.05 v2(30.64,51.33)
  BOTTOM w0.114: 18.92,59.82 19.07,59.82 22.12,56.76 26.18,56.76 29.36,53.58 29.36,51.86 30.1,51.12 30.43,51.12 v2(30.64,51.33) ; 18.92,59.82 15.59,59.82 13.39,62.02 11.26,62.02 10.66,62.62 10.38,62.62 10.25,62.75 CON6700.3 ; 18.92,59.82 v1(18.92,60.06) ; U2000.AJ7 173.99,60.03 v2(174.09,60.14)
V_SA0_DIMM0_CHA: length 23.5
  TOP w0.305: v2(96.62,85.74) 96.62,82.67 97.97,81.32 100.94,81.32 101.73,80.53 101.73,76.22 101.01,75.51 100.01,75.51 99.38,76.14 CON1600.256
  BOTTOM w0.305: v1(94.3,86.86) 94.48,86.67 95.54,86.67 95.76,86.89 96.75,86.89 ; R1604.2 R1613.1 96.75,87.42 96.75,86.89 ; 96.75,86.89 96.75,85.87 v2(96.62,85.74)
V_SA0_DIMM0_CHB: length 6.5
  BOTTOM w0.305: CON1701.256 97.38,56.15 97.18,55.95 95.48,55.95 94.87,55.34 93.62,55.34 93.45,55.16 R1715.1 R1704.2
V_SA0_DIMM1_CHA: length 37.7
  TOP w0.305: v2(91.72,85.21) 94.36,87.85 96.06,87.85 97.76,86.14 97.76,83.01 98.54,82.23 101.17,82.23 102.54,80.86 102.54,74.67 102.78,74.43 102.78,72.51 101.04,70.77 v2(100.75,70.77)
  BOTTOM w0.254: v2(100.75,70.77) 100.27,70.29 97.56,70.29 97.38,70.1 CON1601.256
  BOTTOM w0.305: v2(91.72,85.21) 92.28,85.21 v1(92.58,84.9) 92.96,84.52 92.96,82.51 92.43,81.98 R1607.2 R1617.1
V_SA0_DIMM1_CHB: length 36.6
  TOP w0.305: R1707.2 R1712.1 108.66,55.31 108.81,55.15 108.81,51.77 107.62,50.57 v1(107.04,50.57) 105.25,50.57 103.94,51.88 96.43,51.88 95.62,52.69 v2(95.62,52.82) ; CON1700.256 99.38,63.14 97.65,61.41 97.03,61.41 v2(96.95,61.49)
  IN2 w0.305: v2(95.62,52.82) 94.67,52.82 93.95,53.54 93.95,59.59 95.85,61.49 v2(96.95,61.49)
V_SA1_DIMM0_CHA: length 20.2
  TOP w0.305: CON1600.260 100.38,77.92 100.91,78.46 100.91,80.18 100.59,80.51 96.92,80.51 96.01,81.41 96.01,86.15 v2(96.24,86.37)
  BOTTOM w0.305: v2(96.24,86.37) 96.12,86.26 93.72,86.26 93.26,86.72 93.26,87.54 R1614.1 R1605.2 92.59,88.86 v1(92.57,88.86)
V_SA1_DIMM0_CHB: length 3.9
  BOTTOM w0.305: CON1701.260 98.38,55.93 98.56,55.75 99.27,55.75 99.47,55.54 R1716.1 R1705.2
V_SA1_DIMM1_CHA: length 35.2
  TOP w0.305: v2(91.72,84.55) 92.12,84.55 94.16,86.58 95.43,86.58 95.73,86.88 96.45,86.88 97.33,86 97.33,82.86 98.37,81.83 101,81.83 102.13,80.7 102.13,74.5 102.37,74.26 102.37,72.68 101.13,71.43 v2(100.74,71.43)
  BOTTOM w0.254: v2(100.74,71.43) 100.77,71.43 101.23,70.97 101.23,70.57 100.56,69.9 98.47,69.9 98.38,69.8 CON1601.260 ; v1(91.32,86.15) 91.17,86 91.17,84.75 91.37,84.55 v2(91.72,84.55)
  BOTTOM w0.305: R1618.1 R1608.2 92.43,84.19 92.37,84.26 92.37,84.27 92.28,84.36 92.27,84.36 92.08,84.55 v2(91.72,84.55)
V_SA1_DIMM1_CHB: length 31.8
  TOP w0.305: R1708.2 R1713.1 106.97,55.31 106.6,55.67 v1(106.43,55.67) 103.05,52.29 96.6,52.29 96.37,52.52 v2(96.37,52.8) ; CON1700.260 100.38,64.15 100.64,63.89 100.64,63.15 99.93,62.45 99.27,62.45 97.62,60.8 v2(96.7,60.8)
  IN2 w0.305: v2(96.37,52.8) 95.78,53.38 94.79,53.38 94.36,53.81 94.36,59.43 95.74,60.8 v2(96.7,60.8)
V_SA2_DIMM0_CHA: length 8.7
  TOP w0.102: v2(78.51,79.36) 77.77,79.36 76.88,78.47 CON1600.166
  BOTTOM w0.305: R1606.2 R1615.1 82.02,81.55 81.59,81.12 81.59,80.79 81.1,80.3 80.44,80.3 80.42,80.28 80.4,80.28 80.4,80.28 v1(79.52,80.28) 78.61,79.36 v2(78.51,79.36)
V_SA2_DIMM0_CHB: length 7.5
  BOTTOM w0.102: v1(78.99,52.57) 78.99,53.28 78.08,54.2 R1706.2
  BOTTOM w0.305: CON1701.166 74.88,56.18 75.11,55.95 76.51,55.95 77.29,55.16 R1717.1 R1706.2
V_SA2_DIMM1_CHA: length 22
  IN3 w0.102: v2(80.26,83.07) 78.31,81.12 76.07,81.12 75.03,80.08 75.03,74.8 75.51,74.31 75.51,72.62 v2(75.11,72.21)
  BOTTOM w0.102: v2(75.11,72.21) 75.11,72.18 75.24,72.05 75.24,70.33 74.88,69.97 CON1601.166
  BOTTOM w0.254: v1(82.11,84.53) 81.94,84.53 80.49,83.07 v2(80.26,83.07)
  BOTTOM w0.305: v2(80.26,83.07) R1609.2 R1619.1
V_SA2_DIMM1_CHB: length 41.4
  TOP w0.102: v2(106.38,61.03) 106.6,61.03 v1(106.96,61.38)
  TOP w0.254: CON1700.166 76.88,63.86 77.78,62.96 77.78,61.48 78.47,60.79 78.47,60.59 v2(79.02,60.04)
  IN1 w0.305: v2(79.02,60.04) 79.9,60.04 80.69,60.83 82.25,60.83 84.68,63.26 88.72,63.26 90.09,61.89 92.99,61.89 93.52,62.42 97.65,62.42 98.2,61.87 98.2,60.87 99.12,59.95 104.14,59.95 105.22,61.03 v2(106.38,61.03)
  BOTTOM w0.305: v2(106.38,61.03) 106.58,60.83 107.67,60.83 107.9,60.6 R1719.1 R1709.2
VCLK: length 29.8
  TOP w0.203: v2(220.57,75.68) 220.57,75.15 220.39,74.96 U8100.19
  IN1 w0.254: v2(245.01,67.4) 244.06,68.35 243.45,68.35 235.22,76.58 221.47,76.58 v2(220.57,75.68)
VCORE_VCCSENSE: length 67.6
  TOP w0.152: R8004.1 9.14,177.08 C8025.1 9.37,178.25 v1(9.32,178.3) 9.03,178.59 8.24,178.59 8,178.83 8,179.64 v2(7.67,179.97) 8.74,179.97 9.32,179.39 10.34,179.39 R80112.2 C8000.1
  IN3 w0.152: v2(7.67,179.97) 7.9,180.2 8.28,180.2 10.72,177.77 16.69,177.77 17.45,177 17.45,176.4 19.2,174.64 21.59,174.64 23.25,172.98 24.59,172.98 25.12,172.46 25.12,171.79 23.44,170.1 23.44,167.9 25.24,166.1 27.69,166.1 28.25,165.54 28.25,165.11 v2(27.61,164.48)
  BOTTOM w0.203: U0300.AG37 42.68,151.46 42.68,152.41 40.82,154.27 38.49,154.27 36.47,156.28 36.47,161.9 34.93,163.44 28.65,163.44 28.07,164.02 28.06,164.02 27.79,164.29 27.79,164.3 v2(27.61,164.48)
VCORE_VSSSENSE: length 64.8
  TOP w0.152: v1(6.69,176.35) 6.78,176.44 R8005.1 8.31,176.44 8.51,176.65 C8025.2 R8000.1 C8002.1 7.72,179.29 v2(7.04,179.97)
  IN3 w0.152: v2(28.25,164.48) 28.5,164.73 28.5,165.65 27.79,166.35 25.35,166.35 23.69,168.01 23.69,170 25.37,171.68 25.37,172.63 24.77,173.24 23.36,173.24 21.65,174.95 19.38,174.95 17.7,176.62 17.7,177.23 16.91,178.02 10.89,178.02 8.46,180.46 7.52,180.46 v2(7.04,179.97)
  BOTTOM w0.203: U0300.AG38 43.08,152.59 40.99,154.67 38.66,154.67 36.88,156.45 36.88,162.07 35.1,163.84 28.88,163.84 v2(28.25,164.48)
VGA_BST1:
  vias: v1(149.43,84.19)
VGA_BST1_R:
  vias: v1(145.95,85.56)
VGA_BST2:
  vias: v1(148.2,78.22)
VGA_BST2_R:
  vias: v1(144.5,77.92)
VGA_BST3:
  vias: v1(145.12,93.05)
VGA_BST3_R:
  vias: v1(142.06,94.19)
VGA_DDR_BST1:
  vias: v1(177.32,82.84)
VGA_DDR_BST1_R:
  vias: v1(174.68,83.2)
VGA_DDR_HG1: length 8.6
  BOTTOM w1.016: 174.8,89.76 174.8,88.63 175.79,87.64 175.79,86.95 177.06,85.68 177.06,83.35 v3(177.98,82.44)
  vias: v1(179.12,82.72)
VGA_DDR_HG1_R: length 3.8
  BOTTOM w1.016: 169.34,87.72 170.49,88.87 172.64,88.87
  vias: v1(173.41,88.64) v2(168.58,87.34) v2(168.58,86.71)
VGA_DDR_LG1: length 9.7
  IN4 w1.016: v3(175.57,85.74) 174.6,85.74 173.91,85.06 173.91,81.75 173.22,81.06 169.74,81.06
  vias: v1(176.49,84.94) v3(168.58,80.99)
VGA_DDR_LX1: length 15.1
  BOTTOM w0.762: 167.56,79.98 167.56,78.04 168.55,77.06 171.14,77.06 175.95,81.86 T8900.1 175.95,83.81 v3(175.64,84.12)
  vias: v2(162.98,82.2) v2(163.63,82.26) v2(164.24,82.26) v2(164.85,82.26) v2(165.46,82.26) v2(166.07,82.26) v2(166.68,82.26) v2(167.28,82.26) v2(169.72,82.01) v2(170.36,82.01) v2(170.99,82.01) v2(171.63,82.01) v2(172.26,82.01) v2(172.9,82.01) v3(162.78,84.7) v3(162.78,83.81) v3(162.78,82.92) v3(167.82,84.68) v3(167.82,83.79) v3(167.82,82.9) v3(168.07,82.01) v3(168.71,84.68) v3(168.71,83.79) v3(168.71,82.9) v3(168.96,82.01)
VGA_DDR_PG: length 97.5
  TOP w0.102: SR8908.1 176.7,88.05 v2(176.99,87.75) ; R9208.1 130.05,47.41 130.26,47.2 131,47.2 131.41,46.79 133.79,46.79 134.8,45.79 T9211.1 136,46.2 v2(136,46.44)
  IN2 w0.102: v2(179.77,65.4) 179.49,65.68 177.71,65.68 177.04,65.01 174.5,65.01 174.01,65.5 172.39,65.5 171.95,65.05 169.38,65.05 168.71,64.38 159.24,64.38 158.35,63.49 158.35,62.67 154.91,59.23 152.95,59.23 150.94,57.22 150.94,54.66 149.92,53.64 144.81,53.64 144.33,53.16 144.33,50.08 140.92,46.66 138.8,46.66 138.58,46.44 v2(136,46.44)
  BOTTOM w0.102: v2(179.77,65.4) 179.77,65.81 180,66.03 180,69.02 179.56,69.46 178.64,69.46 178.16,69.94 178.16,70.95 176.74,72.37 174.3,72.37 173.99,72.68 173.39,72.68 172.81,73.26 172.31,73.26 171.83,73.74 171.83,75.01 173.36,76.54 173.36,77.43 175.02,79.09 175.58,79.09 178.94,82.45 178.94,86.31 177.5,87.75 v2(176.99,87.75)
VGA_DDR_PG_R: length 2.9
  TOP w0.102: U8900.13 178.99,87.06 178.54,87.51 178.14,87.51 v1(177.79,87.85) 177.53,88.11 SR8908.2
VGA_DDR_RC1:
  vias: v1(170.76,83.02)
VGA_DDR_REFIN: length 5.8
  TOP w0.203: U8900.7 180.85,84.96 181.86,83.94 R8900.2 182.79,83.94 v1(183.32,83.41) 183.38,83.35 C8909.1 R8901.2
VGA_DDR_TON: length 5.4
  TOP w0.203: R8910.1 R8907.1 183.99,85.71 v1(181.73,85.71) 181.27,85.71 181.22,85.76 U8900.9
VGA_DDR_VCCP: length 4.8
  TOP w0.203: U8900.18 177.3,85.36 177.07,85.58 177.07,85.94 176.9,86.11
  TOP w0.381: R8905.2 175.18,88.19 C8910.1
  TOP w0.508: 176.9,86.11 176.46,86.55 v1(176.46,86.71) 176.46,86.91 C8910.1
VGA_DDR_VREF: length 4.6
  TOP w0.203: U8900.8 180.88,85.36 181.43,84.81 R8900.1 183.26,84.81 v1(183.54,85.08) 183.64,85.18 184.48,85.18 C8908.1
VGA_DDR_VRON: length 7.8
  TOP w0.102: U8900.3 178.99,83.51 179.58,82.92 179.58,82.56 C8904.1 SR8903.2 177.51,81.31 v1(178.23,80.59) 178.23,79.36 178.49,79.11 D8900.1
VGA_HG1: length 32.1
  TOP w0.508: v1(148.54,86.17) v3(147.5,86.17)
  IN2 w0.762: 146.23,85.95 145.34,86.83 137.39,86.83 135.02,84.46 121.5,84.46 120.9,85.06 v3(116.76,85.06)
VGA_HG1_R:
  vias: v1(118,82.48)
VGA_HG2: length 38.3
  IN2 w0.762: v3(123.53,89.82) 123.53,89.06 126.62,85.97 134.95,85.97 136.88,87.9 147.22,87.9 149.65,85.47 149.65,79.06 148.66,78.07 148.16,78.07
  vias: v1(148.86,76.6) v2(147.52,77.29) v2(148.13,77.29)
VGA_HG2_R:
  vias: v1(124.92,88.14)
VGA_HG3:
  vias: v1(143.98,94.84)
VGA_HG3_R: length 20.2
  TOP w0.102: v1(149.12,106.39) 149.96,106.39
  IN4 w0.762: 151.18,105.88 153.47,103.6 153.47,99.28 151.55,97.36 148.93,97.36 148.31,96.74 147.22,96.74 146.66,96.18 146.66,94.84 144.96,93.13
  vias: v2(144.23,93.3) v2(144.23,92.67) v2(150.16,106.69) v2(150.16,106.05)
VGA_LG1: length 45.9
  TOP w0.762: 110.29,87.22 114.22,87.22 115.11,86.33
  IN2 w0.762: 147.64,82.3 144.58,82.3 142.82,80.55 139.98,80.55 138.61,81.92 120.28,81.92 119.18,83.02 115.6,83.02 112.83,85.79 112.83,86.53 112.22,87.15 110.8,87.15
  vias: v1(148.69,82.05) v2(109.37,87.41) v2(109.37,86.77) v2(116.64,86.2) v2(117.27,86.2) v2(147.66,82.91) v2(148.27,82.91)
VGA_LG2: length 19.8
  TOP w0.762: 125.91,80.36 130.48,80.36
  IN2 w0.762: 147.15,80.02 143.51,80.02 143.1,79.61 137.76,79.61 137.14,80.23 132.39,80.23
  vias: v1(147.15,80.25) v2(125.27,80.87) v2(125.27,80.23) v2(131.35,80.66) v2(131.35,80.02) v2(148.21,80.09) v2(148.85,80.09)
VGA_LG3: length 18.2
  TOP w0.508: v1(155.42,110.05) 155.42,109.92 v3(155.98,109.36)
  IN4 w0.762: 154.48,98.57 152.3,96.38 149.43,96.38 148.77,95.72 ; 154.94,107.87 154.94,100.45
  BOTTOM w0.762: 155.75,99.41 156.9,100.55 156.9,101.95
  vias: v2(147.63,95.72) v2(148.26,95.72) v2(154.61,99.28) v2(154.61,98.65)
VGA_LX1: length 47.3
  IN2 w0.762: 146.9,84.17 144.53,84.17 142.93,85.77 138.36,85.77 135.78,83.19 120.63,83.19 119.78,84.04 116,84.04 114.45,85.59 114.45,88.76 v3(114.48,88.79)
  IN4 w0.508: v2(150.58,77.25) 149.77,78.06 149.77,82.62 v2(148.58,83.81)
  BOTTOM w0.381: R8718.1 151.28,76.55 v2(150.58,77.25)
  vias: v2(147.94,83.81) v3(114.48,89.99) v3(115.41,89.95) v3(115.38,89.05) v3(115.42,88.18) v3(115.89,87.37) v3(116.3,89.95) v3(116.27,89.05) v3(116.29,88.14) v3(117.19,89.95) v3(117.16,89.05) v3(117.18,88.14) v3(121.67,89.68) v3(121.67,88.8) v3(121.67,87.91) v3(121.67,87.02) v3(122.56,89.68) v3(122.56,88.8) v3(122.56,87.91) v3(122.56,87.02)
VGA_LX2: length 13.9
  TOP w0.508: v2(153.43,77.56) 152.09,78.9 148.91,78.9 v2(148.62,79.19)
  BOTTOM w0.508: R8719.1 153.05,76.88 153.43,77.26 v2(153.43,77.56)
  BOTTOM w0.762: R8723.1 138.73,79.87 139.52,79.08 144.91,79.08
  vias: v3(124.61,89.83) v3(125.54,89.79) v3(125.53,88.89) v3(126.41,89.79) v3(126.42,88.92) v3(130.99,89.5) v3(130.99,88.61) v3(131.88,89.5) v3(131.88,88.61) v3(131.88,87.72) v3(131.88,86.83) v3(132.77,89.55) v3(132.77,88.66) v3(132.77,87.77) v3(132.77,86.88) v3(133.66,89.55) v3(133.66,88.66) v3(133.66,87.77) v3(133.66,86.88)
VGA_LX3: length 45.5
  TOP w0.508: 142.8,95.98 142.42,95.98 141.21,94.77 141.21,91.96 144.93,88.23 152.71,88.23 153.52,87.41 153.52,86.45 154.5,85.47 154.5,81.05 155.35,80.21 158.22,80.21 158.45,79.98 158.45,78.79 v2(158.93,78.31)
  BOTTOM w0.254: v2(158.93,78.31) 158.23,79.01 R8720.1
  BOTTOM w0.762: 151.31,102.07 149.91,100.68 149.91,100.42 148.9,99.41 145.62,99.41 143.4,97.19
  vias: v2(142.47,96.5) v2(142.9,96.93) v3(147.5,109.31) v3(147.72,114.89) v3(148.39,109.31) v3(148.39,108.42) v3(148.39,107.54) v3(148.61,114.89) v3(149.28,109.31) v3(149.28,108.42) v3(149.28,107.54) v3(149.53,114.9) v3(150.17,109.31) v3(150.17,108.42) v3(150.17,107.54) v3(150.42,114.9) v3(151.31,114.9) v3(152.2,114.9) v3(153.09,114.9)
VGA_PSI#: length 115.8
  TOP w0.102: v6(102.03,118.71) 102.03,119.6 v1(101.78,119.85) 101.52,120.11 99.62,120.11 99.19,119.68 99.19,116.95 99.08,116.84 94.72,116.84 94.14,116.26 94.14,115.4 v2(94.44,115.1)
  IN4 w0.102: v2(94.44,115.1) 93.98,114.65 93.98,114.24 95.89,112.34 98.22,112.34 98.36,112.2 99.46,112.2 99.82,111.84 99.82,111.09 99.7,110.97 99.7,103.52 110.05,93.17 110.05,89.7 115.28,84.48 115.87,84.48 116.81,83.53 118.95,83.53 122.75,79.73 123.5,79.73 124.29,78.94 125.38,78.94 127.07,77.25 127.07,76.75 128.15,75.66 138.06,75.66 139.19,76.8 146.21,76.8 146.69,76.32 150.87,76.32 151.87,77.32 151.87,82.84 151.23,83.48 v2(151.23,85.41)
  BOTTOM w0.102: v2(151.23,85.41) 151.18,85.41 149.24,87.36 149.24,88.29 149.53,88.58 R8706.1 R8707.1 SR8700.1 ; U7000.AT1 100.7,119.97 101.28,119.39 101.35,119.39 v6(102.03,118.71) 102.29,118.46 R7439.2
VGA_PWM: length 19.2
  TOP w0.102: R8725.1 147.68,91.08 v1(147.87,90.89)
  TOP w0.381: v2(148.23,80.83) 148.23,81.23 148.87,81.88 R8716.1
  IN4 w0.762: 147.75,92.68 148.11,92.32 148.11,89.15 148.97,88.29 148.97,85.69 148.24,84.96 147.6,84.96 146.76,84.11 146.76,82.13 147.31,81.58 148.05,81.58
  BOTTOM w0.254: U8700.22 148.68,81.54 148.23,81.09 v2(148.23,80.83)
  vias: v2(147.99,93.66) v2(147.99,93.02)
VGA_PWRON: length 179.2
  TOP w0.102: v1(99.96,119.3) v6(99.96,118.66)
  IN1 w0.102: v2(157.55,115.98) 157.8,115.98 159.08,114.7 159.5,114.28 159.58,114.05 159.69,113.75 159.69,113.39 159.72,113.36 159.89,113.19 159.9,113.15 160.06,112.71 160.16,112.45 160.38,111.82 161.11,109.79 161.11,106.31 159.39,104.59 158.5,103.07 158.35,102.71 158.11,101.89 158.03,101.36 158.03,99.15 158.06,98.79 158.08,98.61 158.09,98.57 158.2,98.13 158.46,97.4 158.59,97.17 158.85,96.75 159.19,96.34 162.55,92.99 162.55,91.02 158.47,86.94 155.89,86.94 154.73,88.09 150.97,88.09 149.83,89.22 v2(149.38,89.22) 149.25,89.22 148.45,88.42 143.62,88.42 142.66,87.47 139.93,87.47 138.06,85.6 123.44,85.6 120.63,82.79 118.32,82.79 117.36,83.75 113.89,83.75 112.84,84.79 112.84,87.7 98.27,102.27 98.27,107.61 99.13,108.47 99.13,110.94 98.98,111.09 98.35,111.09 98.22,111.22 98.22,112.72 97.82,113.12 97.82,116.52 v6(99.96,118.66)
  BOTTOM w0.102: 99.05,118.91 99.24,118.71 99.24,118.43 R7419.2 ; SR9102.1 142.14,87.6 141.5,88.23 141.5,90.19 142.8,91.48 148.31,91.48 149.38,90.42 v2(149.38,89.22)
  BOTTOM w0.103: R7419.2 99.96,118.39 v6(99.96,118.66) ; U7000.AW1 98.48,121.73 98.48,119.47 99.05,118.91
  BOTTOM w0.127: v2(157.55,115.98) 157.55,120.78 157.07,121.25 156.01,121.25 153.3,123.96 153.3,124.71 153.56,124.97 153.73,124.97 154.4,125.65 154.4,127.98 153.57,128.82 152.17,128.82 151.08,129.92 151.08,131 150.77,131.31 150.01,131.31 149.83,131.49 149.83,133.06 149.92,133.15 149.92,135.61 149.83,135.7 149.83,137.86 151.13,139.16 151.13,139.46 151.94,140.27 151.94,141.27 152.09,141.42 R5706.1
VGA_REFADJ: length 3.2
  BOTTOM w0.254: U8700.6 v1(152.94,84.29) 152.94,84.67 C8709.1 R8700.1
VGA_REFIN: length 5.2
  BOTTOM w0.254: R8702.2 R8704.2 C8726.1 156.13,83.86 155.58,83.3 155.02,83.3 T8700.1 154.81,83.1 154.53,83.1 153.98,82.54 U8700.7
VGA_VDD: length 4.6
  TOP w0.508: R8714.1 151.56,81.25 v1(151.14,80.82) 151.01,80.95 C8727.1 149.02,80.95 v2(148.91,80.84)
  BOTTOM w0.254: v2(148.91,80.84) 149.12,81.05 U8700.21
VGA_VID: length 99
  TOP w0.102: v2(152.17,86.94) 151.74,86.5 v1(151.54,86.5)
  IN1 w0.102: v2(152.17,86.94) 151.42,87.68 143.5,87.68 142.88,87.06 140.1,87.06 138.23,85.2 123.67,85.2 120.71,82.24 118.18,82.24 117.17,83.25 113.69,83.25 112.51,84.43 109.08,84.43 107.97,85.53 107.97,92 97.84,102.13 97.84,110.69 97.97,110.81 97.97,112.34 97.49,112.82 97.49,116.75 99.37,118.63 99.37,127.01 v6(100.25,127.9)
  BOTTOM w0.102: v2(152.17,86.94) 152.43,86.94 153.12,87.64 SR8701.1 ; U7000.AT9 100.65,128.3 v6(100.25,127.9)
VGA_VREF: length 7.2
  BOTTOM w0.254: R8701.1 157.63,85.39 v1(157.63,85.11) 157.56,85.03 157.56,83.89 C8725.1 156.59,83.35 156.08,82.85 155.42,82.85 155.11,82.53 154.61,82.53 154.12,82.05 U8700.8
VGA_VRON: length 10.8
  BOTTOM w0.102: U8700.3 151.44,84.62 148.13,87.93 C8707.1 147.56,87.94 147.47,87.85 147.47,87.28 147.23,87.04 T8702.1 146.15,87.85 R8710.2 145.88,88 D8700.1
VIDALERT#: length 60.7
  TOP w0.114: R0717.2 R80148.2 18.36,148.48 18.14,148.48 R0708.1 17.12,148.48 15.89,148.48 15.6,148.19 15.6,147.39 13.56,145.35 v1(13.56,145.03) 13.56,144.49 12.82,143.75 9.08,143.75 7.67,145.16 v2(7.09,145.16)
  IN4 w0.076: v2(10.82,183.58) 10.82,183.19 9.84,182.22 9.84,179.38 8.11,177.65 7.06,177.65 5.33,175.92 5.33,173.83 4.8,173.3 4.8,169.71 4.19,169.1 4.19,165.93 6.7,163.42 6.7,145.5 7.04,145.16 v2(7.09,145.16)
  BOTTOM w0.114: R8013.2 10.96,182.92 10.82,183.07 v2(10.82,183.58)
VIDSCLK: length 71.7
  TOP w0.114: v2(7.09,145.77) 7.75,145.77 9.3,144.21 v1(9.6,144.21) 12.77,144.21 13.04,144.48 13.04,145.35 15.23,147.54 15.23,149.94 15.98,150.69 R0747.2 R80149.2 18.05,150.29 18.23,150.29 18.45,150.06 19.68,150.06 20.12,149.62 20.58,149.62 20.89,149.31 20.89,148.25 22.79,146.34 25.41,146.34 25.75,146.67 25.75,147.73 v6(26.15,148.13)
  IN4 w0.076: v2(7.09,145.77) 7.03,145.83 7.03,163.56 4.52,166.06 4.52,168.96 5.13,169.57 5.13,173.16 5.73,173.76 5.73,175.86 7.19,177.32 8.24,177.32 11.4,180.47 11.4,183.11 v2(11.85,183.56)
  BOTTOM w0.102: U0300.BH32 26.47,147.81 v6(26.15,148.13)
  BOTTOM w0.114: v2(11.85,183.56) 11.95,183.46 R8012.2
VIDSOUT: length 71
  TOP w0.114: v2(7.09,144.53) 7.75,144.53 8.92,143.35 13.73,143.35 v1(13.77,143.31) 14.07,143.61 14.07,145.34 16.21,147.48 17.14,147.48 R80147.2 R0707.2 18.06,147.5 19.76,147.5 19.89,147.63 19.94,147.63 19.95,147.64 20.92,147.64 22.85,145.71 25.36,145.71 v6(26.53,144.54)
  IN4 w0.076: v2(10.21,183.43) 9.51,182.73 9.51,179.52 7.97,177.98 6.92,177.98 4.96,176.02 4.96,173.99 4.47,173.5 4.47,169.85 3.86,169.24 3.86,165.79 6.37,163.28 6.37,145.2 7.04,144.53 v2(7.09,144.53)
  BOTTOM w0.076: U0300.BH29 26.67,144.68 v6(26.53,144.54)
  BOTTOM w0.114: R8014.2 10.11,183.33 v2(10.21,183.43)
VLDOIN: length 2.3
  TOP w0.203: 132.21,61.59 U8300.19
  TOP w0.381: SR8300.2 v1(129.21,60.47)
VR_ENABLE: length 8.1
  TOP w0.102: R80151.1 10.78,181.55 10.9,181.43 11.95,181.43 12.19,181.67 12.87,181.67 13.35,181.19 v2(13.35,180.67) 13.35,180.24 13.64,179.95 13.64,179.26 13.78,179.12 v1(14.12,179.12)
  BOTTOM w0.102: U8000.48 12.66,180.36 12.86,180.55 13.23,180.55 v2(13.35,180.67) 13.61,180.94 R8017.1
VR_HOT#: length 2.9
  BOTTOM w0.102: U8000.46 11.87,180.48 11.78,180.57 11.78,180.92 12.08,181.23 v1(12.67,181.23) 12.67,181.63 12.78,181.74 R8003.1
VREF_CA_RC: length 2.1
  TOP w0.305: C0501.2 13.36,123.71 v1(13.26,123.82) 13.15,123.71 R0510.1
VREF_DQ: length 13.1
  TOP w0.305: v6(22.56,132.72) 22.03,132.72 21.67,132.37 21.67,130.86 20.27,129.46 19.63,129.46 17.07,126.89 T0500.1 16.25,126.15 C0500.1 15.53,126.35 14.65,127.23 R0502.2
  BOTTOM w0.254: v6(22.56,132.72) 22.56,132.79 U0300.BP13
VRM_PWRGD: length 354.7
  TOP w0.102: R9203.2 SR9206.2 143.08,49.8 143.38,49.5 143.38,48.91 143.68,48.61 145.41,48.61 145.69,48.9 145.69,49.23 145.36,49.57 v2(144.88,49.57) ; R9203.2 142.95,50.45 U9201.1 ; R9203.2 141.58,51.82 D9202.1 141.58,52.89 T9207.1
  IN3 w0.102: v2(110.21,46.77) 110.47,47.03 130.97,47.03 131.3,46.7 133.35,46.7 133.52,46.87 140.79,46.87 143.5,49.57 v2(144.88,49.57) 152.53,49.57 153.34,50.38 153.34,53.83 156.48,56.96 158.9,56.96 161.93,59.99 164.03,59.99 164.52,60.47 164.52,62.15 170.2,67.84 172.36,67.84 174.96,70.44 174.96,71.72 175.85,72.61 182.98,72.61 183.27,72.32 187.9,72.32 189.46,70.76 190.12,70.76 191.24,69.64 193.73,69.64 v2(194.08,69.99)
  IN4 w0.102: v2(12.18,180.75) 12.18,180.7 8,176.52 8,174.07 6.6,172.67 6.6,170.35 4.92,168.66 4.92,166.23 7.42,163.72 7.42,146.6 7.67,146.35 7.67,144.25 3.22,139.8 3.22,125.51 4.34,124.39 4.34,116.38 6.2,114.52 v2(6.4,114.52) 6.45,114.57 7.57,113.46 7.57,113.39 7.62,113.34 7.62,91.02 10.24,88.4 11.97,88.4 12.12,88.25 12.12,87.41 12.79,86.73 13.64,86.73 18.64,81.73 21.16,81.73 24.56,78.33 24.56,74.66 24.41,74.51 24.41,70.43 23.72,69.74 23.72,69.38 25.15,67.95 25.15,64.32 25.5,63.97 25.5,62.79 34.07,54.23 37.24,54.23 41.93,49.54 100.87,49.54 102.6,47.81 108.91,47.81 109.5,47.22 109.75,47.22 v2(110.21,46.77)
  BOTTOM w0.102: U8000.47 12.27,180.67 v2(12.18,180.75) ; R4417.2 9.83,119.32 9.4,118.89 9.4,116.98 6.94,114.52 6.41,114.52 v2(6.4,114.52) ; v2(194.08,69.99) 193.23,69.14 193.23,66.76 193.3,66.68 194.83,66.68 194.91,66.6 U2402.1 195.54,66.05 195.58,66.01 R2493.1
VSUS_ON: length 272.6
  TOP w0.102: U3001.19 117.92,46.01 v2(117.53,46.4) 117.53,47.58 R3064.2 117.95,48.01 117.95,49.79 R3061.2 ; Q8106.6 217.87,86.34 218.36,86.83 218.36,87.26 218.49,87.39 JP9303.2 219.43,87.67 219.25,87.85 218.87,87.85 218.62,88.1 218.62,88.71 R8110.1 220.46,89.3 221.34,88.42 221.34,87.57 221.79,87.11 T9303.1 223.04,83.56 223.04,81.98 224.92,80.1 224.92,77.94 224.66,77.69 R8108.1 223.01,77.26 R8111.2 222.35,76.85 222.29,76.92 220.58,76.92 219.91,76.24 v2(219.91,76.24)
  IN1 w0.102: v2(220.14,60.04) 220.14,63.18 219.24,64.08 216.37,64.08 215.46,64.99 213.69,64.99 213.33,64.64 207.29,64.64 202.8,69.13 196.17,69.13 195.84,69.46 195.84,69.68 194.89,70.63 v2(194.18,70.63)
  IN2 w0.102: v2(194.18,70.63) 194.49,70.32 194.49,69.83 194.25,69.59 190.13,69.59 190,69.72 181.11,69.72 178.15,66.75 170.5,66.75 168.54,64.79 159.07,64.79 157.94,63.66 157.94,62.84 154.83,59.72 152.82,59.72 150.48,57.38 150.48,55.59 149.72,54.83 146.47,54.83 145.68,54.04 144.65,54.04 143.93,53.33 143.93,50.96 141.61,48.65 141.61,47.96 140.72,47.07 133.68,47.07 133.33,46.73 124.28,46.73 123.04,45.5 118.72,45.5 117.82,46.4 v2(117.53,46.4) ; v2(219.91,76.24) 219.91,75.1 218.01,73.2 218.01,72.66 220.92,69.75 220.92,60.82 v2(220.14,60.04)
  IN4 w0.102: v2(210.24,81.57) 208.7,81.57 208.04,80.91 192.67,80.91 187.36,75.6 183.34,75.6 182.52,76.41 174.12,76.41 173.3,75.6 166.96,75.6 166.95,75.58 166.87,75.58 164.62,73.33 161.29,73.33 160.96,73 155.38,73 151.92,69.54 150.51,69.54 149.84,68.87 147.04,68.87 143.5,65.32 141.36,65.32 140.18,64.14 v2(139.45,64.14)
  BOTTOM w0.102: v2(219.91,76.24) 217.32,76.24 214.76,78.8 210.99,78.8 210.24,79.55 v2(210.24,81.57) ; v2(139.45,64.14) 138.7,63.39 D8200.2 137.44,64.23 136.65,65.01 R8201.1
VSUS_ON_EN: length 21.4
  TOP w0.102: R8110.2 216.57,88.7 Q8106.3 216.57,87.71 216.33,87.47 215.83,87.47 215.24,86.89 v2(214.4,86.89) ; v2(212.57,79.29) 212.47,79.29 211.84,78.66 v1(211.84,78.3) 211.89,78.25 R8109.1 C8118.1 SR8103.1
  BOTTOM w0.102: v2(214.4,86.89) 214.12,87.17 211.81,87.17 210.64,86 210.64,83.72 210.88,83.48 212.47,83.48 212.83,83.13 212.83,79.55 v2(212.57,79.29)
WAKE#: length 7.3
  TOP w0.102: U3300.3 230.79,92.36 231.66,91.49 234.1,91.49 v1(234.52,91.08) 235.28,91.08 235.92,90.44 235.92,90.08 R3303.1
WARNING: length 67.8
  TOP w0.102: v2(118.33,77.08) 117.95,76.7 117.95,76.13 116.71,74.88 116.71,74.51 116.45,74.26 116.45,72.39 R8738.1 118.7,70.88 118.75,70.92 U8702.8 ; v2(100.32,115.97) 100.32,115.05 99.69,114.42 98.88,114.42 98.53,114.07 96.82,114.07 96.57,113.82 96.57,113.33 96.33,113.09 96.33,111.71 95.81,111.19 95.1,111.19 95.02,111.12 94.83,110.93 v1(94.71,110.8) v2(94.03,110.12)
  IN4 w0.102: v2(118.33,77.08) 116.07,77.08 114.16,79 114.16,81.75 112.25,83.66 109.65,83.66 108.22,85.09 108.22,92.08 95.05,105.26 95.05,108.81 94.03,109.82 v2(94.03,110.12)
  BOTTOM w0.102: R7438.2 99.64,115.74 99.87,115.97 v2(100.32,115.97) 100.47,115.97 100.74,116.23 100.74,116.96 R7447.2
WLAN_DISABLE#: length 152.8
  TOP w0.102: v2(167.78,32.03) 167.78,31.45 v1(167.64,31.31) ; R5308.2 249.66,94.31 v2(249.66,94.17)
  IN2 w0.102: v2(167.78,32.03) 168.28,32.53 168.28,32.8 169.15,33.67 178.15,33.67 178.2,33.62 190.3,33.62 191.87,32.05 193.84,32.05 196.77,34.98 199.63,34.98 200.33,35.68 201.92,35.68 202.26,36.02 204.54,36.02 205.88,37.35 205.88,37.88 210.59,42.59 210.59,46.15 211.01,46.57 211.01,47.67 212.3,48.95 212.3,50.09 214,51.79 214,56.68 214.96,57.64 214.96,60.2 217.01,62.25 217.01,64.75 213.23,68.53 213.23,79.49 211.99,80.74 211.99,83.1 216.41,87.52 221.33,87.52 222.33,88.51 224.46,88.51 225.68,89.73 225.68,91.81 226.65,92.79 229.82,92.79 230.11,93.07 233.87,93.07 234.48,92.47 248.33,92.47 249.66,93.8 v2(249.66,94.17)
  BOTTOM w0.089: 168.77,37.73 169.83,38.79 169.83,40.52 169.85,40.54 169.85,40.55 170.18,40.88 170.18,41.49 U2000.AB44
  BOTTOM w0.102: 168.77,37.73 168.28,37.24 168.28,36.71 168.08,36.52 168.08,35.02 168.22,34.88 168.22,32.48 v2(167.78,32.03) ; v2(249.66,94.17) 249.5,94 CON5300.56
XCLK_BIASREF: length 13.7
  BOTTOM w0.114: v1(156.45,72.59) 156.45,68.05 R2512.1 157.35,67.58 157.45,67.48 157.45,65.91 158.75,64.61 161.23,64.61 161.44,64.41 161.44,63.18 161.65,62.96 U2000.E1
XDP1_JTAG_TCK: length 8.6
  BOTTOM w0.102: R4402.1 11.53,123.05 11.53,126.15 v1(11.23,126.46) 11.23,127.91 10.94,128.2 10.6,128.2 10.26,127.85 XDP4400.55
XDP1_PIN60: length 10
  BOTTOM w0.114: R4425.1 3.23,120.87 R4426.1 3.23,121.38 v1(2.59,122.01) 1.63,122.98 1.63,126.28 2.2,126.85 XDP4400.60
XDP_PCUDEBUG3: length 4.5
  BOTTOM w0.102: XDP4400.1 10.3,141.35 v1(11,142.05) 11.19,142.24 11.19,142.98 R4422.1 R4424.2
XTAL24_IN_NO_IO: length 7.2
  BOTTOM w0.114: R2522.2 R2524.2 153.01,62.98 C2503.1 152.96,63.77 v1(152.96,64.74) 152.45,65.24 152.45,67.78 152.15,68.09 Y2501.3
XTAL24_IN_R: length 7
  BOTTOM w0.114: R2522.1 v1(154.94,61.94) 155.31,62.31 158.37,62.31 159.18,61.5 159.18,61.03 U2000.A6
XTAL24_OUT_NO_IO: length 11.7
  BOTTOM w0.114: U2000.A5 159.46,61.26 159.46,61.73 158.08,63.11 v1(156.25,63.11) 155.97,62.83 R2524.1 153.8,63.06 C2502.1 153.8,64.81 153.92,64.94 154.24,64.94 154.37,65.06 154.37,65.31 154.24,65.44 153.92,65.44 153.8,65.57 153.8,66.39 Y2501.1
Y5_R: length 3.6
  BOTTOM w0.114: v1(189.53,64.8) 188.67,63.94 Y2500.1 187.81,63.33 187.59,63.11 R2525.2
ZVM_TP: length 1.3
  TOP w0.102: T1000.1 36.7,133.69 v6(36.24,133.22)
  BOTTOM w0.102: U0300.AT13 35.91,132.9 v6(36.24,133.22)
N17740100: length 6.3
  TOP w0.102: v1(224.38,78.22) 223.9,78.22 223.75,78.07 222.81,78.07 R8102.1 221.9,77.16 219.99,77.16 219.42,76.59 U8100.1
N17742210: length 4
  TOP w0.102: U8100.5 217.82,76.09 217.71,76.19 216.59,76.19 v1(216.13,76.65) 216.13,77.01 215.62,77.51 215.37,77.51 R8103.1
N21115423: length 4.7
  TOP w0.102: U8800.6 218.86,28.6 v1(218.8,28.54) 218.49,28.85 C8814.2 R8807.2 R8805.1
N21533547: length 4.2
  TOP w0.203: C8310.1 137.85,63.57 v1(137.72,63.44) 137.24,62.96 137.24,62.73 136.9,62.39 U8300.9
  TOP w0.254: R8300.2 C8310.1
N23400012: length 19.8
  TOP w0.102: R9207.2 130.89,49.4 131.16,49.67 U9200.2 133.01,49.67 133.12,49.78 133.12,50.2 133,50.32 U9200.1 131.05,50.32 v1(130.86,50.51) 130.58,50.8 D9200.1 131.37,52.04 132.43,53.09 R9206.2 ; R9207.2 R9208.2 R9210.2 R9209.2 128.27,48.66 127.31,48.66 127.23,48.73 R9211.2 127.23,49.49 R9212.2 R9200.2 ; R9207.2 131.17,48.71 131.37,48.51 133.35,48.51 SR9204.2
N25316574: length 8.7
  TOP w0.102: SR9205.1 141.87,48.95 ; 141.87,48.95 142.25,49.33 143.01,49.33 143.18,49.16 143.18,48.33 143.64,47.87 v1(143.94,47.87) 145.34,47.87 146.4,48.93 U9201.4 ; 141.87,48.95 SR9206.1 141.4,49.8 141.28,49.67 Q9200.5
N59712038: length 3.8
  TOP w0.102: SR8800.2 217.26,27.82 v1(217.5,27.58) 219.23,27.58 219.76,28.11 U8800.7
N59900925: length 9
  TOP w0.102: R9205.2 136.02,51.27 136.17,51.43 136.93,51.43 137.18,51.67 D9201.1 138.71,52.21 139.61,51.31 139.61,49.54 138.68,48.61 v1(138.68,47.82)
N60195343: length 3.6
  TOP w0.102: v1(173.96,80.19) SR8900.1 175.73,80.99 SR8902.2 SR8903.1
N60195449: length 13.7
  TOP w0.203: C8907.1 178.73,89.46 v2(178.77,89.49) 178.77,89.98 178.31,90.44 177.33,90.44 SR8910.2 ; U8900.10 181.56,86.16 181.98,86.58 182.88,86.58 183.14,86.84 SR8906.2 183.67,86.54 v2(183.3,86.17)
  BOTTOM w0.254: v2(183.3,86.17) 181.38,86.17 178.94,88.61 T8907.1 178.94,89.32 v2(178.77,89.49)
N60195463: length 8.2
  TOP w0.254: R8907.2 v2(186.07,86.25) ; v2(182.11,88.09) 181.95,87.93 181.69,87.93 R8912.1 C8915.1
  IN1 w0.254: v2(186.07,86.25) 184.28,86.25 183.33,87.2 182.35,87.2 182.11,87.44 v2(182.11,88.09)
  BOTTOM w0.102: v1(182,87.34) 182,87.99 v2(182.11,88.09)
N60195527: length 4.2
  TOP w0.203: C8912.1 U8900.11 181.3,86.71 181.9,87.32 v1(182.46,87.32)
N60250597: length 4.3
  BOTTOM w0.102: R9105.2 220.22,87.34 v1(220.85,87.98)
  BOTTOM w0.152: U9102.3 218.72,85.63 218.83,85.74 219.84,85.74 C9118.1 R9105.2
N60250604: length 4.6
  TOP w0.102: v2(219.56,84.63) 219.71,84.78 219.71,85.92 v1(219.61,86.02)
  BOTTOM w0.152: R9106.2 C9120.1 219.79,84.85 v2(219.56,84.63) 219.43,84.75 218.85,84.75 218.77,84.83 U9102.5
N60250715: length 4.3
  BOTTOM w0.102: v1(212.42,86.73) 213.87,86.73 C9124.1
  BOTTOM w0.152: C9124.1 214.98,85.99 215.34,85.63 U9102.12
N60250719: length 2.8
  BOTTOM w0.102: v1(214.91,84.02) 214.6,84.32 C9123.1
  BOTTOM w0.152: C9123.1 215.34,84.98 215.49,84.83 U9102.10
N60253878: length 5.7
  BOTTOM w0.102: R9100.2 139.98,65.6 C9100.1 141.15,65.24 141.74,64.65 v1(142,64.65) 142.56,64.65 143.29,63.91 U9100.3
N60253885: length 7.7
  BOTTOM w0.102: C9103.1 144.6,65.42 144.6,64.62 144.09,64.11 U9100.5 ; C9103.1 145.02,65.84 145.11,65.84 145.43,66.16 v1(145.8,66.16) ; C9103.1 144.36,65.45 144.23,65.57 144.23,65.75 144.11,65.88 143.43,65.88 143.05,66.26 141.71,66.26 R9112.2
N60253996: length 4
  BOTTOM w0.102: v1(141.04,59.23) 141.48,59.23 141.63,59.08 142.63,59.08 C9109.1 143.29,59.74 U9100.12
N60254000: length 7.2
  BOTTOM w0.102: U9100.10 144.09,59.81 144.07,59.78 C9108.1 143.79,59.02 143.57,58.8 140.73,58.8 140.31,59.23 v1(139.19,59.23)
N60314877: length 5.3
  TOP w0.102: v2(195.21,69.74) 195.36,69.59 U9101.5 ; U9101.3 196.16,69.5 v2(196.27,69.61)
  BOTTOM w0.102: v2(195.21,69.74) 195.21,69.75 195.03,69.92 R9104.2 C9111.1 195.9,69.98 v2(196.27,69.61) 196.56,69.32 v1(196.56,69.05)
N60314934: length 3.3
  TOP w0.102: U9101.12 196.16,65.04 195.89,64.76 C9117.1 196.72,64.33 v1(196.82,64.43)
N60315047: length 2.4
  TOP w0.102: U9101.10 195.36,65.68 v1(194.92,65.24) 194.92,64.76 195,64.69 C9116.1
N60322557: length 4.4
  TOP w0.203: R8401.2 C8400.2 168.71,25.57 v1(169.14,26) 169.8,26 R8403.1 170.11,26.31 170.89,26.31 171.03,26.17 U8400.2
N60425076: length 2.4
  TOP w0.203: R9502.2 117.31,61.84 118.55,61.84 118.75,61.64
  vias: v3(119.08,61.86)
N60425117: length 7.9
  TOP w0.203: JP9501.1 v1(114.78,65.62) 116.45,65.62 117.52,66.69 C9513.1 R9505.1
N60425130: length 4
  TOP w0.102: R9502.1 v1(115.69,63.36)
  TOP w0.203: C9513.2 117.72,65.56 117.72,65.28 R9504.2 116.96,64.52 116.96,63.68 R9502.1
N60425240:
  vias: v1(121.85,58.26)
N60425541:
  vias: v1(122.22,61.18)
N60425619: length 3.6
  TOP w0.254: C9504.1 118.51,64.32 v1(119.25,64.32) 119.25,63.64 v2(119.13,63.51)
  BOTTOM w0.203: U9500.11 120.17,62.92 119.96,63.14 119.63,63.14 119.25,63.51 v2(119.13,63.51)
N60690738:
  vias: v1(121.38,79.51)
N60690747:
  vias: v1(139.5,77.82)
N60690916: length 2.1
  BOTTOM w0.254: U8700.12 154.67,80.05 v1(154.71,80) 154.82,79.9 C8724.1
N60691002: length 6.3
  TOP w0.102: v2(156.42,87.45) 156.13,87.17 v1(156.13,86.83)
  IN4 w0.254: v2(154.41,86.88) 155.85,86.88 v2(156.42,87.45)
  BOTTOM w0.254: C8700.2 154.41,87.47 v2(154.41,86.88) 154.41,86.12 R8700.2 154.36,86.07 R8702.1 ; R8701.2 156.43,87.45 v2(156.42,87.45)
N60691151: length 5.1
  BOTTOM w0.102: SR8700.2 151.42,86.63 v1(151.07,86.28) 151.69,85.66 151.69,84.42 151.94,84.17 U8700.4
N60691188: length 6.3
  BOTTOM w0.102: U8700.5 152.44,84.18 151.89,84.73 151.89,86.43 151.74,86.58 151.74,87.24 152.29,87.79 SR8701.2 152.29,88.63 v1(152.53,88.87)
N60691282: length 5.4
  BOTTOM w0.102: R8712.1 156.9,81.96 156.33,81.39 v1(155.89,81.39) 155.89,81.69 155.99,81.8 155.99,82.08 155.7,82.36 155.34,82.36 155.22,82.25 154.72,82.25 154.02,81.54 U8700.9
N60691292: length 4.9
  BOTTOM w0.102: v1(157.55,80.92) 158.2,81.57 158.2,82.07 R8712.2 157.76,83.13 158.34,83.71 C8723.1 R8741.1
N60691324: length 8.1
  BOTTOM w0.102: U8700.16 151.44,78.78 150.11,77.45 150.11,76.61 149.48,75.97 v1(146.91,75.97) 146.52,76.36 SR8702.2
N60691573: length 1.8
  BOTTOM w0.254: R8704.1 155.25,85.41 155.27,85.44 R8705.2 155.27,86.8 v1(155.29,86.82)
N60725232: length 4.4
  TOP w0.102: R9102.1 C9104.1 153.98,47.01 v1(153.98,47.82) 153.77,47.82 153.24,47.29 152.69,47.29 152.59,47.39 Q9100.1
N60725234: length 2.2
  TOP w0.102: Q9101.2 148.51,46.38 148.55,46.42 SR9100.2 148.55,47.81 v1(148.46,47.91)
N60725315: length 14
  TOP w0.102: R9102.2 155.26,45.85 R9103.1 155.08,44.94 155.01,44.94 T9103.1 153.98,44.54 153.37,45.15 153.37,45.97 151.92,47.41 150.24,47.41 149.66,46.83 149.66,44.67 149.45,44.47 147.98,44.47 147.86,44.35 Q9101.4
N65022721: length 5.5
  TOP w0.102: U8800.9 219.57,27.1 219.38,26.92 218.82,26.92 ; v1(218.82,26.66) 218.82,26.92 ; 218.82,26.92 215.13,26.92 SR8802.2
N65022884: length 6.7
  TOP w0.102: U8800.10 219.69,26.6 219.41,26.32 219.41,25.54 218.53,24.66 v1(217.94,24.66) 217.71,24.43 C8824.1 R8813.2 R8811.1
N65023456:
  vias: v1(10.09,107.7)
N65023505: length 5.8
  TOP w0.102: SR8801.2 215.51,27.12 215.93,27.12 ; U8800.8 219.68,27.6 219.2,27.12 215.93,27.12 ; v1(215.93,27.37) 215.93,27.12
N65979211: length 3.2
  TOP w0.457: R8814.2 243.48,13.69 243.48,14.72 243.46,15.09 v1(243.54,15.17) 243.58,15.21 Q8800.4 245.17,15.21
N68998160: length 8.2
  TOP w0.102: Q8805.1 219.19,36.61 219.51,36.92 220.32,36.92 220.45,37.05 221.29,37.05 221.77,36.57 221.77,36.06 v1(222.28,35.55)
  TOP w0.254: Q8805.1 219.19,34.78 218.95,34.53 R8817.2 R8816.1
N68998162: length 13.6
  TOP w0.102: Q8805.3 220.14,38.29 219.73,38.7 219.41,38.7 218.49,39.62 v1(218.28,39.62) 218.28,38.77 218.41,38.64 218.41,37.3 C8827.1 217.73,36.62 R8815.2 217.6,36.09 217.25,35.74 217.25,34.96 217.4,34.81 217.4,33.36 216.01,31.97 216.01,31.78 215.34,31.11 215.34,30.79 SR8807.1
N125017610: length 6.6
  TOP w0.102: T0301.1 67.78,147.5 v2(67.23,146.95)
  BOTTOM w0.102: U0300.A33 62.47,148.75 62.72,148.5 63.07,148.5 63.35,148.22 63.75,148.22 63.84,148.14 65.67,148.14 66.24,147.56 66.62,147.56 v2(67.23,146.95)
N125017656: length 2.8
  TOP w0.102: v1(61.74,149.98) 61.34,150.38 R0300.2
  TOP w0.254: R0300.2 60.52,150.97 v6(60.3,151.19)
  BOTTOM w0.254: U0300.D37 60.23,151.13 v6(60.3,151.19)
N125020990: length 4.3
  TOP w0.102: R0900.1 43.06,144.55 42.4,145.21 42.4,145.36 42.2,145.55 42.2,146.15 41.74,146.61 v1(41.74,147.18)
  TOP w0.254: R0900.1 43.74,145.06 v6(43.74,145.3)
N125034509: length 1.4
  TOP w0.254: v1(26.06,139.46) v6(26.67,139.46) 26.94,139.46 R1000.2
N125034565:
  vias: v1(26.94,143.85) v6(26.72,143.27) v6(27.28,143.27)
N126015045: length 3.6
  TOP w0.305: v1(8.8,128.15) 8.8,127.26 R0503.1 R0500.2 C0503.2 R0501.1
N126015147: length 4.2
  TOP w0.305: C0504.2 R0501.2 ; C0504.2 12.34,125.49 v1(12.27,125.42) ; C0504.2 C0505.2 14.07,126.35 14.5,125.92 R0502.1
N126050534: length 13.3
  BOTTOM w0.089: 166.23,37.73 168.19,39.7 168.36,39.7 168.74,40.08 168.74,40.97 168.86,41.08 168.86,41.47 U2000.Y44
  BOTTOM w0.102: v1(166.95,32.3) 166.75,32.1 165.41,32.1 165.28,32.22 165.28,32.73 R2132.2 165.32,33.71 165.32,37 166.05,37.73 166.23,37.73
N126050588: length 9.3
  BOTTOM w0.089: U2000.AC44 170.71,41.42 170.85,41.27 170.85,40.15 170.2,39.5 170.2,38.24 169.69,37.73
  BOTTOM w0.102: R2120.2 R2121.1 169.09,34.33 169.14,34.38 169.14,37.18 v1(169.64,37.69) 169.69,37.73
N126051766: length 5
  TOP w0.102: v1(171.17,44.42) 170.64,44.95 v2(170.63,44.95) 170,44.31 170,42.96 169.47,42.44 R2142.1
  BOTTOM w0.089: v2(170.63,44.95) 171.03,44.54 U2000.AD38
N126053407: length 14.4
  BOTTOM w0.089: U2000.N44 165.46,41.31 165.46,40.96 165.19,40.69 165,40.69 164.95,40.63
  BOTTOM w0.102: R2249.2 156.9,34.66 156.48,35.08 156.48,36.35 R2258.1 157.48,37.35 157.48,37.66 v1(157.99,38.17) 158.65,38.83 162.2,38.83 163.09,39.71 164.02,39.71 164.94,40.63 164.95,40.63
N126053413: length 8.3
  BOTTOM w0.089: 163.95,37.73 164.87,38.65 165.89,38.65 166.24,39.01 167.23,39.99 167.23,40.71 167.55,41.03 167.55,41.32 167.53,41.34 167.53,42.23 U2000.U42
  BOTTOM w0.102: R2208.2 163.36,37.01 163.36,37.15 163.95,37.73
N126053497: length 18.6
  TOP w0.102: R2243.2 v1(156.9,37.66) 156.9,39.34 158.06,40.51 159.33,40.51 159.33,40.5 159.67,40.5 159.67,40.51 159.79,40.51 160.64,41.36 162.06,41.36 163.36,42.66 163.36,44.02 164.47,45.13 164.47,45.27 165.77,46.58 168.07,46.58 168.22,46.73 v2(168.22,46.73)
  BOTTOM w0.089: U2000.U35 167.67,46.17 v2(168.22,46.73)
N126053501: length 18.6
  BOTTOM w0.089: 158.1,39.75 161.78,39.75 162.64,40.61 163.6,40.61 164.01,41.02 164.01,41.17 U2000.L44
  BOTTOM w0.102: R2244.2 152.93,34.51 152.12,34.51 151.92,34.71 151.92,35.58 v1(151.51,35.98) 151.81,36.29 152.78,36.29 R2255.1 153.26,36.96 153.61,37.3 153.85,37.3 156.41,39.87 157.98,39.87 158.1,39.75
N126053508: length 21.1
  BOTTOM w0.089: 154.99,38.8 156.31,40.12 158.14,40.12 158.34,39.93 161.59,39.93 162.47,40.81 163.02,40.81 163.64,41.43 163.97,41.43 164.14,41.6 164.14,41.8 U2000.L43
  BOTTOM w0.102: R2245.2 151.73,34.1 151.42,34.42 151.42,35.4 150.54,36.28 v1(150.54,37.43) 151.79,37.43 R2256.1 153.24,37.56 153.75,37.56 154.99,38.8
N126053667: length 14.9
  BOTTOM w0.089: U2000.M45 164.94,41.14 163.87,40.07 162.87,40.07 162,39.21 157.56,39.21 156.08,37.73 155.9,37.73
  BOTTOM w0.102: R2204.2 155.54,34.57 155.54,35.52 155.64,35.62 155.64,36.35 R2201.1 155.22,37.05 155.9,37.73
N126061466: length 13
  BOTTOM w0.089: U2000.AY44 178.99,41.6 178.8,41.41 178.8,40.84
  BOTTOM w0.102: 178.8,40.84 179.5,40.14 180.71,40.14 181.25,39.59 181.79,39.59 ; v1(185.42,33.62) 184.94,34.1 R2329.2 C2306.1
  BOTTOM w0.114: C2306.1 183.06,34.61 183.06,35.03 183.18,35.15 183.18,38.2 181.79,39.59
N126061486: length 10.6
  TOP w0.102: R2333.2 179.68,34.8 179.74,34.86 179.74,35.54 R2347.2 178.96,36.32 178.96,37.69 178.53,38.12 178.53,40.87 v1(178.31,41.09) 178.15,41.25 178.15,42.44 178.71,43.01 v2(178.89,43.01)
  BOTTOM w0.089: v2(178.89,43.01) 179.25,43.37 U2000.BA40
N126061517: length 12.4
  TOP w0.102: R2331.2 178.66,34.34 178.86,34.54 178.86,35.74 178.69,35.91 C2308.1 178.75,36.34 178.75,37.61 178.09,38.27 v1(178.09,39.46) 178.32,39.69 178.32,40.25 178.09,40.49 178.08,40.49 177.83,40.74 177.83,42.41 178.47,43.05 v2(178.47,43.83)
  BOTTOM w0.102: v2(178.47,43.83) 178.43,43.79 U2000.AW42
N126061523: length 10
  BOTTOM w0.089: 178.51,40.86 179.29,40.08
  BOTTOM w0.102: R2332.2 182.55,34.28 182.8,34.53 182.8,35.08 182.97,35.24 182.97,36.35 C2309.1 182.52,36.79 v1(182.52,37.66) 182.52,38.37 181.5,39.4 181.18,39.4 180.63,39.95 179.42,39.95 179.29,40.08 ; U2000.AW45 178.51,40.86
N126061775: length 10.1
  TOP w0.102: v2(175.17,44.1) 175.03,44.24 174.03,44.24 173.62,43.83 173.62,40.9 174,40.52 174,39.29 173.37,38.66 v1(173.37,38.21) 173.37,37.99 173.04,37.66 173.04,37.16 R2302.2
  BOTTOM w0.102: U2000.AL39 174.95,44.05 175.12,44.05 v2(175.17,44.1)
N126061781: length 11.1
  TOP w0.102: R2303.2 174.21,36.96 174.21,38.58 174.68,39.04 174.68,39.18 175.22,39.72 175.22,41.7 175.78,42.26 175.78,43.91 v2(176.2,44.33) 176.63,44.76 v1(176.63,46.09)
  BOTTOM w0.102: v2(176.2,44.33) 176.1,44.33 U2000.AN38
N126061784: length 9
  TOP w0.102: v2(175.17,43.49) 174.79,43.49 v1(174.57,43.71) 174.57,43.05 173.82,42.29 173.82,40.98 174.2,40.6 174.2,39.14 173.8,38.74 173.8,37.96 173.53,37.69 R2304.2
  BOTTOM w0.089: U2000.AN41 175.46,43.2 v2(175.17,43.49)
N126061787: length 5.4
  BOTTOM w0.089: U2000.AG44 172.5,41.4 172.45,41.35 172.45,40.78 172.3,40.63 172.3,39.07 v1(172.57,38.8) 172.57,38 172.84,37.73
  BOTTOM w0.102: 172.84,37.73 173.53,37.04 R2305.2
N126071044: length 7.4
  TOP w0.102: v2(178.26,45.47) 178.79,44.95 178.79,44.75 v1(179.07,44.47) 179.19,44.59 180.52,44.59 180.79,44.32 180.79,44.11 181.42,43.48 182.45,43.48 183.16,42.77 R2472.2
  BOTTOM w0.089: v2(178.26,45.47) 178.61,45.81 U2000.AW35
N126071761: length 18.2
  TOP w0.114: v2(189.92,46.37) 189.59,46.7 v1(189.59,47.21) 189.76,47.39 R2429.2
  IN4 w0.076: v2(175.93,47.35) 176.47,47.89 178.17,47.89 178.59,48.31 180.18,48.31 182.54,45.95 189.5,45.95 v2(189.92,46.37)
  BOTTOM w0.102: U2000.AR31 176.4,47.82 v2(175.93,47.35)
N126071784: length 31.1
  IN2 w0.114: v2(199.31,41.95) 198.57,42.7 193.86,42.7 193.29,42.12 185.2,42.12 184.8,42.52 184.8,45.42 184.13,46.09 184.13,47.83 184.4,48.1 v2(184.4,51.08)
  BOTTOM w0.089: 184.24,50.92 183.5,50.92 181.81,50.92 181.55,50.66 181.29,50.66 181.23,50.72 181.11,50.72 U2000.BD25
  BOTTOM w0.102: R2483.1 199.77,41.42 199.31,41.88 v2(199.31,41.95) 199.12,42.15 v1(199.12,42.83) ; R2412.2 184.59,51.27 v2(184.4,51.08)
  BOTTOM w0.114: 184.24,50.92 v2(184.4,51.08)
N126071872: length 8.7
  BOTTOM w0.089: 184.71,59.91 184.2,59.91 183.93,59.64 183.93,59.04 182.57,57.68 182.03,57.68 181.83,57.48 181.3,57.48 181.19,57.59 181.06,57.59 U2000.BD11
  BOTTOM w0.102: 184.71,59.91 186.51,59.91 v1(186.92,60.32) 187.34,60.32 R2445.2
N126071895: length 14.3
  BOTTOM w0.089: U2000.BE11 181.81,57.73 181.94,57.86 182.5,57.86 183.76,59.12 183.76,60.35 184.16,60.75 184.71,60.75
  BOTTOM w0.102: v1(192.52,59.88) 192.15,60.26 191.6,60.26 R2448.2 190.53,61.33 189.03,61.33 188.97,61.27 187.59,61.27 187.07,60.75 186.45,60.75 C2401.1 185.61,60.75 184.71,60.75
N126072312: length 19.9
  TOP w0.102: v2(176.15,49.73) 176.15,49.35 176.37,49.13 v1(176.71,49.13) 177.94,49.13 178.25,48.81 179.12,48.81 179.25,48.68 180.71,48.68 181.44,47.95 183.77,47.95 183.9,48.07 184.26,48.07 184.99,48.81 186.93,48.81 187.5,49.38 188.73,49.38 188.94,49.58 190.94,49.58 R2426.1 R2499.1 R2406.2
  BOTTOM w0.089: v2(176.15,49.73) 176.15,49.74 176.5,50.09 U2000.AR27
