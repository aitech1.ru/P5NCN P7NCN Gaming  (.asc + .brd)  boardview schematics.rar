# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_D-MIC L: length 31.8
  TOP w0.381: 178,145.84 D302.2 ; D302.2 178.58,146.34 ; D302.2 178.58,145.33 ; 178.58,146.65 D301.2 178,147.16 ; 175.56,151.8 C301.2 176.07,152.27 ; 168.45,147.71 C302.2 ; C302.2 168.96,148.18 ; C302.2 167.95,148.18 ; 175.44,151.4 C300.2 174.97,151.91
  TOP w0.508: 182.08,150.35 U300.1 ; U300.1 183.58,150.35 ; U300.1 182.83,149.6 ; v2(177.82,150.18) 178.32,149.68 D300.2 ; 171.9,146.65 CON300.5 ; CON300.5 v2(172.87,147.75) ; CON300.5 171.05,147.75 ; CON300.5 171.9,148.85 ; 176.05,147.75 CON300.6 ; CON300.6 176.9,146.65 ; CON300.6 176.9,148.85 ; CON300.6 177.68,147.75 ; R301.1 177.65,149.06 v2(177.65,149.04) ; 182.08,147.05 U300.3 183.58,147.05 ; v2(175.6,148.84) CON300.1 176.27,149.7 ; CON302.8 165.65,152 ; CON302.8 163.45,152 ; CON302.8 164.55,151.15 ; 167.25,146.7 CON302.1 165.75,146.7 ; CON302.7 165.65,145.4 ; CON302.7 164.55,146.25 ; CON302.7 163.45,145.4 ; 165.75,148.3 CON302.3 167.25,148.3 ; 167.25,147.5 CON302.2 165.75,147.5
  vias: v2(162.76,150.03) v2(162.76,147.49) v2(162.92,152.39) v2(163,144.96) v2(164.73,147.51) v2(164.91,150.05) v2(165.82,145) v2(166.11,152.44) v2(167.11,145.85) v2(167.79,147.24) v2(167.95,145) v2(168.86,152.13) v2(169.8,147.85) v2(170.59,152.12) v2(171.31,144.96) v2(172.52,145.84) v2(173.48,147.17) v2(173.56,152.09) v2(173.85,144.96) v2(175.26,145.74) v2(176.39,144.96) v2(176.87,152.44) v2(177.88,145.74) v2(178.93,144.96) v2(179.41,152.44) v2(181.05,148.11) v2(181.25,149.82) v2(181.41,145.51) v2(181.79,146.91) v2(181.95,152.44) v2(183.82,145.38) v2(184.49,152.44) v2(185.44,145.76) v2(186.51,151.22) v2(186.51,148.68) v2(186.51,146.39) v2(186.61,145.38) v2(187.03,152.44) v2(187.34,149.92) v2(187.34,147.38) v5(170.34,148.38)
GND_D-MIC R: length 10.6
  TOP w0.432: C401.2 205.3,149.85 205.09,150.06 v2(205.09,150.1) ; v2(209.07,151.34) 209.07,150.81 R401.1
  TOP w0.457: v2(204.6,149.63) CON400.6 ; U400.3 v2(192.05,147.05)
  TOP w0.508: U400.1 v2(192.05,150.35) ; v2(206.38,149.55) 206.62,149.55 206.88,149.8 D400.2 ; v2(200.6,147.8) CON400.5 v2(199.6,149.06) ; v2(203.92,149.75) CON400.1 v2(203.3,150.6)
  vias: v2(190.88,152.11) v2(190.88,149.57) v2(190.88,147.03) v2(191.33,144.98) v2(193.26,152.42) v2(193.87,144.98) v2(195.8,152.42) v2(196.41,144.98) v2(197.79,152.37) v2(198.95,144.98) v2(201.35,152.37) v2(201.49,144.98) v2(203.42,152.42) v2(204.03,144.98) v2(205.96,152.42) v2(206.57,144.98) v2(207.78,147.03) v2(207.87,146.09) v2(208.32,144.98) v2(208.5,152.42) v2(209.65,148.72) v2(210.43,152.11) v2(210.43,149.57) v2(210.43,147.03) v5(209.35,147.52)
GND_LED: length 18
  TOP w0.356: LQ803.4 v2(192.56,157.4) ; LQ803.1 191.02,159.13 ; LQ803.1 191.74,158.7 ; LQ803.1 v2(190.14,158.7)
  TOP w0.381: v2(179.53,158.46) LC801.2 179.02,159.04
  TOP w0.432: 191.46,161.13 LC802.2 v2(190.96,160.55) ; v2(195.48,156.31) LC803.2
  TOP w0.508: LQ800.2 177.95,159.38 ; LQ800.2 177.95,158.19 ; LQ800.2 v2(176.73,158.78) ; LQ801.2 177.95,162.61 ; LQ801.2 177.06,162.01 ; LQ801.2 v2(177.95,161.3) ; LQ801.2 178.84,162.01 ; LQ802.2 v2(193.7,160.1) ; LQ802.2 191.75,160.1 ; LQ802.2 192.64,160.69 ; LQ802.2 192.64,159.5 ; 189.9,160.8 CON1.9 v2(188.26,160.8) ; 182.2,160.8 CON1.10 181.45,162.06
  vias: v1(171.02,156.97) v2(162.84,162.86) v2(162.8,156.32) v2(169.56,155.97) v2(169.66,162.93) v2(172.1,155.97) v2(172.2,162.93) v2(174.64,155.97) v2(174.74,162.93) v2(174.88,159.87) v2(177.18,155.97) v2(177.28,162.93) v2(178.89,157.75) v2(179.72,155.97) v2(179.82,162.93) v2(182.31,161.43) v2(182.26,155.97) v2(182.36,162.93) v2(182.35,160.12) v2(184.78,155.98) v2(184.9,162.93) v2(185.18,160.99) v2(186.76,160.62) v2(187.05,156.94) v2(187.1,155.97) v2(187.44,162.93) v2(187.63,157.68) v2(188.77,157.32) v2(188.86,155.97) v2(189.15,162.28) v2(189.98,162.93) v2(191.29,159.64) v2(191.4,155.97) v2(192.52,162.93) v2(193.94,155.97) v2(195.06,162.93) v2(196.48,155.97) v2(198.23,162.93) v2(198.39,155.97) v2(200.52,162.93) v2(200.55,155.97) v2(207.03,156.01) v2(207.16,162.86)
GND_PWR: length 61.9
  TOP w0.254: v2(203.4,177.48) PCON702.17 v2(203.4,175.27) ; v2(202.71,175.27) 202.91,175.47 PCON702.18 202.91,177.3 v2(202.73,177.48) ; v2(184.96,176.5) 185.2,176.73 CON402.21 185.2,178.89 v2(185.34,179.04) ; v2(181.7,178.91) CON402.28 ; CON402.28 181.3,177.7 ; CON402.28 v2(181.7,176.5) ; v2(195.2,178.91) CON402.1 v2(195.2,176.37) ; v2(171.5,172.43) PCON700.8 v2(171.5,170.77)
  TOP w0.381: 187.31,172.77 PC700.2 ; PC700.2 186.8,173.24 ; PC700.2 v2(187.94,173.24) ; PD700.2 v2(186.41,168.09) ; PD700.2 187.18,168.59 ; PD700.2 187.18,167.58
  TOP w0.432: 210.35,170.37 PC701.2 ; PC701.2 v2(210.86,169.73) ; PC701.2 211.37,170.37
  TOP w0.508: v2(169.4,173.27) 169.4,174.65 PCON700.10 ; PCON700.9 177.85,174.65 ; PCON700.9 v2(177.1,173.27) ; PCON700.9 176.35,174.65 ; PCON700.9 v2(177.1,176.06) ; 196.85,179.55 CON402.29 ; CON402.29 195.69,180.5 ; CON402.29 196.85,181.45 ; CON402.29 198.01,180.5 ; 213.05,179.23 v2(213.05,180.35) ; 213.05,179.23 PCON702.19 v2(213.05,178.05) ; 213.05,179.23 214.21,179.23 ; 213.05,179.23 211.9,179.23 ; PQ700.2 v2(197.29,172.86) ; PQ700.2 198.35,173.46 ; PQ700.2 199.24,172.86 ; PCON700.10 170.15,174.65 ; PCON700.10 v2(168.52,174.65) ; PCON700.10 169.4,175.91 ; 180.05,179.55 CON402.30 ; CON402.30 178.89,180.5 ; CON402.30 180.05,181.45 ; CON402.30 181.21,180.5 ; 201.26,179.23 202.41,179.23 ; 201.26,179.23 PCON702.20 v2(201.26,178.15) ; 201.26,179.23 v2(201.26,180.5) ; 201.26,179.23 200.1,179.23 ; v2(211.36,174.29) 211.36,173.95 211.11,173.69 PD702.2 ; v2(197.14,174.2) PD701.2 196.44,173.62
  BOTTOM w0.457: PSW1700.6 v2(190.48,166.63) ; PSW1700.6 191.25,167.11 ; PSW1700.6 191.9,166.63 ; 191.25,170.46 PSW1700.5 ; PSW1700.5 v2(190.48,169.98) ; PSW1700.5 191.25,169.49 ; PSW1700.5 191.9,169.98
  BOTTOM w0.508: PSW1700.1 193.75,169.4 ; PSW1700.1 v2(192.16,169.4) ; PSW1700.1 193.03,169.96 ; PU701.3 v2(209.25,183.9) ; PU701.3 209.25,182.14 ; PU701.3 208.69,182.95 ; PU701.3 209.81,182.95 ; PSW1700.2 190.2,169.4 ; PSW1700.2 v2(188.58,169.4) ; PSW1700.2 189.48,169.96
  vias: v1(185.45,168.09) v2(162.77,175.78) v2(162.77,173.36) v2(162.77,170.65) v2(162.77,167.6) v2(164.45,185.91) v2(164.46,166.46) v2(166.91,174.94) v2(166.98,185.92) v2(167,166.46) v2(167.8,169.81) v2(169.52,185.92) v2(169.54,166.46) v2(170.65,168.23) v2(171.61,183.8) v2(171.66,179.43) v2(171.66,174.68) v2(172.06,185.92) v2(172.08,166.46) v2(173.59,173.49) v2(173.97,170.75) v2(174.23,177.22) v2(174.6,185.92) v2(174.62,166.46) v2(175.73,183.42) v2(176.21,180.98) v2(176.44,168.16) v2(177.05,171.66) v2(177.14,185.92) v2(177.16,166.46) v2(178.24,178.8) v2(178.61,173.32) v2(178.74,180.5) v2(178.7,176.64) v2(179.68,185.92) v2(179.7,166.46) v2(180.14,175.61) v2(180.32,183.4) v2(180.42,168.16) v2(180.68,171.64) v2(181.41,180.43) v2(182.22,185.92) v2(182.24,166.46) v2(182.76,170.04) v2(183.82,179.67) v2(183.9,168.21) v2(184.76,185.92) v2(184.78,166.46) v2(185.3,171.79) v2(186.29,183.35) v2(187.3,185.92) v2(187.33,171.98) v2(187.32,166.46) v2(187.46,180.68) v2(187.82,178.95) v2(187.92,170.95) v2(189.37,178.98) v2(189.41,172) v2(189.84,185.92) v2(189.86,166.46) v2(190.84,181.87) v2(191.65,183.35) v2(192.38,185.92) v2(192.4,166.46) v2(192.67,180.55) v2(192.67,178.95) v2(194.92,185.92) v2(194.94,166.46) v2(195.36,181.75) v2(195.5,180.5) v2(197.06,175.85) v2(197.46,185.92) v2(197.48,166.46) v2(198.53,183.35) v2(199.13,180.5) v2(199.63,178.27) v2(199.73,181.85) v2(199.78,174.94) v2(200,185.92) v2(200.02,166.46) v2(202.54,185.92) v2(202.5,183.4) v2(202.56,166.46) v2(202.75,180.48) v2(203.87,181.95) v2(205.08,185.92) v2(205.1,166.46) v2(205.29,178.01) v2(206.33,183.42) v2(206.99,180.5) v2(207.64,185.92) v2(207.64,166.46) v2(207.75,182.08) v2(209.41,179.71) v2(210.16,185.92) v2(210.15,166.46) v2(210.86,178.09) v2(212.25,183.5) v2(212.7,185.92) v2(212.69,166.46) v2(213.77,181.59) v2(215.24,185.92) v2(215.23,166.46) v2(216.42,183.47) v2(217.78,185.92) v2(217.77,166.46) v2(218.4,180.25) v2(219.73,184.53) v2(219.72,182.13) v2(219.72,178.88) v2(219.72,167.27)
GND_RT8812A: length 9.1
  TOP w0.381: C8909.2 R8901.1 185.46,84.76 185.39,84.82 C8908.2 186.57,85.23 v1(186.61,85.18) 186.61,86.64 186.37,86.88 v2(186.11,86.88) 185.78,87.21 185.45,87.21 R8910.2 ; SR8906.1 183.91,87.92 v2(184.47,87.92)
  BOTTOM w0.508: v2(184.47,87.92) 185.03,87.37 185.75,87.37 186.11,87.01 v2(186.11,86.88)
GND_SIGNAL: length 13.4
  TOP w0.381: v2(231.45,24.3) C8826.1
  TOP w0.508: R8807.1 C8814.1 218.49,30.82 v2(218.26,31.05) ; R8808.1 v2(220.52,31.72) ; v2(224.64,31.18) C8809.1 ; R8813.1 C8824.2 216.65,25.29 v2(217.01,25.66) ; C8831.2 C8815.1 214.07,29.43 v2(213.28,29.43) ; C8825.1 231.37,25.7 v2(231.45,25.62) ; C8808.1 223.24,31.64 v2(222.94,31.34)
  IN3 w0.102: 219.76,34.89 220.14,34.64
  BOTTOM w0.381: U8801.2 v2(222.3,36.42)
  BOTTOM w0.508: v2(222.35,33.11) 222.35,32.85 222.06,32.56 C8832.2 ; v2(220.52,31.72) 220.7,31.89 R8818.1 ; C8830.2 218.88,36.11 219.18,36.42 v2(220.02,36.42)
  vias: v1(225.98,29.94) v2(225.6,30.7) v2(226.24,30.7) v2(226.86,30.68)
SGND_VGA: length 12.7
  TOP w0.457: SR8703.1 157.49,83.79 v1(157.85,84.16) 157.17,84.84 v2(156.79,84.84)
  BOTTOM w0.381: C8700.1 153.98,88.41 153.72,88.16 153.72,87.47 152.97,86.72 152.97,85.91 152.65,85.59 C8709.2
  BOTTOM w0.457: C8700.1 155.32,88.41 155.75,87.98 155.75,87.24 156.13,86.86 R8705.1 C8726.2 156.6,85.03 v2(156.79,84.84) 157.02,84.61 C8725.2
VCC: length 4.1
  BOTTOM w0.203: U8000.42 10.27,180.48 9.63,181.12 9.63,181.42 C80108.1
  BOTTOM w0.432: v1(9.19,183.74) SR8000.1 C80108.1
VCC0P9_CIO: length 1.8
  TOP w0.254: U1101.R8 241.15,35.7 v4(241.47,35.37) 241.15,35.05 U1101.R9 ; U1101.R11 241.15,34.36 v4(240.84,34.05) U1101.R12
VCC0P9_DP: length 2.6
  TOP w0.254: U1101.L11 243.1,34.4 v4(243.42,34.07) 243.1,33.75 U1101.L12
  BOTTOM w0.102: C1172.1 241.55,38.35 v1(241.53,38.32)
  BOTTOM w0.254: v4(240.17,34.07) 240.17,34.65 C1171.1
  vias: v4(240.17,33.42) v4(242.77,36.01)
VCC0P9_LVR: length 10.9
  TOP w0.254: 244.72,31.47 245.02,31.18 245.02,31.18 U1101.F18 ; 244.72,31.47 v4(244.72,31.47) ; 244.72,31.47 244.4,31.15 U1101.H18 ; U1101.H11 244.4,34.4 v4(244.07,34.07) 243.75,34.4 U1101.J11
  BOTTOM w0.102: C1163.1 247.48,28.43 v1(248,27.91)
  BOTTOM w0.305: 244.8,31.54 244.88,31.63 244.88,32.27 C1165.1 C1166.1 244.41,33.73 v4(244.07,34.07) ; 244.8,31.54 v4(244.72,31.47) ; 244.8,31.54 244.83,31.51 246.31,31.51 247.12,30.7 C1164.1
  BOTTOM w0.508: C1163.1 C1164.1
VCC0P9_PCIE: length 1.6
  BOTTOM w0.102: C1177.1 242.5,28.03 v1(242.95,27.58)
  vias: v4(242.14,32.12) v4(242.13,31.46) v4(242.11,30.85) v4(242.12,30.2)
VCC0P9_SVR:
  vias: v1(249.58,33.75) v2(249.61,44.42) v2(250.24,44.16) v2(250.24,43.53) v2(250.24,42.89) v4(245.37,34.07) v4(245.37,33.42) v4(245.37,32.77)
VCC0P9_USB: length 5.3
  TOP w0.254: U1101.R15 241.15,32.45 v4(241.47,32.12) 241.15,31.8 U1101.R16
  BOTTOM w0.102: C1182.1 241.15,31.11 241.25,31.01 241.25,29.46 240.94,29.15 v1(240.36,29.15)
  BOTTOM w0.305: v4(241.47,32.12) 241.19,31.84 C1181.1 240.92,31.11 C1182.1
VCCGT_VCCSENSE: length 49.6
  IN3 w0.152: v2(27.74,162.45) 29.95,164.66 29.95,170.95 28.95,171.95 26.44,171.95 24.9,173.49 23.46,173.49 19.77,177.18 v2(18.97,177.18)
  BOTTOM w0.203: R8019.2 C8013.1 R8020.1 19.27,176.49 C8023.1 19.22,176.94 v2(18.97,177.18) ; v2(27.74,162.45) 27.74,162.78 v1(27.99,163.03) 34.77,163.03 36.07,161.73 36.07,156.11 38.32,153.86 40.65,153.86 42.29,152.23 U0300.AH38
VCCGT_VSSSENSE: length 51.3
  TOP w0.254: R8089.1 17.87,176.23 18.17,176.23 v1(18.42,176.48) 18.42,177.05 v2(18.29,177.18)
  IN3 w0.152: v2(18.29,177.18) 18.8,177.69 19.62,177.69 23.57,173.74 25.08,173.74 26.62,172.2 29.08,172.2 30.24,171.04 30.24,164.32 v2(28.37,162.45)
  BOTTOM w0.203: U0300.AH37 41.9,151.46 41.9,152.09 40.54,153.45 38.16,153.45 35.66,155.95 35.66,161.56 34.6,162.63 28.55,162.63 v2(28.37,162.45) ; R8027.1 17.1,177.26 17.1,177.07 C8022.1 C8023.2 18.35,177.12 v2(18.29,177.18)
VCCIO_BST:
  vias: v1(74.76,159.1)
VCCIO_BST_R: length 0.9
  BOTTOM w0.102: v1(75.08,162.88) 75.08,161.99
VCCIO_EN: length 7.5
  TOP w0.102: v1(79.64,158.43) C9411.1 ; C9411.1 R9403.2 79.25,159.73 v2(79.43,159.91) ; C9411.1 77.97,158.43 77.14,157.6 D9400.1
  BOTTOM w0.102: v2(79.43,159.91) 78.89,159.91 78.65,159.68 U9400.15
VCCIO_FB: length 16.6
  TOP w0.203: v2(79.67,162.51) 79.41,162.51 78.63,161.73 78.63,161.72 77.22,160.3 76.97,160.3 76.32,159.66 76.32,157.66 v1(75.59,156.92) 75.59,156.88 v2(73.3,154.6)
  BOTTOM w0.203: R9407.2 73.05,154.35 v2(73.3,154.6) ; U9400.13 77.65,159.84 78.11,160.3 R9406.1 78.11,162.12 R9405.2 78.68,162.15 79.05,162.51 v2(79.67,162.51)
VCCIO_FB_R: length 7.5
  BOTTOM w0.203: JP9401.1 71.42,161.97 71.81,162.35 71.81,162.83 v1(72.24,163.26) 72.39,163.42 75.36,163.42 76.51,162.27 77.09,162.27 R9405.1
VCCIO_LX: length 2.3
  BOTTOM w0.203: R9408.1 74.02,155.31
VCCIO_O: length 8
  TOP w0.254: v2(71.24,153.62) 75.93,153.62 v2(76.7,154.39)
  BOTTOM w0.254: v2(76.7,154.39) 76.7,154.79 77.65,155.74 U9400.6
  vias: v1(68.83,152.82)
VCCIO_RC:
  vias: v1(77.78,152.75)
VCCSA_VCCSENSE: length 90.4
  TOP w0.102: C8006.2 R8048.2 3.61,176.67 3.86,176.93 v2(3.86,177.44) ; C8006.2 C8001.1 ; C8006.2 R8075.1
  IN3 w0.152: v2(27.74,165.44) 27.33,165.84 25.14,165.84 19.89,171.09 14.83,171.09 7.92,177.99 5.64,177.99 5.63,177.98 5.27,177.98 5.26,177.99 4.11,177.99 3.86,177.74 v2(3.86,177.44)
  BOTTOM w0.203: 34.21,167.15 30.53,167.15 28.68,165.29 27.88,165.29 v2(27.74,165.44) ; 34.21,167.15 40.89,167.15 41.47,166.57 47.85,166.57 51.42,163.01 62.46,163.01 64.68,160.78 64.68,157.04 61.79,154.14 59.08,154.14 57.86,152.92 55.73,152.92 54.89,152.09 U0300.M38 ; 34.21,167.15 v1(34.21,167.4)
VCCSA_VSSSENSE: length 89.2
  TOP w0.102: v2(5.71,177.4) 5.71,176.94 R8033.2 C8001.2 C8003.2
  IN3 w0.152: v2(5.71,177.4) 6,177.69 7.8,177.69 14.7,170.79 19.84,170.79 25.21,165.41 v2(27.1,165.41)
  BOTTOM w0.152: v2(5.71,177.4) 5.92,177.61 6.93,177.61 7.16,177.38 U8000.31
  BOTTOM w0.203: v1(35.94,166.59) 35.94,166.84 ; 35.94,166.84 30.66,166.84 28.76,164.95 27.4,164.95 27.1,165.24 v2(27.1,165.41) ; 35.94,166.84 40.76,166.84 41.34,166.27 47.73,166.27 51.29,162.7 62.33,162.7 64.38,160.66 64.38,157.23 61.62,154.48 58.91,154.48 57.71,153.28 55.52,153.28 54.49,152.25 54.49,151.46 U0300.M37
VCCST_PG: length 252.4
  TOP w0.102: v2(27.46,99.35) 27.46,95.67 28.22,94.9 28.22,85.96 27.54,85.28 20.22,85.28 19.46,84.52 19.46,83.3 18.98,82.82 5.86,82.82 4.89,81.86 v2(3.92,81.86) ; U0702.4 110.4,50.55 110.11,50.26 109.35,50.26 107.9,48.81 105.31,48.81 v2(105.14,48.64)
  IN3 w0.102: v2(27.46,99.35) 36.26,108.15 41.25,108.15 42.72,109.61 47.6,109.61 48.66,108.55 63.68,108.55 64.03,108.9 64.03,111.17 63.51,111.7 63.51,112.88 v2(63.81,113.18) 64.38,113.18 64.98,112.58 64.98,103.13 83.33,84.77 83.33,82.41 85.4,80.34 89.07,80.34 90.27,79.13 90.27,74.17 91.2,73.25 91.2,70.52 92.67,69.04 92.67,64.23 94.27,62.63 94.27,60.41 93.92,60.06 93.92,53.57 94.29,53.2 94.29,52.36 98.49,48.17 104.67,48.17 v2(105.14,48.64)
  BOTTOM w0.102: v1(105.17,49.44) 105.17,48.67 v2(105.14,48.64) ; v2(63.81,113.18) 64.98,113.18 73,121.2 R0730.1 R0729.1 ; v2(3.92,81.86) 3.33,81.86 3.11,82.07 3.11,88.52 5.28,90.7 5.28,94.4 4.88,94.79 4.88,99.73 5.88,100.73 9.27,100.73 9.55,100.45 13.15,100.45 13.46,100.76 13.46,104.95 11.25,107.15 8.98,107.15 5.59,110.54 5.59,115.6 5.98,115.99 6.34,115.99 7.48,117.13 7.48,118.71 6.91,119.29 R4405.2
VCCST_PG_R: length 21.1
  IN1 w0.102: v2(70.51,123.69) 69.16,125.04 66.69,125.04 62.31,129.42 62.31,130.85 60.61,132.54 57.65,132.54 57.08,133.12 v6(57.08,133.59)
  BOTTOM w0.102: U0300.H13 57.33,133.34 v6(57.08,133.59) ; R0730.2 71.25,123.92 v1(71.15,124.02) 70.82,123.69 v2(70.51,123.69)
VCCST_PWRGD: length 9.6
  TOP w0.102: U0703.4 112.49,53.7 112.15,53.36 112.15,52.65 111.89,52.39 111.2,52.39 111.05,52.54 U0702.2 111.05,54.23 111.24,54.42 111.74,54.42 111.94,54.62 R0750.1 111.94,55.09 112.14,55.29 113.25,55.29 R0751.1 113.67,55.25 114.08,55.66 v1(114.08,55.93)
VDD_+3VS_L: length 17
  TOP w0.102: v2(179.4,150.33) 179.84,150.77 v5(179.84,150.89)
  TOP w0.432: U300.6 184.31,151.21 181.59,151.21 180.06,149.68 D300.1 v2(179.4,150.33) ; v2(176.45,150.36) 176.76,150.36 176.9,150.49 R300.2 C301.1 175.8,150.67 174.32,150.67 174.11,150.88 C300.1 SR300.2
  IN1 w0.432: v2(176.45,150.36) 176.45,150.41 177.25,149.61 178.68,149.61 v2(179.4,150.33)
VDD_+3VS_R: length 17
  TOP w0.432: D400.1 206.63,151.05 206.3,150.72 C401.1 ; D400.1 207.31,151.05 207.52,151.26 R400.2 ; D400.1 v2(206.88,151.73) ; U400.6 v2(196.96,150.35)
  TOP w0.457: v5(205.67,151.66) 205.61,151.71 SR400.2
  TOP w0.508: C401.1 205.76,151.57 v5(205.67,151.66)
  IN4 w0.432: v2(206.88,151.73) 202.21,151.73 200.83,150.35 v2(196.96,150.35)
VIN: length 2.1
  TOP w0.102: v1(10.52,182.8) 9.86,182.8
  BOTTOM w0.203: U8000.41 9.87,180.44 v2(9.12,181.18)
15_17_ID: length 326.8
  TOP w0.102: v2(172.04,31.08) 172.04,31.44 172.88,32.28 172.88,33.71 173.28,34.11 R2309.2 173.74,34.11 174,34.37 174,37.44 174,37.44 174,38.65 174.47,39.13 174.47,39.27 175.01,39.81 175.01,41.78 175.58,42.35 175.58,44.39 v2(176.2,45.01)
  IN1 w0.102: v2(105.33,35.35) 109.75,30.93 115.98,30.93 117.39,29.52 130.09,29.52 130.93,30.36 151.57,30.36 152.34,31.13 163.58,31.13 164.6,30.12 165.54,30.12 166.03,30.61 168.71,30.61 168.75,30.65 169.52,30.65 170.36,31.49 171.63,31.49 v2(172.04,31.08)
  IN2 w0.102: v2(106.38,43.2) 102.28,43.2 100.21,45.26 73.48,45.26 71.78,46.96 65,46.96 64.98,46.94 61.62,46.94 60.8,47.76 54.42,47.76 53.86,47.2 50.51,47.2 46.51,51.2 43.87,51.2 42.2,52.88 40.12,52.88 35.03,57.97 35.03,61.12 34.4,61.74 34.4,62.3 30.16,66.55 30.16,68.31 27.69,70.77 27.69,81.92 19.45,90.16 19.45,119.53 16.82,122.17 16.82,122.93 15.35,124.4 15.35,130.57 17.83,133.05 17.83,137.35 18.29,137.8 18.29,143.29 18.01,143.56 18.01,145.57 17.4,146.19 17.4,146.7 17.86,147.16 17.86,151.63 24.36,158.13 24.36,166.84 23.74,167.46 23.74,169.62 26.48,172.36 26.48,175.61 27.5,176.63 32.24,176.63 32.62,177.01 34.82,177.01 36.14,178.32 38.56,178.32 39.53,179.29 39.83,179.29 40.75,180.21 42.81,180.21 42.95,180.07 v2(42.95,179.79)
  BOTTOM w0.102: v2(176.2,45.01) 175.72,45.49 U2000.AN36 ; CON5602.28 43.25,179.48 42.95,179.78 v2(42.95,179.79) ; v2(105.33,35.35) v1(105.33,37.13) 105.33,42.16 v2(106.38,43.2)
+1P2V: length 257.4
  TOP w0.254: R2452.2 187.12,64.45 186.87,64.71 v2(186.87,65.42)
  TOP w0.305: R0500.1 9.73,125.69 v1(10.15,125.28) 10.94,125.28 11.48,124.73 12.7,124.73 v2(13.54,125.57)
  TOP w0.508: R1017.1 92.5,108.58 91.77,109.31 74.01,109.31 71.02,112.31 v2(64.44,112.31) ; 22.61,127.14 22.61,126.89 25.1,124.4 25.1,123.36 24.71,122.98 v6(24.71,121.81)
  IN1 w0.254: v2(104.64,70.06) 105.61,69.09 105.61,67.1 v2(106.37,66.34) ; v2(186.87,65.42) 186.87,64.18 185.65,62.96 185.03,62.96 181.45,59.38 181.45,42.51 180.04,41.1 179.62,41.1 179.3,41.42 172.36,41.42 170.25,39.31 151.57,39.31 151.39,39.5 146.25,39.5 145.42,40.33 136.73,40.33 134.39,42.66 117.31,42.66 117.25,42.61 112.17,42.61 110.88,43.91 105.33,43.91 103.45,42.03 99.19,42.03 98.88,42.33 v2(98.88,42.82)
  BOTTOM w0.254: v2(106.37,66.34) 106.41,66.34 107.01,65.74 107.01,65.02 108.79,63.24 108.79,58.77 111.86,55.69 111.86,54.38 104.57,47.09 102.63,47.09 100.14,44.6 v1(100.14,43.37) 100.14,42.34 99.76,41.97 99.19,41.97 98.88,42.28 v2(98.88,42.82)
  BOTTOM w0.356: C0701.1 14.46,126.68 14.26,126.48 U0701.5
  BOTTOM w0.381: v2(13.54,125.57) 13.8,125.82 U0701.5
  BOTTOM w0.508: v2(64.44,112.31) 46.03,112.31 v1(45.98,112.36) 45.98,112.31 43.43,114.85 34.76,114.85 29.85,119.77 26.04,119.77 24.71,121.09 v6(24.71,121.81) 23.95,121.81 22.7,120.56 18.74,120.56 16.76,122.53 C0701.1
  vias: v3(93.77,108.56) v3(93.77,107.68) v3(93.77,106.79) v3(105.45,82.19) v3(105.45,81.28) v3(105.45,80.34) v3(105.45,79.47) v3(105.45,78.57) v3(105.41,77.61) v3(106,76.91) v3(106.27,78.9) v3(106.25,77.97) v3(106.87,76.86) v3(106.93,75.96) v3(107.12,77.69) v3(107.87,76.9)
+1P2V_CPU: length 9.5
  TOP w0.102: 57.58,131.36 57.58,131.51 v6(57.15,131.94) 56.74,131.54 56.74,131.41
  IN2 w0.102: 28.12,117.82 28.55,117.82 ; 57.88,130.22 58.08,130.22 ; 59.14,130.2 60.21,130.2
  BOTTOM w0.254: v2(68.28,123.98) 68.55,124.26 R1001.2 ; v6(43.55,130.6) 43.45,130.6 U0300.AG9 ; v6(44.45,131.92) 44.59,131.92 U0300.AE12 ; v6(41.72,132.55) 41.42,132.25 U0300.AJ12 41.1,132.25 v6(40.81,131.96) U0300.AL11
  BOTTOM w0.305: U0300.AA6 48.57,128.01 v6(48.64,128.01) 48.97,128.34 U0300.W6 ; U0300.L12 56.07,132.43 56.56,132.43 U0300.K12
  BOTTOM w0.33: U0300.K12 56.84,132.25 v6(57.15,131.94)
  vias: v1(56.31,110.56) v3(53.99,107.43) v3(54.62,106.81) v3(55.34,106.08) v3(56.33,105.09) v3(56.98,104.45) v3(57.64,103.78) v6(33.5,129.37) v6(33.5,128.72) v6(35.31,131.99) v6(35.76,117.03) v6(36.04,127.98) v6(36.24,132.52) v6(43.6,127.96) v6(52.07,127.98) v6(52.08,127.35) v6(56.17,127.97) v6(57.87,128)
+1P2V_DUAL: length 275.7
  TOP w0.305: CON1700.112 61.38,66.23 61.71,66.56 v2(62.71,66.56) 62.88,66.4 CON1700.118 ; CON1600.136 67.38,78.54 v2(67.74,78.91) 68.05,78.6 68.75,78.6 68.88,78.48 CON1600.142 ; CON1600.178 79.88,78.8 80.34,79.26 v2(80.72,79.26) ; CON1600.241 C1834.1 95.05,67.2 v2(95.05,67.2) ; CON1700.241 95.63,55.52 v2(95.73,55.42) ; CON1600.148 72.38,78.34 73.33,79.29 73.89,79.29 ; CON1600.153 73.63,68.04 73.42,67.83 v2(73.06,67.83) 73.04,67.81 72.47,67.81 72.13,68.15 CON1600.147 72.13,70.27 v2(71.74,70.65) ; CON1700.178 79.88,66.56 79.98,66.66 79.98,67.15 C1616.1 79.71,67.2 79.43,66.92 v2(79.27,66.92) ; v2(73.91,78.68) 73.88,78.64 CON1600.154 ; CON1600.130 65.88,78.29 65.46,78.7 v2(65.02,78.7) 64.82,78.7 64.38,78.26 CON1600.124 ; C1835.1 85.13,67.2 CON1600.199 ; CON1700.141 68.63,55.94 68.61,55.94 v2(68.38,55.71) 68.36,55.69 v2(67.28,55.69) 67.13,55.85 CON1700.135 ; CON1700.33 41.63,58.03 41.28,58.38 v2(41.25,58.38) ; v2(73.38,55.74) 73.63,55.99 CON1700.153 ; CON1600.141 68.63,68.09 68.89,67.83 v2(70.03,67.83) ; v2(71.88,58.47) 72.13,58.22 CON1700.147 ; CON1700.124 64.38,66.3 v2(64.64,66.56) 64.72,66.56 C1823.1 65.88,66.68 CON1700.130 ; v2(48.14,67.21) 47.25,67.21 C1832.1 46.88,66.84 CON1700.54 ; v2(66.83,66.56) 66.95,66.56 67.28,66.89 67.34,66.89 C1824.1 67.64,66.54 67.38,66.27 CON1700.136 ; C1828.1 76.07,66.92 75.38,66.22 CON1700.160 ; C1828.1 76.07,67.2 76.07,67.91 76.13,67.96 CON1600.163 ; C1828.1 75.43,67.2 v2(75.38,67.15) 75.13,67.4 CON1600.159 ; C1617.1 90.6,66.49 90.38,66.26 CON1700.220 ; v2(88.82,79.9) 89.54,79.9 90.38,79.06 CON1600.220 ; v2(63.96,55.62) 64.13,55.78 CON1700.123 ; CON1600.12 36.38,79.49 36.78,79.9 v2(37.24,79.9) ; CON1600.75 C1836.1 ; CON1700.117 62.63,56.01 62.26,55.64 v2(61.39,55.64) 61.13,55.91 CON1700.111 ; v2(70.03,66.56) 69.21,66.56 68.88,66.22 CON1700.142 ; v2(73.06,67.2) C1825.1 CON1700.148 ; CON1600.33 41.63,67.78 41.55,67.71 C1833.1 ; CON1600.54 46.88,78.32 46.72,78.48 46.72,78.91 47.07,79.26 v2(47.3,79.26) ; v2(51.82,58.41) 52.13,58.1 CON1700.75 ; CON1700.163 76.13,55.49 v2(76.17,55.44) ; 73.89,79.29 v2(73.91,79.31) ; 73.89,79.29 74.48,79.29 75.38,78.39 CON1600.160 ; v2(66.5,55.67) 65.83,55.67 65.63,55.87 CON1700.129 ; C1837.1 36.38,67.15 CON1700.12 ; v2(56.35,79.44) 56.87,79.44 57.38,78.94 CON1600.96 ; CON1600.112 61.38,78.31 61.82,78.75 v2(62.18,78.75) 62.57,78.75 62.88,78.45 CON1600.118 ; CON1600.111 61.13,67.82 61.01,67.71 C1838.1 60.26,67.2 60.18,67.28 v2(60.18,67.25) ; CON1700.96 57.38,66.48 57.4,66.51 C1839.1 ; CON1600.123 64.13,68.16 63.78,67.81 62.71,67.81 v2(62.69,67.83) 62.63,67.9 CON1600.117 ; CON1700.199 85.13,58.22 85.34,58.43 v2(85.55,58.43) ; CON1700.154 73.88,66.32 73.63,66.56 v2(73.06,66.56) ; CON1700.159 75.13,55.48 v2(75.08,55.44) ; CON1600.129 65.63,68.15 65.94,67.83 v2(66.83,67.83) 67.13,68.13 CON1600.135
  TOP w0.432: v2(52.97,67.22) 52.94,67.2 C1836.1 ; v2(37.52,67.22) 37.49,67.2 C1837.1 ; C1833.1 v2(42.52,67.2) ; v2(85.8,67.2) C1835.1 ; C1617.1 91.24,67.2 91.26,67.17 v2(92,67.17) ; C1839.1 56.74,67.2 v2(56.71,67.22)
  TOP w0.508: v2(42.52,67.2) 42.55,67.18 C1843.1
  IN2 w0.102: 71.46,60.78 71.7,60.52 ; 79.95,81.19 79.74,80.88
  BOTTOM w0.254: R1710.1 C1710.2 C1717.1 34.8,91.45 35.31,91.96 v2(35.66,91.96) ; R1701.1 105.56,62.3 105.56,62.3
  BOTTOM w0.305: v2(66.83,66.56) 66.63,66.36 CON1701.141 ; v2(42.52,67.2) 44.07,67.2 44.88,68 CON1601.54 ; CON1701.159 73.13,66.5 v2(73.06,66.56) ; v2(63.96,55.62) 63.88,55.7 CON1701.130 ; CON1701.123 62.13,66.25 62.43,66.56 v2(62.71,66.56) 63.32,66.56 63.63,66.26 CON1701.129 ; CON1701.153 71.63,66.36 71.83,66.56 v2(73.06,66.56) ; CON1701.178 77.88,58.13 78.77,59.02 v2(78.99,59.02) ; v2(73.06,66.56) 73.84,66.56 74.13,66.28 CON1701.163 ; CON1701.135 65.13,66.34 64.9,66.56 v2(64.64,66.56) ; 69.11,78.91 69.62,78.91 70.13,78.4 CON1601.147 ; CON1701.111 59.13,66.3 59.46,66.64 60.18,66.64 v2(60.18,66.64) 60.51,66.64 60.63,66.53 CON1701.117 ; C1826.1 85.95,54.45 86.79,54.45 87.61,55.27 87.85,55.27 88.38,55.8 CON1701.220 88.38,59.12 87.76,59.73 v2(87.43,59.73) ; CON1601.124 62.38,68.15 v2(62.69,67.83) 63.73,67.83 63.88,67.98 CON1601.130 ; v2(48.14,67.21) 49.88,67.21 50.13,66.97 CON1701.75 ; CON1601.118 60.88,67.52 60.61,67.25 v2(60.18,67.25) 59.77,67.25 59.38,67.65 CON1601.112 ; CON1701.160 v2(73.38,55.74) ; CON1601.33 39.63,74.44 40.36,73.7 41,73.7 v2(41.15,73.55) 40.85,73.25 37.39,73.25 36.78,72.64 36.78,72.41 35.48,71.11 35.23,71.11 34.38,70.25 CON1601.12 ; CON1601.142 66.88,67.88 v2(66.83,67.83) 65.59,67.83 65.38,68.04 CON1601.136 ; CON1701.154 v2(71.88,58.47) ; v2(55.32,70.42) 55.38,70.37 CON1601.96 ; CON1701.199 83.13,66.4 83.92,67.2 v2(85.8,67.2) ; CON1601.148 70.38,68.18 v2(70.03,67.83) ; R1700.1 69.77,55.34 70.38,55.94 CON1701.148 70.38,58.27 v2(70.03,58.61) ; CON1601.111 59.13,78.23 58.98,78.37 58.98,79.66 59.11,79.78 v2(59.56,79.78) ; CON1701.136 65.38,55.9 65.68,55.59 ; v2(66.5,55.67) 66.88,56.04 CON1701.142 ; CON1701.118 60.88,56.16 v2(61.39,55.64) 62.05,55.64 62.38,55.96 CON1701.124 ; v2(95.05,67.2) 94.21,67.2 93.63,66.61 CON1701.241 ; CON1701.147 70.13,66.46 v2(70.03,66.56) ; v2(49.82,75.11) 50.13,75.41 CON1601.75 ; v2(58.07,60.16) 58.87,60.16 59.51,59.52 59.51,58.26 59.38,58.13 CON1701.112 59.38,55.27 ; CON1601.199 83.13,75.47 82.63,74.97 v2(82.3,74.97) ; CON1701.54 44.88,58.18 v2(45.11,58.41) ; CON1601.160 73.38,68.14 v2(73.06,67.83) 72.09,67.83 71.88,68.04 CON1601.154 71.88,70.52 v2(71.74,70.65) ; v2(40.21,62.48) 40.19,62.5 39.01,62.5 37.85,61.34 36.09,61.34 35.52,60.77 35.52,59.65 34.38,58.5 CON1701.12 ; CON1601.178 77.88,67.51 78.33,67.05 79.14,67.05 v2(79.27,66.92) ; v2(55.38,55.59) CON1701.96 ; CON1601.241 93.63,75.4 v2(90.48,72.25) 89.46,72.25 88.38,71.17 CON1601.220 ; v2(37.52,67.22) 39.01,67.22 39.49,66.75 39.49,66.37 39.63,66.24 CON1701.33
  BOTTOM w0.432: v2(68.15,85.36) 68.1,85.31 R1601.1
  BOTTOM w0.508: C1822.1 79.76,55.34 v2(80.04,55.62)
  vias: v1(40.08,105.71) v1(85.64,48.98) v2(39.95,107.46) v2(40.44,107.03) v2(40.86,106.56) v2(41.37,106.05) v2(53.14,55.64) v2(53.14,55.01) v2(55.37,54.93) v2(58.73,55.64) v2(58.73,55.01) v2(61.39,55.01) v2(62.18,79.39) v2(63.96,54.98) v2(65.02,79.34) v2(67.74,79.52) v2(89.17,84.72) v3(63.3,102.33) v3(63.93,101.64) v3(64.19,102.48) v3(64.57,101.01) v3(64.8,101.85) v3(65.2,100.37) v3(65.43,101.24) v3(66.04,100.6) v3(68.35,53.41) v3(69.29,53.41) v3(70.23,53.41) v3(71.17,53.41) v3(75.36,53.1) v3(76.66,53.13) v3(77.86,53.14) v3(101.37,65) v3(101.4,64.1) v3(101.4,63.24)
+1P05V_GPU: length 161.1
  TOP w0.381: 97.03,140.55 97.03,139.03 95.8,137.8 95.8,136.45 95.38,136.03 94.84,136.03 93.74,134.94 90.02,134.94 89.43,134.36 88.8,134.36 87.78,133.34 87.78,131.61 88.28,131.11 L7204.1
  TOP w0.508: L7201.1 v2(82.89,151.78)
  IN1 w0.102: 95.3,149.9 95.68,149.9 ; 95.89,144.07 95.89,143.74 ; 95.9,145.69 95.9,145.34 ; 92.9,145.89 93.37,145.89 ; 95.1,149.67 95.1,149.29 ; 95.89,149.67 95.89,149.29 ; 92.7,144.04 92.7,143.7 ; 94.89,149.9 94.49,149.9 ; 96.11,149.9 96.52,149.9 ; 92.72,145.66 92.72,145.34 ; 93.74,143.48 95.66,143.48 ; 93.5,146.46 93.5,146.07 ; 96.11,145.92 96.55,145.92
  IN1 w0.381: v2(131.23,184.69) 131.3,184.76 145.12,184.76 146.7,183.17 148.72,183.17 149.91,184.37 155.18,184.37 158.59,180.97 158.59,160.79 158.04,160.24 v2(157.53,160.24) ; v2(92.13,164.48) 94.87,167.22 94.87,169.14 95.75,170.01 95.75,173.39 96.9,174.54 99.24,174.54 100.84,176.14 100.84,177.94 101.4,178.5 101.4,181.96 103.3,183.86 103.3,184.37 103.69,184.76 116.67,184.76 v2(117.04,184.38)
  IN2 w0.508: v2(131.23,184.69) 131.22,184.7 117.36,184.7 v2(117.04,184.38)
  BOTTOM w0.381: R5701.1 157.6,131.78 158.67,132.85 158.67,159.03 157.53,160.16 v2(157.53,160.24)
  vias: v1(97.38,142.36) v2(91.11,163.08) v2(91.54,163.62) v2(92.13,163.84) v2(92.13,163.08) v6(91.11,162.45) v6(92.13,162.45) v6(96.29,147.89) v6(96.3,143.1) v6(97.1,149.5) v6(97.1,143.9) v6(97.1,143.1) v6(97.1,141.5) v6(97.21,146.19) v6(97.21,145.56) v6(97.89,143.09) v6(97.88,141.49) v6(97.99,147.89) v6(97.97,143.91)
+1P05V_GPU_DISCH_A: length 6.4
  BOTTOM w0.203: R5701.2 156.77,130.39 156.9,130.27 156.9,129.76 157.04,129.62 158.15,129.62 158.55,130.01 v1(158.55,131.54)
  BOTTOM w0.508: Q5701.3 156.26,131.03 R5701.2
+2P5VPP: length 9.1
  BOTTOM w0.305: CON1601.259 98.13,75.68 97.84,75.39 97.63,75.61 CON1601.257
  BOTTOM w0.508: 97.84,75.39 97.84,72.94 98.7,72.08 v2(100.1,72.08)
  vias: v2(101.81,69.57) v2(101.76,68.95)
+A/D_DOCK_IN: length 273.1
  TOP w0.508: C8800.1 11.3,111.35 11.48,111.35 14.15,108.68 15.55,108.68 16.05,108.17 ; R8805.2 216.21,30.75 v2(216.51,31.06) ; 22.16,107.64 D8801.1 23.55,106.83 23.79,106.6 24.95,106.6 27.92,103.63 27.92,103.02 v1(28.06,102.88) 28.31,102.63 v2(28.31,98.48)
  IN1 w0.508: v2(216.51,31.06) 216.18,30.72 216.18,28.82 215.2,27.84 213.37,27.84 211.34,29.86 v2(210.64,29.86)
  IN3 w0.508: v2(94.72,47.6) 94.72,47.37 94.33,46.99 75.89,46.99 74.01,48.86 66.07,48.86 65.67,48.47 56.02,48.47 54.96,47.41 51.63,47.41 49.65,49.39 43.93,49.39 37.92,55.39 37.92,56.43 35.43,58.92 35.43,61.29 35.04,61.68 35.04,62.99 32.73,65.3 32.58,65.3 31.45,66.43 31.45,68.79 29.29,70.95 29.29,75.49 29.77,75.96 29.77,94.22 28.18,95.81 28.18,98.35 v2(28.31,98.48) ; v2(210.64,29.86) 209.71,28.93 204.15,28.93 204.04,28.82 201.63,28.82 200.33,27.52 196.59,27.52 196.24,27.17 178.36,27.17 178.29,27.09 166.65,27.09 165.72,28.02 155.99,28.02 153.95,30.06 144.66,30.06 144.18,30.54 113.03,30.54 111.66,31.91 110.34,33.23 98.49,33.23 v2(97.88,33.84)
  BOTTOM w0.508: v2(97.88,33.84) 98.27,34.23 98.27,44.04 v2(94.72,47.6)
+A/D_DOCK_IN_CON:
  vias: v1(16.08,98.24) v3(11.9,93.95) v3(11.9,93.06) v3(11.9,92.17) v3(11.9,91.28) v3(12.78,93.95) v3(12.78,93.06) v3(12.78,92.17) v3(12.78,91.28)
+A/D_DOCK_IN_Q: length 347.6
  TOP w0.457: v2(245.8,14.44) 245.62,14.27 R8802.2 R8814.1
  TOP w0.508: C8801.2 10.31,115.2 10.31,115.64 10.34,115.66 ; 13.22,118 15.44,118 16.67,119.23 20.24,119.23 22.2,117.26 v1(22.2,114.62) 22.2,113.97 25.67,110.5 27.09,110.5 28.55,109.04 28.55,105.94 30.01,104.48 30.01,96.79 v2(30.01,96.78) ; v2(221.9,34.5) 222.17,34.22 R8804.2
  IN1 w0.508: v2(231.45,23.59) 231.7,23.59 232.2,24.09 232.2,24.62 232.7,25.13 235.11,25.13 237.03,23.2 245.55,23.2 248.21,20.54 249.35,20.54 250.37,19.52 250.37,16.35 249.25,15.23 246.31,15.23 245.8,14.72 v2(245.8,14.44) ; v2(221.9,34.5) 221.9,34.23 219.79,32.13 219.79,30.66 215.74,26.61 212.08,26.61 211.11,27.57 210.4,27.57 209.04,28.92 208.25,28.92 207.65,28.32 206.41,28.32 205.61,27.53 205.41,27.53 204.79,26.91 204.22,26.91 200.03,22.72 178.02,22.72 177.75,22.99 155.44,22.99 152.39,26.03 145.69,26.03 145.1,25.44 110.77,25.44 109.11,27.11 107.18,27.11 102.04,32.25 96.64,32.25 v2(95.05,33.84)
  IN3 w0.14: 38.14,61.68 38.14,61.68 38.14,62.97 37.88,63.23 37.38,63.23
  IN3 w0.203: 37.44,60.38 37.44,59.03
  IN3 w0.305: 37.9,60.72 38.5,60.13 38.5,58.69
  IN3 w0.368: 37.38,63.23 37.18,63.03 37.18,61.76 37.5,61.44
  IN3 w0.508: v2(92.82,47.6) 92.82,47.85 91.63,49.04 76.02,49.04 74.98,50.08 65.3,50.08 64.91,49.69 52.15,49.69 50.13,51.71 50.13,52.13 48.57,53.69 41.56,53.69 39.33,55.92 39.33,56.81 38.69,57.46 ; v2(221.9,34.5) 222.52,33.88 223.06,33.88 225.35,31.59 226.87,31.59 227.89,30.57 227.89,29.56 230.3,27.14 231.45,27.14 232.33,26.26 232.33,24.22 231.7,23.59 v2(231.45,23.59) ; 37.38,63.23 37.38,63.56 35.65,65.28 35.01,65.28 33.91,66.39 33.91,68.24 34.6,68.93 34.6,75.79 31.29,79.09 31.29,94.71 29.9,96.11 29.9,96.67 v2(30.01,96.78) ; 37.9,61.33 37.9,60.72
  BOTTOM w0.508: v2(92.82,47.6) 92.82,46.33 95.2,43.95 95.2,33.99 v2(95.05,33.84)
+A/D_DOCK_IN_Q_Q:
  vias: v1(3.15,118.48)
+AC_BAT_SYS: length 1365.6
  TOP w0.508: 138.79,66.08 138.79,68.19 137.68,69.3 133.63,69.3 133.62,69.28
  IN1 w1.27: 8.46,184.92 3.46,184.92 1.83,183.29 1.83,168.67
  IN1 w1.524: 3.86,163.84 5.05,162.65 5.05,144.32 5.05,144.01 5.05,143.5 1.9,140.35 1.9,112.05 2.08,111.88
  IN1 w1.905: 118.37,22.49 90.63,22.49 86.31,26.81 64.24,26.81 63.24,27.82 41.78,27.82 ; 213.29,20.39 149.8,20.39 147.7,22.49 127.43,22.49 ; 2.46,107.28 4.12,105.63 4.12,98.01 2.21,96.11 2.21,64.78 ; 24.69,39.64 24.69,36.97 25.55,36.11 25.55,34.13 25.02,33.6 25.02,31.23 28.47,27.78 33.7,27.78 33.74,27.82
  IN1 w2.032: 82.63,161.72 81.97,162.38 ; 81.97,162.38 81.61,162.74 81.61,172.05 79.96,173.7 ; 81.97,162.38 81.97,162.4
  IN2 w1.27: 60.34,170.03 58.98,170.03 58.84,169.89 54.7,169.89 54.56,170.03 52.56,170.03 51.37,171.22 51.37,172.93 50.47,173.83 48.44,173.83 47.42,174.85 47.42,175.78 46.28,176.93 41.51,176.93 40.69,176.11 ; 1.83,168.47 1.83,183.29 3.46,184.92 7.83,184.92
  IN2 w1.524: 1.9,114.14 1.9,140.35 5.05,143.5 5.05,162.65 3.86,163.84
  IN2 w1.905: 211,20.39 149.8,20.39 147.7,22.49 127.43,22.49 ; 24.69,39.11 24.69,36.92 25.58,36.03 25.58,34.21 25.04,33.67 25.04,31.31 28.78,27.58 32.43,27.58 ; 41.78,27.82 63.21,27.82 64.24,26.79 86.3,26.79 86.33,26.79 90.63,22.49 117.35,22.49 ; 2.46,107.28 4.12,105.63 4.12,98.01 2.21,96.11 2.21,64.73
  IN2 w3.048: 215.65,19.02 216.41,18.25 218.87,18.25 221.78,15.35 237.15,15.35 238.79,16.98 243.26,16.98
  IN3 w1.27: 40.13,175.86 41.2,176.93 46.28,176.93 47.42,175.79 47.42,174.85 48.44,173.83 50.47,173.83 51.36,172.94 51.36,171.19 52.51,170.04 54.53,170.04 54.66,169.92 58.98,169.92 ; 1.85,168.75 1.83,168.77 1.83,183.29 3.46,184.92 6.61,184.92 ; 30.53,183.86 44.65,183.86
  IN3 w1.524: 1.9,114.33 1.9,140.35 5.05,143.5 5.05,162.65 4.24,163.46
  IN3 w1.905: 41.75,27.8 41.78,27.82 63.25,27.82 64.26,26.81 86.31,26.81 90.63,22.49 118.95,22.49 ; 2.21,64.58 2.21,96.11 4.12,98.01 4.12,105.63 2.46,107.28 2.46,108.22 ; 32.43,27.58 28.78,27.58 25.04,31.31 25.04,33.67 25.58,34.21 25.58,36.03 24.69,36.92 24.69,39.11 ; 127.43,22.49 147.7,22.49 149.8,20.39 212.5,20.39 212.52,20.41
  IN3 w3.048: 216.31,18.25 218.87,18.25 221.74,15.38 237.23,15.38 238.83,16.98 243.59,16.98
  IN4 w0.508: v2(218.4,62.76) 220.75,65.11 220.75,69.87 220.1,70.52 v2(217.76,70.52)
  IN4 w1.27: v3(2.46,167.65) 2.46,168.04 1.83,168.67 1.83,183.29 3.46,184.92 8.21,184.92
  IN4 w1.524: 3.14,164.58 4.24,163.47 4.24,163.46 5.06,162.65 5.06,143.51 1.9,140.35 1.9,113.55
  IN4 w1.905: 119.08,22.49 90.63,22.49 86.29,26.83 64.22,26.83 63.24,27.82 41.37,27.82 ; 213.37,20.39 149.8,20.39 147.7,22.49 127.43,22.49 ; 2.21,64.78 2.21,96.11 4.12,98.01 4.12,105.63 2.46,107.28 2.46,108.22 ; 33.77,27.82 28.44,27.82 25.07,31.18 25.07,33.67 25.48,34.08 25.48,36.26 24.71,37.03 24.71,39.08 24.82,39.18
  BOTTOM w5.08: 124.82,36.29 124.82,30.14
  vias: v2(9.48,184.91) v2(54.12,185.27) v2(54.75,185.27) v2(85.92,176.93) v2(86.53,176.93) v2(87.16,176.93) v2(88.39,177) v2(243.96,19.14) v2(244.17,17.12) v3(1.58,167.65) v3(1.58,166.77) v3(1.58,165.88) v3(1.59,110.97) v3(1.59,110.08) v3(1.59,109.19) v3(1.59,108.33) v3(1.59,107.46) v3(1.78,63.03) v3(1.8,62.04) v3(1.78,61.13) v3(1.8,60.14) v3(2.46,166.77) v3(2.46,165.88) v3(2.46,110.96) v3(2.48,110.08) v3(2.48,109.19) v3(2.48,108.33) v3(2.48,107.46) v3(23.29,41.49) v3(23.27,40.63) v3(27.16,183.86) v3(27.88,175.38) v3(27.88,174.51) v3(28.13,183.86) v3(28.75,175.38) v3(28.75,174.51) v3(29.08,183.87) v3(32.69,26.3) v3(33.58,26.3) v3(34.47,26.3) v3(35.36,26.3) v3(36.25,26.3) v3(37.08,175.38) v3(37.97,175.38) v3(38.86,175.38) v3(39.75,175.38) v3(60.77,170.34) v3(61.66,170.34) v3(62.55,170.34) v3(63.42,170.53) v3(74.85,185.01) v3(75.74,185.01) v3(76.63,185.01) v3(77.65,185.01) v3(78.51,176.12) v3(79.4,176.12) v3(80.28,176.12) v3(82.47,161.18) v3(82.47,160.29) v3(120.7,21.94) v3(121.62,22.81) v3(121.59,21.94) v3(122.51,22.81) v3(122.48,21.94) v3(123.34,21.94) v3(123.37,22.81) v3(129.39,69.12) v3(129.4,68.21) v3(132.36,69.63) v3(132.79,68.87) v3(133.24,69.63) v3(133.68,68.87) v3(134.13,69.63) v3(213.38,21.29) v3(213.38,20.4) v3(213.38,19.51) v3(214.27,21.29) v3(214.27,20.4) v3(214.27,19.51) v3(215.16,21.29) v3(215.16,20.4) v3(215.16,19.51) v3(216.05,21.29) v3(216.05,20.4) v3(216.05,19.51) v3(243.48,18.46) v3(243.51,17.54) v3(243.51,16.6) v3(246.43,17.62) v3(246.43,16.73) v3(247.32,17.62) v3(247.32,16.73) v3(248.21,17.62) v3(248.21,16.73) v3(249.1,17.62) v3(249.1,16.73)
+AC_BAT_SYS_FBVDDQ: length 30.2
  TOP w0.254: R8912.2 181.47,88.83 180.67,89.63 179.98,89.63 179.4,90.21 179,90.21 178.45,90.77 177.92,90.77 177.17,91.52 176.55,91.52 176.43,91.64 175.62,91.64 173.03,89.05 v2(173.03,87.72)
  TOP w2.032: 133.13,72.22 137.33,72.22
  IN2 w2.032: 153.52,89.18 151.81,89.18
  IN4 w2.286: 145.53,89.02 145.53,86.45 144.83,85.75 144.83,81.42 142.22,78.82 141.74,78.82
  vias: v1(139.67,72.71) v2(171.12,87.72) v2(171.76,87.72) v2(172.39,87.72) v3(140.77,77.88) v3(141.66,77.88) v3(145.42,90.19) v3(146.31,90.19) v3(158.32,88.6) v3(158.36,87.72)
+AC_BAT_SYS_NVVDD: length 35.9
  TOP w0.381: v3(150.67,99.03) 150.67,97.88 149.15,96.36 149.15,90.77 150.56,89.36 156.39,89.36 157.66,88.09 157.66,86.72 157.67,86.72 157.67,86.11 158.04,85.75 v2(159.29,85.75)
  IN4 w2.032: 149.67,98.98 146.69,98.98 144.45,96.74 144.45,95.74 142.52,93.81 142.52,90.75
  BOTTOM w0.381: R8741.2 158.81,85.75 v2(159.29,85.75)
  vias: v1(134.14,82.36) v1(151.71,98.83) v3(135.69,78.71) v3(135.69,77.82) v3(135.69,76.93) v3(136.58,78.71) v3(136.58,77.82) v3(136.58,76.93) v3(151.31,99.79) v3(152.2,99.79)
+BAT: length 304.7
  TOP w0.381: D8801.2 25.92,106.57 v1(25.96,106.57) 26.85,105.68 26.85,105.51 28.86,103.5 v2(28.86,97.96)
  TOP w0.508: v2(219.89,25.61) 219.89,25.12 218.62,23.84 205.55,23.84 204.57,24.82 v2(204.57,25.52)
  IN1 w0.508: v2(252.21,19.23) 251.54,19.91 251,19.91 249.73,21.18 248.46,21.18 247.57,22.06 v2(247.57,24.1) ; v2(199.24,25.52) 197.68,23.96 178.51,23.96 178.26,24.21 155.94,24.21 152.7,27.45 135.34,27.45 134.69,26.8 111.87,26.8 105.13,33.54 99.53,33.54 98.63,34.44 94.79,34.44 94.39,34.04 v2(94.39,33.84)
  IN2 w0.508: v2(247.57,24.1) 247.57,24.81 246.7,25.68 237.07,25.68 236.39,24.99 230.74,24.99 228.04,22.29 224.53,22.29 223.74,23.08 221.22,23.08 219.89,24.41 v2(219.89,25.61)
  IN3 w0.114: 36.84,62.85 36.84,61.6
  IN3 w0.254: 35.95,61.03 35.95,59.69 ; 37,61.08 37,60.11
  IN3 w0.394: 35.82,62.02 35.82,61.7 36.07,61.45
  IN3 w0.508: 36.7,59.55 36.7,58.56 38.55,56.7 38.55,55.77 41.27,53.05 47.23,53.05 49.13,51.15 49.75,51.15 51.82,49.08 65.42,49.08 65.81,49.47 74.56,49.47 75.7,48.33 91.48,48.33 92.07,47.74 v2(92.07,47.6) ; 36.04,63.13 36.04,63.96 35.47,64.53 34.9,64.53 33.3,66.13 33.3,70.81 33.96,71.47 33.96,75.53 30.66,78.83 30.66,94.33 28.79,96.2 28.79,97.89 v2(28.86,97.96) ; v2(204.57,25.52) v2(199.24,25.52)
  BOTTOM w0.508: v2(92.07,47.6) 92.07,46.22 94.59,43.7 94.59,34.64 94.39,34.44 v2(94.39,33.84)
+BAT_CON:
  vias: v3(231.95,11.4) v3(232.84,11.4) v3(236.02,11.4) v3(236.91,11.4) v3(258.62,14.06) v3(258.6,13.1) v3(258.6,12.21) v3(258.62,11.27) v3(259.51,13.1) v3(259.51,12.21) v3(259.51,11.27) v3(259.89,18.76) v3(259.89,17.79) v3(259.89,16.91) v3(259.89,15.97) v3(260.78,18.76) v3(260.78,17.79) v3(260.78,16.91) v3(260.78,15.97)
+BAT_R:
  vias: v1(242.27,11.17)
+CPU_VCC_OBS_AB: length 6.7
  TOP w0.508: v2(6.02,130.85) 5.1,130.85 4.6,130.35 R4401.2 2.39,130.35 v1(2.29,130.24)
  BOTTOM w0.203: XDP4400.44 v2(6.02,130.85)
+CPU_VCC_OBS_CD: length 3.9
  TOP w0.508: v2(7.34,130.57) 7.44,130.48 R4400.2 9.26,130.48 v1(9.37,130.37)
  BOTTOM w0.305: v2(7.34,130.57) 7.52,130.57 7.8,130.85 XDP4400.43
+FBVDDQ: length 736.3
  TOP w0.102: 115.02,181.45 115.43,181.46 ; 125.74,133.92 126.16,133.88 ; 128.53,171.66 128.56,171.25 ; 114.54,109.69 114.63,109.69 ; 111.81,182.66 112.15,182.67 ; 127.9,132.09 127.91,131.68 ; 125.51,128.08 125.49,127.66 ; 126.29,136.09 126.29,135.7 ; 125.28,137.88 125.27,137.88 124.9,137.9 ; 122.29,134.11 122.32,134.5 ; 124.1,131.52 124.52,131.5 ; 126.27,139.33 126.33,138.87 ; 153.04,165.54 153.5,165.57 ; 107.84,182.28 108.21,182.29 ; 122.55,133.91 122.87,133.9 ; 126.31,128.88 126.31,128.46 ; 141.63,166.96 141.63,166.57 ; 149.91,164.76 150.25,164.75 ; 126.29,137.63 126.29,137.3 ; 123.29,159.48 123.72,159.48 ; 105.42,172.66 105.84,172.69 ; 140.06,167.22 139.75,166.96 ; 127.15,134.41 127.2,134.54 ; 126.31,134.47 126.31,134.11 ; 126.92,137.84 127.29,137.47 ; 151.43,159.06 151.92,159.09 ; 114.78,111.09 114.78,110.74 ; 125.74,129.11 126.12,129.08 ; 114.22,109.69 114.22,109.7 114.54,109.7 ; 127.74,173.29 127.76,172.87 ; 129.34,170.86 129.35,170.39 ; 127.95,171.1 128.34,171.08 ; 122.49,129.88 122.92,129.91 ; 143.95,170.79 144.02,170.37 ; 105.36,182.27 105.85,182.28 ; 145.8,171.79 146.2,171.79 ; 126.31,132.06 126.3,131.7 ; 126.54,158.72 127.05,158.72 ; 125.52,134.48 125.52,134.09 ; 120.52,179.65 120.53,179.25 ; 114.02,181.19 114.04,180.83 ; 150.41,166.09 150.48,165.67 ; 113.39,182.3 113.86,182.29 ; 124.69,137.69 124.69,137.28 ; 126.3,131.3 126.3,131.03 126.3,130.88 ; 128.79,171.87 129.19,171.87 ; 114.78,181.23 114.84,180.8 ; 108.59,179.09 108.98,179.06 ; 130.13,111.61 130.13,111.96 ; 105.36,170.27 105.76,170.28 ; 126.91,171.67 126.91,171.21 ; 123.1,138.46 123.12,138.07 ; 124.91,131.51 125.35,131.5 ; 123.29,158.69 123.67,158.69 ; 125.5,138.47 125.5,138.09 ; 125.5,132.07 125.51,131.67 ; 125.73,131.5 126.08,131.5 ; 125.49,129.67 125.5,129.3 ; 121.49,179.83 121.95,179.88 ; 141.06,164.7 141.54,164.73 ; 120.53,181.19 120.51,180.84 ; 125.48,137.56 125.48,137.28 ; 105.23,182.85 105.19,182.42 ; 153.08,164.77 153.47,164.77 ; 142.34,170.81 142.34,170.45 ; 125.67,137.87 126.08,137.87 ; 125.5,139.29 125.5,138.88 ; 119.74,181.25 119.74,180.85 ; 124.71,129.67 124.7,129.41 ; 128.75,171.07 129.14,171.08 ; 126.34,158.9 126.29,159.27 ; 119.93,180.68 120.32,180.68 ; 115.02,182.26 115.39,182.28 ; 114.26,179.87 114.65,179.87 ; 123.86,138.57 123.92,138.13 ; 119.74,181.99 119.75,181.62 ; 144.2,170.99 144.6,171.04 ; 114.81,182.84 114.84,182.45 ; 122.32,133.65 122.29,133.35 ; 127.97,173.5 128.35,173.49 ; 112.64,179.05 112.98,179.05 ; 125.72,129.9 126.06,129.91 ; 124.9,138.7 125.42,138.67 ; 121.63,135.56 122.01,135.48 ; 125.5,136.03 125.5,135.73 ; 114.22,111.35 114.58,111.35 ; 124.68,132.1 124.71,131.64 ; 119.14,181.41 119.58,181.44
  TOP w0.127: 105.41,173.47 105.88,173.47 ; 144.82,166.91 144.84,166.53 ; 144.3,167.15 144.66,167.14 ; 149.89,159.14 150.25,159.16 ; 105.44,171.88 105.87,171.9
  TOP w0.203: v6(120.9,181.85) 120.5,182.26 118.97,182.26 118.67,182.56 118.67,182.72 C7610.1
  TOP w0.254: v6(138.76,108.19) 138.74,108.19 138.64,108.29 137.94,108.29 R7917.1 ; R7900.2 116.09,99.6 v1(115.83,99.86) ; v6(142.02,119.37) 142.2,119.56 142.2,120.85 v6(142.44,121.08) ; v6(154.51,119.62) 154.61,119.62 ; v2(101.65,176.44) 101.83,176.44 R7617.1
  TOP w0.305: C7816.1 152.53,146.84 v6(152.46,146.78) ; C7930.1 117.96,104.1 v6(117.6,103.75) ; C7806.1 v6(141.21,153.11) ; v6(127.23,104.65) 127.85,105.28 C7918.1 ; v6(150.44,149.82) 150.44,149.21 C7811.1 ; v6(150.81,145.99) 150.88,146.06 150.88,146.93 C7818.1 ; C7617.1 115.22,173.06 v6(115.22,173.07) ; v2(117.17,165.29) 115.8,165.29 115.37,164.86 R7100.2 R7108.2 ; C7726.1 149.99,156.36 v6(149.99,156.37) ; R7116.2 v6(128.65,119) ; v6(135.36,99.76) 135.64,99.76 135.69,99.71 C7908.1 ; C7624.1 111.66,179.84 v6(112.04,179.45) ; v6(145.26,153.15) 145.69,153.58 R7715.1 ; v6(119.36,180.26) 118.73,180.89 118.73,181.65 C7616.1 ; v2(153.19,168.9) 152.93,169.16 C7712.1 ; C7812.1 v6(152.53,149.87) ; C7913.1 v6(134.49,109.37) ; C7810.1 v6(139.67,151.3) ; C7609.1 111.73,181.31 v6(111.89,181.47)
  TOP w0.381: v6(125.75,179.54) 125.35,179.54 125.07,179.82 C7632.1 ; v6(150.77,180.2) 150.7,180.28 C7707.1 ; v2(155.93,176.92) 155.93,176.8 C7710.1 ; v6(150.85,153.16) 150.85,153.16 C7813.1 ; C7920.1 135.66,106.54 v6(136.03,106.16) ; 108.67,118.58 v6(107.39,118.58)
  TOP w0.406: v6(145.12,169.7) 145.11,169.69 C7711.1 ; v6(120.62,102) 120.02,102 C7931.1 ; C7907.1 v6(132,100.47) ; R7710.2 149.32,169.6 v6(149.15,169.77) ; C7917.1 v2(125.96,100.98) ; C7926.1 117.38,101.92 v6(116.79,101.33) ; v6(149.07,156.2) 148.82,156.2 148.49,155.87 R7817.1 ; v6(113.56,104.51) 114.1,103.98 C7923.1 ; v6(146.02,143.55) 146.27,143.31 C7830.1 ; C7835.1 154.79,128.23 v6(154.36,128.67) ; C7914.1 143.3,128.37 v6(143.24,128.31) ; v6(152.4,122.75) C7825.1 ; C7832.1 v6(149.96,124.14) ; C7929.1 141.16,142.5 v6(141.26,142.61) ; C7922.1 v6(123.62,99.61) ; v6(145.14,128.26) 145.86,128.26 C7831.1 ; R7123.2 124.59,118.96 v6(124.99,119.37) ; R7111.2 129.97,154.83 129.65,155.14 v6(129.65,155.15) ; v2(132.74,125.69) 132.76,125.69 133.14,125.31 R7120.2 ; C7924.1 120.4,103.85 v6(120.68,103.57) ; v6(124.01,104.49) 124.57,103.93 R7910.2 ; C7911.1 133.99,99.76 v6(133.96,99.79) ; v6(128.91,100.58) 128.91,100.35 C7912.1 ; C7725.1 v2(153.14,168.27) ; v6(122.68,179.75) 123.06,179.75 123.22,179.9 C7612.1 ; C7925.1 122.25,109.99 v6(122.38,110.12) ; v6(115.19,105.32) 114.86,105.64 C7927.1 ; v6(116.79,100.47) 116.8,100.46 R7900.2 ; C7919.1 126.06,99.91 v2(125.76,99.61) ; C7713.1 v6(154.56,174.03) ; v6(138.66,102.57) 139.03,102.94 C7909.1 ; v6(153.98,169.81) 154.31,169.48 C7715.1 C7731.1 154.13,168.11 v6(154.13,167.55) ; C7708.1 v6(152.37,173.81) ; C7935.1 v6(125.17,99.61) ; R7600.2 v6(125.12,183)
  TOP w0.432: R7112.2 134.07,122.57 v2(134.14,122.5)
  TOP w0.457: v2(145.59,116.65) 145.59,116.63 145.54,116.58 R7815.1 ; v6(151.58,124.01) 151.13,123.55 C7834.1 ; C7823.1 v2(153.01,116.65) ; v6(143.64,117.79) 143.74,117.69 C7826.1 ; v6(149.66,116.65) 149.71,116.6 C7824.1 ; C7827.1 v6(151.36,116.65)
  TOP w0.508: 154.61,119.62 154.98,119.62 C7837.1 ; 110.04,117.36 C7574.1 109.89,117.36 108.67,118.58 ; 132.61,127.32 132.74,127.18 v2(132.74,125.69) ; C7934.1 v6(119.94,100.22) ; v6(150.44,121.15) 149.96,121.63 C7833.1
  IN1 w0.102: 155.18,173.2 155.18,172.78 ; 122.78,109.48 122.78,109.05 ; 153.46,165.55 153.04,165.55 ; 152.56,170.99 152.15,170.99 ; 151.25,118.74 151.25,118.34 ; 149.91,164.75 150.24,164.75 ; 115.42,182.27 115.05,182.25 ; 153.8,172.61 154.17,172.61 ; 153.56,170.43 153.56,170.81 ; 142.68,118.95 143.03,118.95 ; 147.48,118.16 147.89,118.16 ; 153.08,164.76 153.48,164.76 ; 147.61,116.82 147.62,116.5 ; 152.75,170.77 152.75,170.42 152.81,170.36 ; 128.71,112.15 129.12,112.16 ; 152.22,171.8 152.52,171.8 ; 152.99,171 153.4,171 153.46,171.07 ; 105.22,182.5 105.2,182.75 ; 153.69,146.18 153.63,145.78 ; 127.9,111.34 128.23,111.34 ; 114.84,182.48 114.8,182.86 ; 115.4,181.46 115.04,181.46 ; 114.83,180.83 114.79,181.21 ; 128.72,111.35 129.13,111.37 ; 150.42,166.08 150.45,165.72 ; 147.53,163.95 147.85,163.95 ; 152.32,145.55 152.68,145.55 ; 149.61,146.17 149.65,145.72 ; 127.89,112.15 128.27,112.15 ; 154.57,170.21 154.96,170.21 ; 153.06,146.36 153.43,146.38 ; 146.64,118.96 147.04,118.96 ; 152.87,166.19 152.84,165.73 ; 152.77,171.58 152.77,171.19 152.81,171.16 ; 112.13,182.66 111.71,182.68 ; 121.48,133.65 121.48,133.33 ; 113.03,179.06 112.62,179.06 ; 130.88,103.96 130.91,103.53 ; 151.38,167.89 151.26,167.43 ; 149.67,117.97 149.67,117.58 ; 105.78,182.27 105.44,182.25 ; 114.02,180.79 114.03,181.2 ; 150.43,164.57 150.46,164.08 ; 150.03,128.58 150.34,128.48 ; 113.18,179.62 113.21,179.24 ; 113.82,182.31 113.4,182.29 ; 152.05,118.75 152.04,118.33 ; 127.86,110.54 128.26,110.54 ; 153.11,118.97 153.47,119 ; 151.16,172.82 151.16,173.21 ; 128.78,110.55 129.18,110.55 ; 111.73,177.08 112.12,177.06 ; 130.31,104.17 130.74,104.14 ; 152.85,146.14 152.86,145.75 ; 154.37,173.18 154.37,172.81 ; 115.34,177.49 115.09,177.46 ; 154.36,170.44 154.36,170.8 ; 142.69,118.16 143.08,118.15 ; 114.62,179.87 114.25,179.85 ; 150.67,166.32 151.09,166.33 ; 108.98,179.05 108.61,179.1 ; 152.25,144.76 152.72,144.75 ; 149.91,119.73 150.29,119.73 ; 108.2,182.28 107.84,182.27 ; 151.23,166.16 151.24,165.7 ; 150.59,173.41 150.99,173.41 ; 144.28,118.96 144.67,118.96 ; 130.35,100.98 130.84,101.03 ; 144.22,117.34 144.62,117.34 ; 148.04,118.74 148.05,118.39 ; 147.25,118.73 147.24,118.39 ; 151.44,118.97 151.94,118.97
  IN1 w0.127: 149.67,143.75 149.68,143.39
  IN1 w0.254: v6(127.13,110.99) 127.56,110.55 127.56,109.85 127.22,109.5 ; v6(127.22,109.52) 127.22,109.5 ; 127.22,109.5 127.22,107.97 127.23,107.96 v6(127.23,107.76) ; v6(120.82,109.31) 121.63,110.12 v6(122.38,110.12) 121.92,110.59 121.92,111.26 v6(122.4,111.74)
  IN1 w0.508: 157.3,125.87 157.3,121.4 156.41,120.51
  IN1 w0.889: 123.37,135.09 127.23,135.09
  IN1 w1.27: 155.55,126.18 155.55,123.74
  IN2 w0.102: 146.66,118.97 147.03,118.98 ; 101.49,154.98 101.49,154.98 101.49,155.28 ; 119.74,182.02 119.75,180.81 ; 126.94,182.86 126.95,182.54 ; 123.09,138.46 123.09,138.08 ; 112.64,179.07 113,179.05 ; 123.57,102.69 123.58,102.7 123.58,103.12 ; 142.35,170.83 142.35,170.41 ; 114.76,100.72 114.78,100.24 ; 113.22,174.85 113.2,174.5 ; 153.75,178.22 154.28,178.15 ; 142.4,127.55 142.45,127.13 ; 123.04,103.32 123.39,103.32 123.39,103.31 ; 123.11,140.89 123.09,140.53 ; 152.86,166.13 152.83,165.7 ; 126.36,171.88 126.7,171.88 ; 122.52,137.91 122.95,137.91 ; 149.03,171.74 149.4,171.78 ; 129.74,176.3 130.07,176.24 ; 139.78,167 140.04,167.2 ; 126.37,172.68 126.72,172.68 ; 143.22,127.51 143.21,127.13 ; 101.75,154.7 102.13,154.7 ; 151.48,118.94 151.84,118.95 ; 150.67,166.34 151.08,166.31 ; 115.05,181.46 115.4,181.46 ; 126.3,159.26 126.33,158.88 ; 152.13,179.04 152.55,179.03 ; 126.89,179.67 126.92,179.27 ; 112.6,175.1 113.01,175.13 ; 123.02,102.52 123.39,102.52 ; 114.26,172.68 114.56,172.67 ; 126.54,158.69 126.89,158.7 ; 148.8,120.31 148.83,119.93 ; 153.76,177.42 154.08,177.42 ; 116.36,107.07 116.4,106.71 ; 122.3,145.36 122.3,145.74 ; 123.9,145.66 123.9,145.31 ; 149.67,143.76 149.67,143.39 ; 114.26,171.87 114.6,171.87 ; 151.51,125.37 151.94,125.38 ; 123,100.9 123.44,100.9 ; 123.81,103.3 124.2,103.3 ; 147.62,116.8 147.63,116.49 ; 99.9,158.5 99.9,158.07 ; 153.04,152.75 153.54,152.76 ; 150.02,128.59 150.44,128.45 ; 150.57,173.4 150.99,173.4 ; 146.7,158.36 147,158.36 ; 121.57,179.85 121.94,179.87 ; 152.77,179.56 152.75,179.23 ; 128.63,145.79 128.73,145.41 ; 145.6,160.55 145.64,160.13 ; 153.56,170.78 153.54,170.39 ; 114,171.65 114,171.24 ; 152.25,143.97 152.64,143.98 ; 149.59,152.47 149.61,152.15 ; 153.07,118.96 153.46,118.99 ; 126.12,178.06 126.13,177.68 ; 114.23,100.9 114.59,100.9 ; 151.15,177.95 151.17,177.62 ; 125.5,146.91 125.5,147.26 ; 127.97,171.09 128.31,171.08 ; 128.55,171.64 128.54,171.28 ; 143.99,170.4 143.99,170.8 ; 141.47,125.37 141.4,125.38 141.07,125.4 ; 152.85,146.12 152.88,145.74 ; 120.74,176.71 121.22,176.71 ; 122.77,103.85 122.77,103.53 ; 154.32,179.59 154.36,179.28 ; 126.95,173.24 126.96,172.92 ; 114.25,179.86 114.66,179.86 ; 147.22,145.34 147.22,144.96 ; 126.28,136.09 126.3,135.7 ; 155.19,173.22 155.19,172.78 ; 101.71,157.89 102.1,157.89 ; 123.11,145.69 123.11,145.31 ; 147.43,164.74 147.79,164.76 ; 149.07,125.37 149.43,125.38 ; 151.95,177.96 151.98,177.58 ; 151.44,152.79 151.87,152.79 ; 141.64,152.6 141.64,152.21 ; 102.3,155.2 102.3,154.91 ; 152.27,145.56 152.75,145.54 ; 148.96,171.02 149.45,170.93 ; 127.1,145.66 127.1,145.31 ; 125.5,136.07 125.5,135.71 ; 153.02,159.14 153.61,159.1 ; 153.1,164.77 153.44,164.77 ; 113.27,105.58 113.61,105.64 ; 144.15,171.01 144.56,171.01 ; 115.57,100.68 115.54,100.27 ; 143.23,125.15 143.24,124.75 ; 153.07,165.54 153.47,165.56 ; 153.04,146.35 153.4,146.38 ; 126.38,180.64 126.8,180.65 ; 123.57,100.69 123.57,100.29 ; 126.96,181.22 126.96,180.84 ; 151.38,167.89 151.3,167.49 ; 151.45,127 151.9,126.95 ; 113.4,176.67 113.87,176.7 ; 114.83,174.04 114.83,173.63 ; 151.16,173.17 151.17,172.81 ; 120.53,176.45 120.53,176.07 ; 152.04,143.71 152.04,143.37 ; 125.72,147.46 126.86,147.46 ; 127.91,145.69 127.91,145.31 ; 122.87,178.77 122.47,178.8 ; 119.96,180.68 120.3,180.68 ; 128.72,183.07 129.14,183.07 ; 142.64,126.96 143.05,126.96 ; 126.13,172.13 126.13,172.48 ; 101.75,155.5 102.09,155.5 ; 121.97,104.72 121.99,104.29 ; 141.64,127.53 141.64,127.12 ; 128.77,171.07 129.13,171.07 ; 124.69,145.69 124.69,145.31 ; 120.55,182.86 120.54,182.48 ; 152.24,151.16 152.73,151.13 ; 149.81,178.21 150.17,178.21 ; 141.41,164.7 141.06,164.7 ; 122.95,152.29 122.56,152.29 ; 149.86,159.14 150.23,159.15 ; 116.59,104.08 117,104.09 ; 151.22,150.9 151.23,150.5 ; 144.02,166.92 144.02,166.54 ; 144.28,167.14 144.75,167.15 ; 151.95,179.6 151.95,179.18 ; 153.05,127.77 153.51,127.75 ; 151.45,126.16 151.86,126.22 ; 151.38,179.82 151.78,179.83 ; 114.29,174.23 114.63,174.24 ; 152.21,178.22 152.54,178.25 ; 121.74,141.9 122.15,141.9 ; 114.19,101.68 114.62,101.7 ; 144.25,126.14 144.65,126.17 ; 152.2,151.94 152.65,151.93 ; 144.83,166.9 144.83,166.49 ; 153.85,151.17 154.3,151.14 ; 121.74,142.71 122.07,142.71 ; 141.84,151.16 142.33,151.16 ; 125.5,154.49 125.53,154.12 ; 102.32,157.69 102.32,157.29 ; 120.55,179.66 120.49,179.25 ; 114.22,171.06 114.65,171.06 ; 101.49,156.07 101.49,155.69 ; 129.33,170.84 129.33,170.42 ; 149.65,117.94 149.64,117.57 ; 151.24,118.7 151.24,118.38 ; 115.58,103.88 115.59,103.52 ; 153.54,179.59 153.56,179.17 ; 115.02,104.08 115.36,104.1 ; 128.78,171.86 129.12,171.88 ; 124.7,136.08 124.7,135.72 ; 128.75,180.71 129.04,180.71 ; 141.64,166.95 141.61,166.57 ; 152.29,144.76 152.64,144.76 ; 147.25,125.94 147.25,125.56 ; 153.08,126.95 153.44,126.98 ; 149.91,119.73 150.27,119.73 ; 153.02,179.83 153.41,179.78 ; 147.49,118.16 147.85,118.18 ; 151.21,120.32 151.23,119.92 ; 121.36,104.12 121.81,104.1 ; 153.8,172.61 154.19,172.62 ; 114.82,182.84 114.82,182.48 ; 122.33,143.25 122.3,142.92 ; 111.75,182.67 112.08,182.68 ; 114.79,181.22 114.84,180.83 ; 123.9,143.27 123.9,142.92 ; 115.06,182.27 115.42,182.28 ; 151.42,143.97 151.79,143.97 ; 114.04,181.21 114.02,180.79 ; 152.21,171.81 152.59,171.8 ; 149.9,164.72 150.23,164.75 ; 149.87,125.34 150.32,125.39 ; 154.36,170.78 154.37,170.39 ; 126.34,179.86 126.73,179.86 ; 113.42,182.31 113.85,182.29 ; 122.33,141.65 122.33,141.32 ; 123.58,103.5 123.59,103.51 123.59,103.86 ; 126.35,177.46 126.72,177.45 ; 125.48,145.69 125.48,145.25 ; 117.21,106.26 117.18,105.95 ; 154.6,179.83 154.96,179.81 ; 150.43,166.08 150.47,165.7 ; 143.18,170.38 143.18,170.84 ; 113.21,179.66 113.18,179.23 ; 126.33,171.1 126.72,171.09 ; 127.75,173.27 127.76,172.9 ; 116.4,103.86 116.36,103.52 ; 116.63,106.5 116.94,106.53 ; 154.37,173.18 154.41,172.79 ; 148.03,118.74 148.05,118.38 ; 127.97,173.48 128.39,173.48 ; 120.55,181.24 120.49,180.86 ; 123.87,138.56 123.91,138.07 ; 122.94,145.1 122.58,145.1 ; 152.07,144.5 152.02,144.2 ; 154.57,170.22 154.99,170.2 ; 150.44,164.56 150.44,164.14 ; 153.67,146.12 153.67,145.78 ; 124.66,147.26 124.66,146.86 ; 115.01,177.48 115.44,177.48 ; 151.23,166.11 151.23,165.73 ; 115.62,175.71 115.62,175.23 ; 114.81,170.87 114.82,170.45 ; 100.97,156.3 101.3,156.3 ; 147.24,118.74 147.26,118.39
  IN2 w0.152: 143.16,171.91 143.16,172.35
  IN2 w0.508: v2(134.14,122.5) 133.04,123.6 133.04,125.39 v2(132.74,125.69)
  IN3 w0.102: 114.81,182.84 114.82,182.46 ; 142.35,170.83 142.35,170.41 ; 124.96,143.5 125.29,143.5 ; 151.23,119.89 151.22,119.95 151.23,120.3 ; 116.7,154.5 116.73,154.09 ; 141.83,151.18 142.28,151.15 ; 126.14,178.05 126.15,177.67 ; 153.07,146.34 153.45,146.38 ; 153.09,164.76 153.56,164.77 ; 123.11,145.69 123.11,145.31 ; 112.71,154.5 112.67,154.11 ; 153.05,118.96 153.52,119 ; 111.75,182.67 112.1,182.68 ; 152.25,151.93 152.65,151.97 ; 122.33,141.65 122.33,141.32 ; 124.77,143.44 124.68,142.94 ; 104.1,155.49 104.46,155.49 ; 152.03,118.75 152.05,118.33 ; 126.28,136.09 126.3,135.7 ; 121.53,179.84 121.95,179.88 ; 120.11,154.65 120.61,154.65 ; 101.75,155.51 102.11,155.51 ; 141.65,150.97 141.64,150.57 ; 126.96,181.22 126.97,180.81 ; 147.44,164.72 147.87,164.81 ; 114.25,179.88 114.65,179.85 ; 147.24,125.94 147.26,125.59 ; 147.61,116.84 147.61,116.47 ; 126.36,179.07 126.76,179.1 ; 151.38,179.8 151.85,179.81 ; 141.63,127.53 141.64,127.1 ; 107.36,154.73 107.73,154.72 ; 127.72,173.27 127.78,172.88 ; 149.62,125.94 149.63,125.54 ; 115,177.47 115.45,177.48 ; 123.08,138.5 123.12,138.1 ; 114.81,181.22 114.83,180.84 ; 126.9,179.66 126.92,179.25 ; 149.59,152.49 149.61,152.12 ; 125.72,147.46 126.86,147.46 ; 126.94,173.25 126.94,172.93 ; 153.81,172.61 154.22,172.59 ; 112.93,155.54 113.36,155.48 ; 126.37,177.45 126.74,177.47 ; 151.21,150.92 151.22,150.52 ; 108.66,152.93 108.7,152.52 ; 128.55,171.64 128.56,171.29 ; 101.49,155.7 101.5,155.71 101.5,156.07 ; 149.07,125.37 149.47,125.38 ; 105.2,155.52 104.84,155.48 ; 152.07,159.71 152.05,159.35 ; 114.01,181.2 114.03,180.83 ; 151.46,126.97 151.85,126.97 ; 106.64,155.5 107.9,155.5 ; 112.62,175.09 113.06,175.13 ; 151.26,152.56 151.24,152.21 ; 153.08,127.78 153.48,127.75 ; 126.29,159.32 126.32,158.8 ; 141.64,152.53 141.67,152.15 ; 152.86,166.13 152.85,165.72 ; 116.13,154.69 116.5,154.69 ; 105.51,153.82 105.51,153.24 ; 154.32,179.58 154.35,179.22 ; 106.31,153.75 106.28,153.28 ; 123.9,143.27 123.9,142.92 ; 124.66,147.26 124.66,146.86 ; 108.92,153.9 109.35,153.88 ; 121.31,182.82 121.32,182.39 ; 152.99,179.85 153.41,179.78 ; 125.5,154.53 125.52,154.1 ; 144.83,127.54 144.83,127.13 ; 101.5,155.28 101.5,154.93 ; 126.38,180.65 126.78,180.64 ; 152.2,171.8 152.6,171.8 ; 143.22,127.51 143.23,127.13 ; 122.3,145.36 122.3,145.74 ; 144.02,151.77 144.05,150.45 ; 151.25,118.72 151.23,118.36 ; 126.54,158.7 126.85,158.71 ; 149.88,164.74 150.25,164.76 ; 119.95,180.68 120.31,180.67 ; 122.49,143.49 123.82,143.48 ; 149.78,178.19 150.21,178.21 ; 114.29,174.23 114.65,174.23 ; 114.49,154.69 114.9,154.71 ; 128.74,183.06 129.12,183.07 ; 155.73,174.32 155.85,173.93 ; 123.11,156.89 123.11,156.44 ; 154.38,170.79 154.38,170.39 ; 124.7,136.08 124.7,135.72 ; 123.11,140.89 123.09,140.53 ; 108.06,181.48 108.35,181.39 ; 124.69,145.69 124.69,145.31 ; 121.74,141.9 122.15,141.9 ; 149.87,159.13 150.31,159.16 ; 151.98,177.76 151.96,177.99 ; 144.05,153.27 144.05,152.16 ; 108.88,153.12 109.31,153.12 ; 142.43,127.51 142.44,127.13 ; 151.94,179.6 151.97,179.2 ; 150.24,125.37 149.85,125.35 ; 104.7,154.51 104.72,154.08 ; 148.94,171.01 149.48,170.95 ; 125.48,145.69 125.48,145.25 ; 111.79,157.09 111.25,157.08 ; 127.98,173.48 128.37,173.49 ; 106.5,153.9 106.91,153.88 ; 120.55,176.08 120.52,176.59 ; 151.16,173.19 151.17,172.83 ; 122.5,178.8 122.83,178.78 ; 144.56,171.01 144.56,171.01 144.15,171.01 ; 144.04,166.94 144.04,166.55 ; 151.42,152.78 151.87,152.79 ; 125.74,143.5 126.14,143.51 ; 123.9,145.66 123.9,145.31 ; 111.88,154.48 111.92,154.11 ; 143.18,170.38 143.18,170.84 ; 126.36,171.9 126.69,171.89 ; 122.5,157.07 122.9,157.07 ; 143.99,170.4 143.99,170.8 ; 115.6,175.71 115.64,175.25 ; 152.25,144.76 152.66,144.76 ; 122.33,143.25 122.3,142.92 ; 150.42,166.06 150.46,165.72 ; 152.28,145.55 152.65,145.55 ; 142.64,126.95 143.06,126.95 ; 120.53,181.22 120.54,180.87 ; 123.9,157.69 123.9,157.25 ; 153.87,151.19 154.29,151.14 ; 104.08,154.69 104.5,154.72 ; 149.88,119.74 150.27,119.74 ; 151.5,125.35 151.96,125.42 ; 121.74,142.71 122.07,142.71 ; 149.01,171.75 149.43,171.78 ; 151.49,118.96 151.86,118.97 ; 146.62,118.95 147.11,119 ; 104.14,153.84 104.58,153.91 ; 151.45,126.18 151.87,126.2 ; 101.75,154.69 102.07,154.69 ; 101.72,157.89 102.13,157.89 ; 146.66,158.35 147.09,158.39 ; 114.81,174.05 114.85,173.61 ; 141.44,125.37 141.1,125.37 ; 125.51,143.28 125.5,142.91 ; 144.81,166.91 144.81,166.53 ; 153.56,170.78 153.56,170.41 ; 122.32,138.54 122.32,138.09 ; 125.5,136.07 125.5,135.71 ; 128.74,180.69 129.06,180.71 ; 126.34,172.69 126.74,172.71 ; 148.02,118.75 148.06,118.35 ; 153.07,152.76 153.56,152.78 ; 120.5,179.64 120.53,179.31 ; 115.87,155.28 115.9,154.87 ; 128.8,171.07 129.16,171.08 ; 155.18,173.19 155.19,172.81 ; 122.47,157.88 122.94,157.95 ; 143.18,171.92 143.18,172.43 ; 149.64,117.95 149.66,117.57 ; 120.57,182.9 120.53,182.45 ; 111.31,154.68 111.66,154.69 ; 115.08,155.26 115.09,154.91 ; 113.22,174.87 113.19,174.5 ; 152.86,146.12 152.86,145.78 ; 107.09,154.46 107.14,154.11 ; 144.27,167.15 144.64,167.14 ; 147.24,118.74 147.25,118.34 ; 123.88,138.58 123.89,138.12 ; 151.16,177.96 151.16,177.56 ; 152.86,157.33 152.86,156.81 ; 113.41,182.31 113.82,182.29 ; 128.63,145.79 128.73,145.41 ; 153.05,126.98 153.49,126.97 ; 148.83,120.31 148.82,119.94 ; 147.46,118.16 147.89,118.18 ; 112.64,179.08 112.99,179.06 ; 126.88,171.69 126.91,171.28 ; 150.55,173.42 151.04,173.4 ; 148.06,144.56 148.07,144.16 ; 108.86,154.68 109.34,154.71 ; 128.51,183.66 128.53,183.24 ; 127.1,145.66 127.1,145.31 ; 122.52,137.91 122.95,137.91 ; 123.32,159.49 123.66,159.49 ; 144.27,126.14 144.62,126.18 ; 123.05,158.13 123.03,158.48 ; 125.5,147.26 125.5,146.93 ; 151.24,166.13 151.22,165.71 ; 123.12,157.67 123.11,157.28 ; 126.94,182.84 126.94,182.49 ; 122.94,145.1 122.58,145.1 ; 100.93,156.3 101.31,156.3 ; 126.36,179.86 126.76,179.84 ; 113.19,179.63 113.19,179.28 ; 123.34,157.88 123.71,157.91 ; 154.59,170.21 155.02,170.22 ; 113.44,176.68 113.89,176.69 ; 145.61,166.95 145.62,166.45 ; 123.34,157.09 123.71,157.09 ; 118.53,153.91 118.94,153.9 ; 118.32,153.71 118.31,153.34 ; 127.91,145.69 127.91,145.31 ; 152.23,151.15 152.67,151.15 ; 119.72,179.65 119.72,179.19 ; 114.01,171.63 114.01,171.31 ; 99.91,158.48 99.91,158.07 ; 129.35,170.85 129.34,170.45 ; 123.24,158.69 123.7,158.7 ; 141.08,164.7 141.4,164.71 141.46,164.71 ; 153.64,146.14 153.65,145.77 ; 153.04,165.54 153.5,165.56 ; 154.38,173.18 154.37,172.84 ; 150.63,166.33 151.04,166.32 ; 147.47,163.95 147.92,163.96 ; 122.52,152.28 122.89,152.31 ; 126.14,172.49 126.12,172.11 ; 143.24,125.13 143.26,124.76 ; 102.29,157.68 102.29,157.31 ; 139.74,166.99 140.05,167.25 ; 115.37,155.53 115.75,155.47 ; 141.62,166.97 141.62,166.57 ; 149.67,143.76 149.71,143.34 ; 115.06,182.26 115.4,182.27 ; 128.79,171.87 129.13,171.89 ; 104.9,154.68 105.3,154.69 ; 129.75,176.3 130.06,176.24 ; 149.98,128.6 150.4,128.45 ; 115.07,181.47 115.42,181.47 ; 153.05,159.14 153.55,159.1 ; 154.92,179.82 154.59,179.81 ; 102.31,155.17 102.31,154.9
  IN3 w0.127: 114.25,171.06 114.61,171.06 ; 126.33,171.1 126.68,171.09 ; 145.61,160.53 145.62,160.22 ; 145.83,171.81 146.16,171.79 ; 127.97,171.08 128.3,171.08 ; 109.76,153.88 110.24,153.88 ; 147.18,173.17 147.19,172.8 ; 114.26,171.87 114.61,171.87 ; 111.7,177.09 112.06,177.07 ; 114.8,170.84 114.81,170.49 ; 114.27,172.68 114.61,172.68 ; 101.75,153.9 102.12,153.9
  IN4 w0.102: 151.45,126.18 151.88,126.2 ; 153.03,127.78 153.49,127.73 ; 121.56,179.84 121.96,179.88 ; 123.59,100.67 123.59,100.33 ; 149.63,125.96 149.63,125.53 ; 146.69,158.36 147.06,158.37 ; 145.63,146.13 145.62,145.77 ; 135.68,111.95 135.69,111.55 ; 137.5,100.97 137.87,100.98 ; 130.13,107.95 130.06,107.52 ; 114.6,171.06 114.59,171.06 114.23,171.06 ; 147.61,116.85 147.62,116.44 ; 105.44,182.28 105.82,182.28 ; 151.24,152.56 151.23,152.18 ; 135.71,100.72 135.73,100.32 ; 151.47,125.34 151.9,125.39 ; 135.68,103.95 135.68,103.6 ; 142.64,118.17 143.14,118.16 ; 152.26,151.93 152.64,151.93 ; 141.63,157.31 141.63,156.85 ; 108.42,172.45 108.45,172.07 ; 143.41,178.19 143.86,178.2 144.71,178.2 ; 121.99,104.71 121.98,104.3 ; 144.19,117.34 144.62,117.34 ; 125.48,123.3 125.49,122.87 ; 107.84,172.66 108.22,172.67 ; 125.5,123.75 125.51,124.11 ; 126.94,182.84 126.95,182.49 ; 152.07,159.74 152.06,159.31 ; 152.76,179.59 152.75,179.24 ; 120.09,128.29 120.43,128.3 ; 151.45,127.01 151.87,126.95 ; 126.88,179.66 126.92,179.29 ; 153.53,179.6 153.56,179.18 ; 149.87,159.14 150.2,159.14 ; 151.4,179.82 151.8,179.8 ; 137.49,112.15 137.97,112.17 ; 143.16,180.4 143.2,179.96 ; 129.27,103.92 129.26,103.47 ; 116.42,109.56 116.38,109.1 ; 153.04,152.74 153.44,152.78 ; 119.09,171.08 119.51,171.09 ; 123.11,125.66 123.1,125.24 ; 148.19,179.8 148.63,179.8 ; 135.7,109.56 135.67,109.14 ; 112.69,175.11 112.98,175.11 ; 126.34,179.07 126.75,179.1 ; 126.95,181.2 126.95,180.82 ; 120.76,176.71 121.18,176.71 ; 120.54,182.86 120.54,182.45 ; 149.8,125.33 150.37,125.4 ; 124.92,123.49 125.29,123.49 ; 120.53,181.21 120.52,180.88 ; 125.52,124.9 125.5,126.07 ; 122.99,102.51 123.44,102.51 ; 149.07,125.37 149.47,125.4 ; 126.34,179.86 126.8,179.86 ; 123.01,103.31 124.22,103.3 ; 128.72,180.71 129.08,180.71 ; 123.5,120.91 123.54,120.51 ; 115.58,109.49 115.63,109.07 ; 152.99,179.83 153.4,179.8 ; 107.82,182.29 108.23,182.28 ; 123.59,105.52 123.64,105.08 ; 151.43,152.8 151.9,152.77 ; 147.35,179.81 147.75,179.81 ; 137.52,104.18 137.92,104.16 ; 136.02,109.76 136.26,109.77 ; 130.91,103.93 130.9,103.54 ; 114.81,111.11 114.8,110.69 ; 116.91,128.26 117.32,128.29 ; 151.95,179.59 151.97,179.2 ; 122.77,103.85 122.79,103.53 ; 150.01,128.6 150.43,128.45 ; 119.96,180.68 120.38,180.67 ; 113.19,174.54 113.19,174.86 ; 135.1,111.37 135.45,111.36 ; 154.55,179.82 154.99,179.82 ; 135.12,108.99 135.54,108.98 ; 137.51,103.34 137.86,103.38 ; 153.89,151.16 154.26,151.15 ; 114.01,171.31 114.01,171.65 ; 137.51,102.56 137.89,102.56 ; 130.36,100.98 130.74,100.99 ; 124.95,124.29 125.29,124.3 ; 123.36,124.31 123.74,124.31 ; 120.51,179.63 120.53,179.29 ; 126.11,178.05 126.13,177.67 ; 123.34,125.11 123.71,125.11 ; 113.44,176.68 113.89,176.67 ; 149.61,152.47 149.6,152.12 ; 121.33,104.14 121.79,104.06 ; 135.5,109.78 135.1,109.75 ; 114.25,172.67 114.62,172.69 ; 135.15,113.01 135.56,112.96 ; 119.72,179.66 119.72,179.23 ; 105.22,182.83 105.19,182.47 ; 135.12,112.18 135.53,112.17 ; 135.1,103.39 135.52,103.39 ; 121.34,174.07 121.31,173.64 ; 137.49,117.11 137.96,116.9 ; 122.51,178.78 122.85,178.76 ; 154.35,179.59 154.36,179.23 ; 128.53,183.65 128.51,183.24 ; 129.74,176.31 130.11,176.24 ; 135.13,110.55 135.49,110.57 ; 147.26,125.93 147.24,125.56 ; 129.3,106.33 129.29,105.92 ; 153.08,126.98 153.47,126.96 ; 138.09,109.61 138.13,109.14 ; 135.11,100.94 135.5,100.95 ; 130.3,104.16 130.72,104.17 ; 155.76,174.24 155.85,173.86 ; 123.32,125.9 123.69,125.9 ; 114.26,171.88 114.62,171.88 114.63,171.89 ; 123.01,100.92 123.46,100.91 ; 118.49,128.3 118.95,128.3 ; 126.36,177.46 126.71,177.46 ; 126.4,180.65 126.77,180.63 ; 128.76,183.07 129.11,183.07 ; 153.05,159.12 153.51,159.12
  IN4 w0.127: 117.21,106.29 117.21,105.94
  IN4 w0.254: 157.38,117.97 157.38,120.72
  IN4 w0.635: 155.98,143.83 155.98,146.06
  IN4 w0.889: 124.1,121.81 125.86,120.06 ; 124.31,125.97 124.31,123.56 ; 122.81,128.18 124.03,126.96
  IN4 w1.143: 157.66,143.88 157.66,146.42
  IN4 w1.524: 155.63,117.95 155.63,120.59
  BOTTOM w0.203: U7700.R10 142.03,164.35 v6(142.03,165.09) ; v6(107.21,182.68) 106.81,182.28 U7601.T3 ; U7901.G11 130.09,108.36 129.49,108.97 U7901.F12 ; U7701.E5 145.22,177.06 v6(145.15,177.06) 145.1,177 144.36,177 U7701.C5 ; U7801.B3 141.23,151.53 140.69,151.53 140.45,151.3 v6(139.67,151.3) ; v6(142.77,151.55) 142.82,151.5 142.82,150.94 142.44,150.56 U7801.C5 ; U7601.B12 113.61,170.67 113.61,169.81 ; U7901.L1 138.18,104.88 138.18,104.25 U7901.M1 ; U7801.N5 150.03,150.76 150.03,151.56 U7801.M3 ; U7601.B3 107.19,170.7 v6(107.19,170.68) ; U7901.K3 136.49,105.87 136.87,106.25 136.87,106.77 136.49,107.15 U7901.H3 ; U7601.L2 U7601.L1 ; U7800.B12 152.84,126.17 152.46,126.55 152.46,127.38 U7800.B14 ; v6(138.51,110.23) 138.94,109.8 138.94,109.26 138.65,108.97 U7901.F1 ; v6(145.09,173.01) 144.36,173.01 U7701.C10 ; U7900.N10 121.56,110.1 121.56,110.94 U7900.R10 ; v6(129.96,178.17) 129.85,178.17 129.72,178.05 129.72,178.05 129.55,177.88 128.92,177.88 U7600.G2
  BOTTOM w0.254: v6(142.82,169.76) 143.17,170.11 U7701.B14 ; U7901.G2 U7901.G1 138.71,108.17 138.74,108.19 v6(138.76,108.19) ; v6(153.31,142.74) 152.9,143.15 U7801.T14 ; R7109.2 v2(101.4,166.17) ; U7701.G4 147.04,178.33 147.04,178.42 v6(146.83,178.62) 146.62,178.83 146.54,178.83 U7701.F3 ; U7701.B3 143.61,179.44 v6(143.61,179.44) ; v6(127.23,104.65) 127.38,104.65 U7901.L14 ; v6(154.76,172.2) 154.37,171.81 U7701.T12 ; v6(152.37,180.21) U7701.P1 ; U7901.C10 130.73,111.2 130.73,111.14 v6(130.49,110.9) ; v6(107.98,171.46) 108.15,171.64 108.18,171.64 U7601.C5 ; U7600.L4 127.33,174.67 U7600.M3 ; v6(138.61,112.17) U7901.B1 ; U7701.B12 v6(142.76,171.39) ; v6(152.37,173.81) U7701.N10 ; v6(151.56,178.61) U7701.M3 ; U7801.G14 145.64,142.86 v6(145.83,142.68) ; v6(153.15,178.62) 152.77,179 U7701.P3 ; U7800.L4 U7800.K3 ; v6(145.09,173.01) 145.48,173.4 U7701.E10 ; v6(104.28,171.07) U7601.B1 ; U7701.D3 145.14,178.63 v6(145.21,178.63) ; U7701.P12 152.79,171.8 v6(153.19,172.2) ; U7701.L1 150.38,180.6 v6(150.77,180.2) 151.17,180.6 U7701.M1 ; U7701.T14 v6(153.98,169.81) ; U7900.L11 122.04,108.12 v6(122.45,108.52) 122.78,108.85 U7900.M12 ; v6(113.67,172.28) 113.27,172.67 U7601.D11 ; v6(141.64,155.66) U7700.T1 ; U7701.T1 v6(153.99,180.23) ; v6(154.79,178.58) 154.79,178.58 U7701.T3 ; v6(124.69,110.12) 124.38,110.43 U7900.P14
  BOTTOM w0.305: U7801.L4 v6(148.44,151.55) U7801.K3 ; v6(142.02,117.76) 142.02,117.75 141.64,117.38 U7800.T1 ; C7629.1 v6(104.83,169.33) ; U7801.G4 145.64,151.17 v6(145.24,151.58) 144.86,151.95 U7801.F3 U7801.G2 ; U7601.P14 v6(116.15,180.67) ; U7701.F12 146.37,171.79 v6(146.77,171.39) 147.16,171 U7701.G13 ; v6(113.36,102.51) 113.36,102.52 U7900.D1 ; U7701.H12 v6(147.59,172.18) U7701.G11 ; U7801.F14 144.67,142.98 144.67,142.93 v6(144.35,142.61) ; U7801.R5 v6(152.53,149.87) ; U7600.P12 120.89,173.03 v6(120.93,173.03) 120.97,173.03 U7600.P11 ; v6(143.61,126.53) 143.25,126.17 U7800.P12 143.23,126.17 143.23,125.37 U7800.P11 ; 148.36,145.07 U7801.L11 ; 148.36,145.07 v6(148.36,145.15) ; 148.36,145.07 U7801.K12 ; U7600.B1 129.66,182.27 v6(129.87,182.06) ; U7801.E10 143.96,146.35 v6(143.61,146) 143.61,145.92 U7801.D11 ; v6(152.46,146.78) 152.04,146.36 U7801.R10 ; v6(104.67,174.06) 104.89,174.27 U7601.F1 ; U7800.R5 v6(142.44,121.08) 143.53,121.08 144.04,120.57 U7800.N5 ; U7900.B3 115.19,101.31 v6(115.19,101.31) ; v6(124.85,102.22) 124.55,102.52 U7900.D14 ; C7817.1 148.77,142.28 v6(149.28,142.79) ; U7800.L2 v6(145.26,118.56) U7800.M3 ; U7801.E5 144.05,150.35 v6(144.44,149.96) ; v6(125.65,171.39) 126.13,171.86 U7600.R5 ; v6(127.17,100.97) U7901.T14 ; v6(128.91,100.58) U7901.T12 v6(129.72,101.39) ; v6(116.02,110.15) 115.74,110.43 115.67,110.43 U7900.P3 ; U7600.F14 118.53,179.07 v6(118.29,178.83) ; U7700.M1 144.89,156.74 v6(145.26,157.11) 145.64,156.74 U7700.L1 ; U7900.G14 124.38,104.85 v6(124.01,104.49) U7900.F14 ; U7701.L14 150.37,170.1 v6(150.71,169.75) 151.16,170.2 U7701.M14 ; U7801.D12 U7801.D11 ; U7801.D11 v6(142.83,145.96) U7801.C10 ; v6(152.04,163.43) U7700.C10 ; v6(151.58,124.01) 152.04,124.47 U7800.C10 ; U7801.T3 153.23,151.56 v6(153.23,151.56) ; U7600.T12 120.68,171.22 120.68,171.26 v6(120.89,171.47) ; U7801.P1 v6(150.85,153.16) ; v6(142.06,167.68) 142.06,167.56 U7700.T14 ; v6(129.72,106.95) 129.3,107.37 U7901.H12 129.29,107.37 U7901.G13 128.31,107.98 127.88,107.98 127.88,107.98 U7901.G14 127.61,108.17 127.23,107.78 v6(127.23,107.76) ; U7900.H3 v6(115.19,105.32) U7900.G2 ; U7600.M14 v6(118.51,174.69) 118.89,175.07 U7600.L14 ; U7901.T3 136.44,100.97 v6(136.07,101.34) ; v6(105.39,169.33) 105.72,169.01 C7630.1 ; U7700.K3 v6(146.05,158.74) U7700.L4 ; U7600.E5 125.8,179.54 v6(125.75,179.54) 123.81,181.47 U7600.C10 ; U7601.K12 114.1,177.47 v6(114.46,177.84) ; U7700.H3 148.04,158.37 v6(148.39,158.71) 148.42,158.71 U7700.G4 ; U7800.P3 143.26,118.97 v6(143.64,119.35) ; v6(107.14,172.26) 106.95,172.46 106.95,172.54 U7601.D3 ; U7901.R5 134.54,101.77 v6(134.37,101.95) ; U7601.M1 v6(104.7,179.07) ; U7901.D12 129.66,110.94 v6(129.7,110.94) 129.7,110.96 U7901.D11 ; U7701.N5 151.97,177.32 v6(152.4,176.89) 153.05,176.89 U7701.R5 ; v6(122.68,179.75) 122.45,179.75 122.32,179.87 U7600.E10 ; U7900.G11 121.98,104.92 v6(122.38,105.32) 122.77,105.72 U7900.H12 ; U7601.N5 v6(108.87,180.32) ; U7800.P1 143.24,117.4 v6(143.64,117.79) ; U7801.H12 145.64,143.95 U7801.G13 146.02,143.57 v6(146.02,143.55) 145.64,143.17 U7801.G14 ; U7700.K12 146.43,165.54 v6(146.04,165.93) 145.64,166.33 U7700.L13 ; U7901.E10 130.89,109.73 v6(130.5,109.33) ; U7601.G2 U7601.G1 104.7,175.07 v6(104.67,175.05) ; U7700.T3 142.04,157.95 v6(142.04,157.91) ; U7701.L2 150.37,179.8 v6(149.96,179.39) 149.57,179 U7701.K3 ; U7801.D3 143.24,151.95 143.09,152.1 143.09,152.19 v6(142.85,152.43) ; v6(124.7,108.51) 124.7,108.6 U7900.M14 ; U7900.K3 U7900.L4 116.4,108.12 v6(116.79,107.73) ; v6(136.09,110.99) U7901.D3 ; v6(107.21,177.08) 107.19,177.08 106.81,177.45 U7601.K3 U7601.L4 ; U7601.E5 108.58,173.63 108.6,173.63 v6(108.84,173.87) ; U7800.E5 v6(150.44,121.15) ; U7600.M1 129.33,174.25 v6(128.93,173.85) ; U7700.M14 144.84,167.16 v6(145.24,167.55) 145.64,167.15 U7700.L14 ; v6(127.33,181.88) 127.34,181.88 U7600.B3 ; U7800.T3 141.64,118.99 v6(142.02,119.37) ; U7901.F12 v6(128.92,109.34) ; U7601.M14 115.61,179.05 v6(115.21,178.65) 115.6,178.27 U7601.L14 ; U7701.P14 152.76,170.2 v6(152.37,169.81) ; v6(143.65,157.93) 143.65,157.93 U7700.P3 ; v6(113.65,173.88) 114.01,174.24 U7601.F12 ; U7900.E10 120.93,103.32 v6(120.68,103.57) ; v6(115.21,174.67) U7601.F14 ; v6(115.21,174.67) 114.81,175.07 U7601.G13 ; v6(115.21,174.67) 115.61,175.06 U7601.G14 ; U7601.E10 112.41,173.43 v6(112.8,173.04) ; v6(114.42,181.87) 114.02,182.27 U7601.T12 ; v6(113.67,172.28) 114.01,172.63 U7601.D12 ; U7600.C5 126.32,181.67 126.32,181.69 v6(126.52,181.88) ; U7901.R10 130.54,102.12 v6(130.53,102.12) ; U7601.P1 105,180.46 104.29,180.46 104.04,180.71 C7628.1 ; U7801.B12 141.83,144.56 141.83,144.49 v6(142.05,144.27) ; v6(113.56,104.51) 113.96,104.12 U7900.F1 ; v6(113.56,104.51) 112.81,104.51 112.24,105.07 R7915.1 ; v6(113.56,104.51) U7900.G1 ; v6(152.04,121.1) U7800.C5 ; v6(116.15,182.27) U7601.T14 ; U7600.D14 118.95,180.67 v6(119.36,180.26) ; U7801.F1 144.86,153.55 v6(145.26,153.15) 145.64,153.53 U7801.G1 ; U7901.P3 v6(136.88,102.96) ; C7729.1 139.12,166.54 v6(139.55,166.11) 139.14,165.7 C7735.1 ; U7700.P1 143.24,156.12 v6(142.78,155.66) ; v6(146.05,117.75) 145.67,117.37 U7800.L1 U7800.M1 ; v6(127.12,111.83) 127.35,111.83 U7901.B14 ; U7700.P14 143.25,167.14 v6(143.69,167.58) ; v6(127.31,103.77) 127.31,103.78 U7901.M14 ; U7700.T12 141.66,165.54 141.81,165.39 141.81,165.31 v6(142.03,165.09) ; U7701.H3 v6(148.37,178.6) ; v6(129.68,112.56) 129.68,112.55 U7901.B12 ; U7601.R5 v6(108.79,181.1) ; U7801.L1 v6(149.25,153.15) ; v6(149.25,153.15) U7801.M1 ; v6(149.25,153.15) U7801.L2 ; U7601.B14 116.1,170.58 116.1,168.8 116.46,168.44 C7614.1 117.02,169.15 117.22,169.36 117.27,169.36 117.35,169.43 v2(117.35,169.43) ; v6(150.9,157.14) 151.24,156.8 U7700.D1 ; U7800.G14 v6(149.26,128.18) 149.64,127.79 U7800.F14 ; U7700.L11 145.64,164.74 v6(145.21,165.17) 144.84,165.53 U7700.M12 ; U7901.B3 v6(136.09,112.56) ; v6(134.47,111.78) U7901.C5 ; v6(130.02,180.43) 129.77,180.67 U7600.D1 ; U7600.L2 U7600.L1 129.74,175.07 v6(129.87,175.2) ; U7600.B12 120.53,182.23 v6(120.9,181.85) ; U7701.M12 151.17,171.81 v6(150.8,172.18) 150.37,172.6 U7701.L11 ; U7900.N5 117.47,109.42 v6(117.61,109.42) 117.78,109.59 117.78,110.71 U7900.R5 ; U7700.E10 v6(150.44,163.43) ; v6(150.44,149.82) U7801.N5 ; v6(152.44,119.37) 152.84,118.97 U7800.B3 ; v6(151.63,151.56) 151.6,151.6 151.59,151.6 U7801.P3 ; U7801.H3 146.44,151.95 v6(146.86,151.53) ; v6(150.67,160.47) 150.44,160.24 U7700.E5 ; U7800.E10 150.23,124.36 150.17,124.36 v6(149.96,124.14) ; U7600.T3 127.7,171.07 v6(127.31,170.68) ; U7800.L13 145.64,126.97 v6(145.22,126.56) 144.84,126.18 U7800.M12 U7800.L11 145.64,125.37 v6(146.02,125.74) 146.03,125.76 146.04,125.76 U7800.K12 ; v6(152.43,128.41) 152.43,128.19 U7800.B14 ; U7900.T3 115.58,112.12 v6(116.01,111.69) ; U7700.G14 U7700.F14 ; U7600.D3 127.74,180.67 128.11,181.04 v6(128.11,181.04) ; U7601.G4 v6(107.21,175.48) U7601.H3 ; v6(138.51,110.23) 138.16,110.57 U7901.D1 ; v6(141.26,142.61) 141.26,142.77 U7801.B14 ; U7901.K12 128.71,105.19 ; 128.71,105.19 U7901.L13 ; 128.71,105.19 128.71,105.18 v6(128.12,104.59) ; U7601.F3 v6(107.21,173.88) ; U7700.N5 v6(144.47,160.37) 143.66,161.18 142.39,161.18 142.17,160.96 142.17,160.21 U7700.R5 ; v6(129.69,102.96) 129.34,102.61 U7901.P12 ; 113.61,169.81 113.28,169.48 C7626.1 C7625.1 112.62,167.78 112.52,167.88 112.52,168.45 v2(112.53,168.46) ; U7601.N10 112.41,179.82 v6(112.04,179.45) ; U7600.T14 118.65,171.07 118.59,171.01 v6(118.37,171.01) ; v6(117.6,103.75) 117.6,103.75 U7900.E5 ; v6(150.85,119.37) 150.85,119.36 U7800.D3 ; v6(127.13,110.99) 127.27,110.99 U7901.D14 ; U7800.M14 144.84,127.97 v6(145.14,128.26) 145.15,128.26 U7800.L14 ; v2(102.69,182.24) 103.3,182.84 C7622.1 103.81,182.84 104.57,182.08 105.02,182.08 U7601.T1 ; U7700.F3 149.23,158.76 v6(149.23,158.76) ; U7900.L1 114,108.12 114.34,108.46 114.34,108.47 v6(114.38,108.5) 114.34,108.54 114.34,108.55 113.98,108.91 U7900.M1 ; U7900.N10 120.82,109.36 v6(120.82,109.31) ; U7600.L13 120.07,175.41 120.07,175.41 120.53,175.87 U7600.K12 121.31,175.09 121.31,175.07 ; U7800.H3 U7800.G4 148.85,119.77 v6(149.25,119.37) 149.25,119.36 U7800.F3 U7800.G2 148.84,118.09 v6(148.49,117.74) 148.84,117.39 U7800.G1 ; U7701.D14 144.77,170.05 v6(145.12,169.7) ; U7600.H12 U7600.G11 120.94,178.67 v6(120.92,178.67) 120.92,178.69 U7600.F12 U7600.G13 U7600.G14 v6(118.29,178.27) ; v6(142.01,126.53) 141.65,126.17 U7800.T12 ; U7900.T14 124.71,111.78 v6(124.71,111.7) ; v6(152.46,165.17) 152.83,165.54 U7700.B12 ; v6(149.26,126.56) U7800.F12 ; v6(151.61,142.76) 151.61,142.78 U7801.P14 ; v6(118.36,173.03) 118.57,173.03 U7600.P14 ; U7600.F3 127.7,179.07 v6(127.31,178.68) 126.93,178.3 U7600.G4 ; U7600.F1 130.04,179.07 v6(130.1,179.01) 129.36,178.27 U7600.G1 ; U7901.F3 v6(136.09,108.57) U7901.G4 ; U7800.D14 151.2,127.77 v6(150.85,127.42) ; v6(141.43,169.76) C7714.1 ; U7700.G1 148.84,156.76 v6(149.2,157.11) 148.84,157.47 U7700.G2 ; U7800.P14 v6(143.24,128.31) ; v6(136.03,106.16) 136.42,105.77 U7901.K3 U7901.L4 ; v6(104.67,172.4) 104.95,172.4 U7601.D1 ; U7900.P12 v6(122.38,110.12) U7900.P11 ; v6(136.09,104.56) U7901.M3 U7901.L2 ; 124.38,100.94 U7900.B14 124,101.29 v6(124,101.31) ; U7601.H12 114.01,175.87 v6(113.61,175.48) U7601.G11 ; v6(134.16,102.88) 134.41,102.88 U7901.N5 ; U7901.M12 129.31,104.17 v6(129.72,104.57) 130.09,104.95 U7901.L11 ; U7000.AD10 110.58,129.38 110.58,129.58 U7000.AC11 ; v6(141.21,153.11) 141.22,153.13 141.22,153.13 U7801.B1 ; U7600.B14 118.36,182.84 118.36,184.3 C7611.1 117.61,184.3 v2(117.61,184.08) ; U7700.F1 149.64,156.72 v6(149.99,156.37) ; U7801.T12 v6(153.24,145.15) ; U7900.M3 115.58,108.88 v6(115.18,108.48) 114.82,108.12 U7900.L2 ; U7701.L13 150.36,171 v6(149.94,171.42) 149.57,171.8 U7701.K12 ; U7601.M3 U7601.L2 ; U7901.P14 128.02,102.24 128.02,102.18 v6(128.02,102.18) ; v6(152.04,160.45) U7700.C5 ; U7801.P11 151.26,145.55 v6(151.66,145.15) U7801.P12 ; v6(129.82,173.04) 129.56,172.78 129.44,172.78 U7600.P1 ; v6(124.89,107.91) 124.59,107.91 124.38,108.12 U7900.L14 124.24,108.25 123.71,108.25 U7900.L13 122.78,107.32 U7900.K12 ; v6(112.05,172.24) 112.05,172.22 112.4,171.87 U7601.C10 ; U7801.G11 145.64,145.55 v6(145.24,145.15) 144.84,144.76 U7801.F12 ; v6(122.61,173.88) 122.33,173.6 122.26,173.6 U7600.N10 ; v6(104.7,178.4) 104.83,178.27 U7601.L1 ; U7900.F3 115.61,104.12 v6(116,104.51) 116.38,104.89 U7900.G4 ; U7700.H12 v6(148.43,165.93) ; U7800.G11 U7800.H12 ; U7900.F12 122.84,104.18 v6(123.19,104.54) U7900.G13 ; 133.66,146.06 133.66,146.9 134.67,146.9 v2(135.28,147.51) ; U7900.D3 v6(115.95,102.14) ; U7601.R10 v6(111.89,181.47) ; v6(144.4,124.96) 144.04,124.6 U7800.N10 ; v6(150.81,145.99) U7801.N10 ; v6(147.17,169.69) U7701.G14 U7701.F14 ; v6(122.4,111.74) U7900.T12 ; U7701.M3 U7701.L4 ; U7600.P3 127.65,172.59 127.65,172.54 v6(127.36,172.25) ; U7600.D11 121.3,180.67 v6(120.93,180.3) 120.61,180.62 120.59,180.62 U7600.D12 ; v2(155.93,176.92) 156.2,177.18 C7706.1 156.72,178.96 ; U7901.F14 127.22,109.44 v6(127.22,109.52) ; U7800.K3 v6(146.06,118.58) ; v6(149.25,165.96) 149.64,165.56 U7700.F12 ; U7700.P12 143.24,165.54 143.61,165.17 v6(143.61,165.17) 143.24,164.8 U7700.P11 ; U7600.L11 121.31,175.07 ; 121.31,175.07 121.29,175.07 v6(120.93,174.72) 120.53,174.32 U7600.M12 ; U7900.B12 v6(122.38,101.29) ; U7601.P3 106.82,180.67 v6(107.19,181.04) ; U7800.D12 v6(150.85,125.77) 151.24,125.38 U7800.D11 ; C7814.1 v2(155.17,148.53) ; U7701.R10 153.56,173.41 153.14,172.99 153.14,172.94 v6(153.14,172.94) 152.8,172.6 U7701.P11 ; U7601.P12 v6(113.61,180.28) ; v6(125.76,173.85) 125.76,173.85 U7600.N5 ; U7701.D12 144.78,171.8 v6(145.16,172.18) 144.77,172.56 U7701.D11 ; U7801.M12 v6(149.24,145.15) ; U7600.M3 127.72,174.27 v6(127.31,173.85) ; v6(112.88,180.28) 112.88,180.33 U7601.P11 ; U7901.E5 v6(134.49,109.37) ; U7700.B3 v6(152.47,158.71) ; v2(135.55,144.88) 135.55,144.2 134.84,143.49 134.84,143.49 134.59,143.25 R7113.2 R7121.2 ; v6(127.33,177.87) 127.72,177.47 U7600.H3 ; U7900.C10 120.9,101.72 v6(120.62,102) ; U7601.L13 U7601.M12 v6(113.61,178.68) U7601.L11 ; v6(144.41,164.3) U7700.N10 ; U7700.L2 145.64,157.55 v6(145.24,157.95) 144.85,158.34 U7700.M3 ; v6(129.77,171.46) 129.54,171.23 129.49,171.23 U7600.T1 ; U7901.N10 130.89,103.37 v6(130.48,102.96) 130.09,102.57 U7901.P11 ; U7801.D14 143.24,143.09 142.92,142.76 v6(142.92,142.61) ; U7900.D12 122.75,102.52 v6(122.38,102.89) 122,102.52 U7900.D11 ; U7801.L14 148.84,143.15 v6(148.45,143.55) U7801.L13 ; v6(122.52,172.26) U7600.R10 ; U7801.D1 v6(142.86,153.12) ; v6(152.58,167.61) 152.58,167.41 U7700.B14 ; U7700.D3 v6(150.85,158.73) ; U7800.R10 v6(142.04,124.96) ; U7600.K3 v6(128.14,176.29) ; U7801.T1 v6(152.47,153.18) ; U7900.C5 v6(116.79,101.33) ; U7601.D14 v6(115.22,173.07) ; U7700.G11 v6(149.23,164.35) ; U7800.T14 v6(141.64,128.31)
  BOTTOM w0.381: U7901.M1 138.66,103.6 v6(138.66,102.57) U7901.P1 ; C7819.1 151.44,142.21
  BOTTOM w0.406: C7807.1 142.37,141.77 142.92,142.32 v6(142.92,142.61) ; R7810.2 v6(149.66,128.92) ; R7800.2 156.17,122.93 v2(156.69,122.93) ; C7717.1 v2(150.72,183.38) ; C7829.1 139.24,127.14 v6(139.67,126.71) ; v6(107.39,118.58) 107.39,118.37 107.58,118.18 R7115.2 ; v2(128.35,164.84) 128.42,164.91 R7104.2 ; v2(98.6,166.26) R7101.2 ; C7719.1 v2(152.02,183.42) ; R7717.1 v2(148.51,183.81) ; v2(102.69,180.71) C7628.1
  BOTTOM w0.457: v6(141.64,128.31) 141.71,128.37 C7828.1
  BOTTOM w0.508: C7716.1 140.51,177.74 v2(140.51,177.18) ; v6(154.36,128.67) 153.62,129.41 152.44,129.41 151.65,130.19 R5700.1 ; v2(110.77,116.47) 111.05,116.75 R7122.2 ; R7700.2 v2(156.77,161.81)
  vias: v1(129.82,134.41) v2(110.9,115.15) v2(110.9,114.54) v2(110.9,113.88) v2(110.9,113.25) v2(126.77,113.94) v2(127.39,113.93) v2(132.26,173.7) v2(132.26,172.84) v2(134.27,132.96) v2(134.75,132.45) v2(136.01,145.35) v2(136.27,133.36) v2(136.4,132.1) v2(136.63,132.75) v2(154.56,153.15) v2(154.56,152.52) v2(154.62,144.57) v2(154.82,149.87) v2(154.89,150.8) v2(155.17,145.02) v2(156.3,182.48) v2(156.3,181.85) v3(150.05,95.45) v3(150.05,94.56) v3(150.05,93.67) v3(150.05,92.78) v3(150.06,91.91) v3(150.57,91.21) v3(151.01,95.46) v3(151.01,94.57) v3(151.01,93.68) v3(151.01,92.79) v3(151.05,91.93) v3(151.5,91.19) v3(151.92,95.44) v3(152.08,94.55) v3(152.08,93.66) v3(152.08,92.77) v3(152.08,91.88) v3(152.83,95.47) v3(153.72,96.36) v3(153.72,95.47) v3(154.36,116.62) v3(154.36,115.73) v3(154.61,96.36) v3(154.61,95.47) v3(155.25,116.62) v3(155.25,115.73) v3(156.14,116.62) v3(156.14,115.73) v6(103.51,153.5) v6(105.08,151.65) v6(105.84,151.65) v6(106.48,184.04) v6(107.04,184.04) v6(108.26,151.65) v6(109.1,130.5) v6(111.5,130.5) v6(111.56,151.4) v6(111.9,130.96) v6(112.19,151.4) v6(112.67,100.75) v6(113.06,130.55) v6(113.13,100.4) v6(113.41,113.78) v6(113.41,111.65) v6(113.42,110.23) v6(113.47,130.96) v6(114.44,184.12) v6(114.61,151.4) v6(114.73,130.78) v6(115,184.12) v6(115.29,130.78) v6(116.08,174.82) v6(116.23,152.62) v6(116.28,179.08) v6(116.26,151.4) v6(116.38,130.78) v6(116.94,130.78) v6(118.03,130.78) v6(118.59,130.78) v6(119.48,153.54) v6(119.58,132.68) v6(119.7,148.62) v6(119.69,136.24) v6(119.69,134.77) v6(119.9,129.16) v6(120.07,147.03) v6(120.13,143.92) v6(120.14,143.1) v6(120.12,139.88) v6(120.14,139.11) v6(120.14,135.91) v6(120.14,132.68) v6(120.15,146.3) v6(120.15,144.71) v6(120.27,153.15) v6(120.69,183.71) v6(120.83,153.15) v6(120.96,147.97) v6(120.96,147.03) v6(120.96,146.27) v6(120.96,144.67) v6(120.96,143.1) v6(120.96,142.33) v6(121,141.53) v6(120.96,140.76) v6(120.95,139.9) v6(121,135.11) v6(121.27,183.71) v6(121.36,153.74) v6(121.59,152.93) v6(121.59,152.37) v6(121.56,146.14) v6(121.67,151.71) v6(121.77,143.79) v6(121.95,153.74) v6(121.93,151.09) v6(121.91,144.71) v6(122.15,152.93) v6(122.58,153.74) v6(123.5,153.51) v6(125.91,158.28) v6(125.89,157.5) v6(126.26,183.61) v6(126.7,157.48) v6(126.83,183.61) v6(126.8,169.31) v6(127.43,169.31) v6(127.51,159.05) v6(127.5,157.48) v6(128.45,169.31) v6(138.61,101.08) v6(138.63,100.53) v6(144.37,180.93) v6(144.38,180.22) v6(146,180.23) v6(146.78,180.23) v6(148.48,127.33) v6(150.85,165.17) v6(153.16,156.14) v6(153.72,160.88) v6(154,148.36) v6(153.99,122.65) v6(154.27,123.72) v6(154.44,158.19) v6(154.5,162.44) v6(154.49,159.6) v6(154.52,156.67) v6(154.52,156.09) v6(154.51,120.26) v6(154.51,118.94) v6(154.51,117.87) v6(154.6,121.7) v6(155.65,170.56) v6(155.66,169.87)
