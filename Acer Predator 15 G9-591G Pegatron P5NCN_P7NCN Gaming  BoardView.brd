# Allegro board Acer Predator 15 G9-591G Pegatron P5NCN_P7NCN Gaming  BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_D47: length 23.4
  TOP w0.133: v1(122.21,127.66) 121.68,127.66 v6(121.11,127.09)
  IN4 w0.095: v6(121.11,127.09) 120.22,126.2 120.22,118.6 123.14,115.67 123.14,115.23 126.75,111.62 126.75,110.83 126.97,110.61 127.61,110.61 v6(128.07,110.15)
  BOTTOM w0.133: v6(128.07,110.15) 128.34,109.88 128.39,109.88 U7901.E13 ; U7000.L8 120.7,127.5 v6(121.11,127.09)
FBD_D48: length 34.7
  IN2 w0.089: 118.27,126.54 118.11,126.7 118.11,127.66 117.45,128.33 117.45,128.82 117.18,129.09 116.7,129.09 v6(116.41,129.38)
  IN2 w0.146: v6(128.88,103.75) 129.29,104.16 129.29,104.74 127.6,106.42 127.6,107.54 127.68,107.62 127.68,107.95 127.66,107.97 127.66,113.05 127.82,113.2 127.82,114.82 126.31,116.32 124.53,116.32 123.32,117.53 122.62,117.53 119.82,120.34 119.09,120.34 118.27,121.16 118.27,126.54
  BOTTOM w0.133: v6(128.88,103.75) 128.5,103.37 U7901.N13 ; v6(116.41,129.38) 116.13,129.1 U7000.U10
FBD_D49: length 35.5
  TOP w0.133: v1(115.7,127.53) 116.14,127.1 v6(116.3,127.1)
  IN2 w0.146: v6(128.12,100.54) 126.9,100.54 126.43,101.01 126.43,102.49 124.99,103.93 124.99,104.94 123.96,105.97 123.56,106.37 123.56,108.08 123.62,108.14 123.62,113.03 118.27,118.38 117.04,118.38 115.88,119.53 115.88,122.43 115.53,122.78 115.53,126.33 v6(116.3,127.1)
  BOTTOM w0.133: U7000.U7 115.9,126.7 v6(116.3,127.1) ; U7901.U13 v6(128.12,100.54)
FBD_D50: length 31.2
  IN2 w0.089: v6(116.36,128.74) 116.82,128.28 117.23,128.28 117.92,127.59 117.92,124.2
  IN2 w0.146: 117.92,124.2 117.92,120.9 119.03,119.78 119.71,119.78 126.59,112.89 126.59,107.81 127.16,107.24 127.16,106.24 v6(128.83,104.57)
  BOTTOM w0.133: v6(116.36,128.74) 116.26,128.64 116.24,128.64 U7000.U9 ; v6(128.83,104.57) 128.68,104.42 128.68,104.35 U7901.M13
FBD_D51: length 34.1
  TOP w0.133: v1(127.35,100.39) 127.62,100.66 127.62,100.88 v6(128.1,101.36)
  IN2 w0.146: v6(117.1,126.3) 116.69,125.89 116.13,125.89 115.88,125.65 115.88,122.9 116.25,122.53 116.25,119.51 116.77,119 118.29,119 124.13,113.15 124.13,108.07 124.4,107.8 124.4,106.18 125.5,105.07 125.5,104.13 128.1,101.53 v6(128.1,101.36)
  BOTTOM w0.133: U7000.R7 v6(117.1,126.3) ; U7901.T13 v6(128.1,101.36)
FBD_D52: length 33.3
  TOP w0.133: v1(117.89,127.91) v6(117.89,128.71)
  IN2 w0.089: v6(117.89,128.71) 117.89,128.28 118.3,127.87 118.3,126.96 118.57,126.69 118.84,126.69 119.09,126.44 119.09,124.12 119.06,124.08
  IN2 w0.146: 119.06,124.08 119.06,123.53 119.48,123.1 119.48,121.4 122.76,118.12 123.35,118.12 124.71,116.76 126.64,116.76 128.48,114.91 128.48,108.29 129.41,107.36 129.92,107.36 130.12,107.15 130.12,104.94 v6(130.51,104.56)
  BOTTOM w0.133: v6(130.51,104.56) 130.28,104.34 130.27,104.34 U7901.M11 ; U7000.R10 v6(117.89,128.71)
FBD_D53: length 40.6
  TOP w0.133: v6(130.53,100.6) 130.91,100.98 130.91,101.59 v1(131.32,102)
  IN2 w0.146: v6(119.33,128.77) 119.76,128.34 119.76,127.83 120.65,126.94 120.65,123.91 121.97,122.59 121.97,120.47 122.88,119.56 124.08,119.56 125.36,118.28 128.17,118.28 131.52,114.92 131.52,114.91 132.29,114.14 132.29,101.76 131.13,100.6 v6(130.53,100.6)
  BOTTOM w0.133: U7901.U11 130.52,100.6 v6(130.53,100.6) ; v6(119.33,128.77) 118.86,129.24 118.44,129.24 U7000.P10
FBD_D54: length 33.9
  TOP w0.133: v1(131.24,104.51) 130.51,103.78 v6(130.51,103.77)
  IN2 w0.146: v6(130.51,103.77) 130.99,104.26 130.99,114.06 127.85,117.2 125.04,117.2 123.59,118.65 122.73,118.65 119.94,121.44 119.94,126.39 119.64,126.68 119.35,126.68 119.1,126.94 119.1,127.5 v6(118.7,127.9)
  BOTTOM w0.133: U7000.P8 118.3,127.5 v6(118.7,127.9) ; U7901.N11 130.27,103.54 130.27,103.54 v6(130.51,103.77)
FBD_D55: length 37.5
  TOP w0.133: v1(118.71,129.44) v6(118.71,128.7)
  IN2 w0.146: v6(130.51,101.39) 131.85,102.73 131.85,113.96 128.09,117.72 125.19,117.72 123.77,119.14 122.7,119.14 120.29,121.55 120.29,126.91 119.09,128.12 119.09,128.33 v6(118.71,128.7)
  BOTTOM w0.133: U7901.T11 130.09,100.97 v6(130.51,101.39) ; U7000.P9 118.54,128.54 118.55,128.54 v6(118.71,128.7)
FBD_D56: length 36.7
  TOP w0.089: v1(136.04,105.3) 135.71,104.98 135.71,104.2 v6(135.28,103.77)
  IN1 w0.095: v6(118.7,125.5) 119.09,125.11 119.62,125.11 119.98,124.76 119.98,124.22 120.5,123.7 120.5,120.95 123.4,118.05 130.95,118.05 133.06,115.94 133.06,108.74 134.8,107 134.8,106.7 134.8,106.24 135.71,105.33 135.71,104.2 v6(135.28,103.77)
  BOTTOM w0.133: v6(135.28,103.77) 135.5,103.56 135.5,103.56 U7901.N4 ; U7000.P5 v6(118.7,125.5)
FBD_D57: length 39.2
  IN1 w0.095: v6(118.7,126.3) 118.17,125.77 118.17,124.7 119.93,122.94 119.93,120.31 123.04,117.19 130.6,117.19 132.2,115.59 132.2,108.39 133.83,106.76 133.83,105.98 134.62,105.2 134.62,103.5 134.83,103.29 134.83,102.93 135.19,102.57 136.21,102.57 136.6,102.17 v6(136.91,102.17)
  BOTTOM w0.133: v6(136.91,102.17) 136.91,101.35 U7901.T2 ; U7000.P6 118.3,125.9 v6(118.7,126.3)
FBD_D58: length 37.7
  TOP w0.133: v6(118.97,121.54) 119.36,121.54 v1(119.79,121.96)
  IN1 w0.095: v6(118.97,121.54) 118.65,121.22 118.65,119.37 123.39,114.62 129.25,114.62 130.1,113.77 130.1,107.52 130.99,106.63 130.99,106.06 132.51,104.53 132.51,102.46 133.64,101.33 133.64,101.33 133.69,101.28 134.44,100.53 134.81,100.16 134.92,100.16 134.98,100.16 134.99,100.16 136.39,100.16 136.8,100.57 v6(137.69,100.57)
  BOTTOM w0.133: U7901.U2 137.29,100.17 v6(137.69,100.57) ; U7000.P2 118.66,122.34 118.66,121.84 v6(118.97,121.54)
FBD_D59: length 34.4
  TOP w0.133: v1(119.74,120.36) 119.12,120.97 v6(119.02,120.97)
  IN1 w0.095: v6(119.02,120.97) 119.02,119.39 123.39,115.03 130.48,115.03 130.91,114.59 130.91,107.85 132.54,106.23 132.54,105.38 132.89,105.03 132.89,102.48 134.82,100.56 v6(135.31,100.56)
  BOTTOM w0.133: U7000.P1 118.3,121.54 118.87,120.97 v6(119.02,120.97) ; U7901.U4 v6(135.31,100.56)
FBD_D60: length 33.6
  TOP w0.133: v6(135.33,104.53) 135.02,104.53 v1(134.29,105.26)
  IN1 w0.095: v6(119.5,124.7) 119.5,124.44 120.3,123.64 120.3,120.75 123.28,117.77 130.83,117.77 132.77,115.83 132.77,108.63 134.51,106.88 134.51,106.58 134.51,106.11 134.52,106.11 135.33,105.3 v6(135.33,104.53)
  BOTTOM w0.133: U7901.M4 v6(135.33,104.53) ; U7000.M5 v6(119.5,124.7)
FBD_D61: length 36.5
  TOP w0.133: v1(138.24,103.51) v6(137.69,102.96)
  IN1 w0.095: v6(137.69,102.96) 137.69,103.16 137.1,103.76 137.1,104.37 135.27,106.19 135.27,106.93 133.34,108.86 133.34,116.06 131.07,118.34 123.59,118.34 121.56,120.36 121.35,120.36 120.7,121.01 120.7,123.77 120.17,124.3 120.17,124.84 v6(119.5,125.5)
  BOTTOM w0.133: U7901.N2 137.69,102.97 v6(137.69,102.96) ; U7000.M6 v6(119.5,125.5)
FBD_D62: length 36.4
  TOP w0.133: v1(138.21,105.59) 138.21,105.06 v6(137.72,104.56)
  IN1 w0.095: v6(137.72,104.56) 137.14,105.14 137.14,105.59 135.25,107.48 135.13,107.48 133.63,108.98 133.63,116.18 131.19,118.62 127.39,118.62 126.59,119.42 125.77,119.42 125.17,120.02 123.85,120.02 123.47,119.64 122.76,119.64 122.56,119.85 122.56,121.79 121.01,123.33 121.01,123.71 120.35,124.37 120.35,125.41 v6(119.48,126.28)
  BOTTOM w0.133: U7901.M2 137.49,104.37 137.53,104.37 v6(137.72,104.56) ; U7000.M7 119.76,126.56 119.76,126.56 v6(119.48,126.28)
FBD_D63: length 42.1
  TOP w0.133: v1(117.98,126.2) 117.98,126.38 v6(118.7,127.09)
  IN1 w0.095: v6(118.7,127.09) 117.88,126.28 117.88,124.63 118.16,124.35 118.16,123.11 118.6,122.67 119.25,122.67 119.46,122.46 119.46,119.36 122.63,116.19 130.18,116.19 131.2,115.17 131.2,107.97 132.82,106.35 132.82,105.5 133.18,105.14 133.18,102.6 134.8,100.98 135.68,100.98 v6(136.12,100.54)
  BOTTOM w0.133: U7000.P7 118.3,126.7 v6(118.7,127.09) ; U7901.T4 v6(136.12,100.54)
FBD_DEBUG0: length 7.2
  BOTTOM w0.102: v1(110.08,117.16) 110.5,117.58 110.5,117.91 110.77,118.18 R7122.1 110.68,118.55 110.68,123.12 U7000.AD3
FBD_DEBUG1: length 6.7
  TOP w0.089: v6(123.08,120.13) 123.38,119.83 R7123.1 125.3,119.83 v1(125.78,119.35)
  BOTTOM w0.102: v6(123.08,120.13) 122.67,120.54 122.67,123.14 U7000.J3
FBD_DQM0: length 32.1
  IN4 w0.095: v6(107.46,129.44) 108.53,128.37 108.53,122.38 109.3,121.61 109.3,120.89 110.44,119.75 110.44,119.01 112.13,117.31 112.13,106.52 112.95,105.7 112.95,104.54 113.46,104.03 114.1,104.03 115.2,102.93 v6(115.2,102.1)
  BOTTOM w0.133: U7000.AG10 107.69,129.31 107.59,129.31 v6(107.46,129.44) ; U7900.D2 v6(115.2,102.1)
FBD_DQM1: length 31.6
  TOP w0.133: v6(112.3,124.7) 112.9,124.1 v1(112.9,124)
  IN1 w0.095: v6(123.97,102.91) 123.59,103.29 121.39,103.29 121.33,103.34 121.32,103.34 121.06,103.61 121.06,103.72 120.78,104 120.62,104 120,104.62 120,105.03 119.31,105.72 119.31,114.65 114.14,119.82 113.72,119.82 112.87,120.67 112.87,121.26 111.12,123 111.12,124.06 111.39,124.32 111.92,124.32 v6(112.3,124.7)
  BOTTOM w0.133: U7000.AA5 v6(112.3,124.7) ; U7900.D13 v6(123.97,102.91)
FBD_DQM2: length 21.8
  TOP w0.133: v1(115.64,126.25) 115.69,126.3 v6(116.3,126.3)
  IN4 w0.095: v6(116.3,126.3) 116.69,125.91 117.53,125.91 118.26,125.18 118.26,122.85 118.49,122.62 118.49,119.21 122.23,115.47 122.23,114.54 123.75,113.02 123.75,110.73 v6(123.16,110.15)
  BOTTOM w0.133: v6(123.16,110.15) 123.37,110.36 123.42,110.36 U7900.P13 ; U7000.U6 115.9,125.9 v6(116.3,126.3)
FBD_DQM3: length 19.6
  TOP w0.133: v6(112.29,127.09) 112.23,127.03 v1(112.23,126.48)
  IN2 w0.089: 112.65,122.72 112.69,122.77 112.69,126.69 v6(112.29,127.09)
  IN2 w0.146: 112.65,122.72 112.65,118.91 114.78,116.78 114.78,115.05 114.34,114.61 114.34,113.08 114.34,112.89 115.01,112.21 115.01,111.12 v6(115.2,110.93)
  BOTTOM w0.133: v6(112.29,127.09) 112.7,127.5 U7000.AA8 ; U7900.P2 115.19,110.93 v6(115.2,110.93)
FBD_DQM4: length 22.8
  TOP w0.133: v1(125.9,122.39) v6(125.9,123.1)
  IN1 w0.095: v6(125.9,123.1) 126.29,123.48 129.29,123.48 130.45,122.32 132.04,122.32 136.85,117.52 136.85,115.44 138.3,113.99 138.3,113.55 138.2,113.45 138.2,111.52 v6(137.68,111)
  BOTTOM w0.133: U7000.E3 v6(125.9,123.1) ; U7901.D2 137.48,110.76 137.48,110.8 v6(137.68,111)
FBD_DQM5: length 22.3
  TOP w0.133: v1(122.53,124.3) 122.53,124.86 v6(121.84,125.54)
  IN4 w0.095: v6(121.84,125.54) 121.46,125.16 121.46,124.59 120.89,124.02 120.89,119.75 124.78,115.86 126.81,115.86 127.22,115.45 127.22,114.69 127.86,114.05 127.86,113.43 128.45,112.85 128.45,111.61 128.92,111.13 v6(128.92,110.96)
  BOTTOM w0.133: U7901.D13 128.65,110.72 128.69,110.72 v6(128.92,110.96) ; U7000.J5 122.08,125.32 122.06,125.32 v6(121.84,125.54)
FBD_DQM6: length 32.9
  TOP w0.133: v6(128.07,102.99) 128.07,103.6 v1(128.06,103.6)
  IN2 w0.089: v6(116.3,127.9) 116.71,127.49 116.71,126.96 116.95,126.73 117.21,126.73 117.5,126.43 117.5,125.37 117.27,125.14 116.92,125.14 116.71,124.93 116.71,124.31 116.72,124.3
  IN2 w0.146: v6(128.07,102.99) 127.48,102.99 126.65,103.82 126.65,104.74 125.47,105.92 125.47,108.04 125.12,108.4 125.12,112.79 117.12,120.78 117.12,123.35 116.72,123.75 116.72,124.3
  BOTTOM w0.133: v6(128.07,102.99) U7901.P13 ; U7000.U8 115.9,127.5 v6(116.3,127.9)
FBD_DQM7: length 36.6
  TOP w0.133: v6(119.5,123.9) 119.51,123.9 119.51,123.43 119.62,123.31 119.62,123.3 v1(119.63,123.3)
  IN1 w0.095: v6(119.5,123.9) 120.11,123.29 120.11,120.53 123.16,117.48 130.71,117.48 132.49,115.71 132.49,108.51 134.23,106.77 134.23,106.46 134.23,105.99 134.9,105.32 134.9,103.62 135.12,103.4 137.02,103.4 137.26,103.16 137.26,102.56 v6(137.67,102.15)
  BOTTOM w0.133: U7000.M4 v6(119.5,123.9) ; v6(137.67,102.15) 137.45,102.36 137.45,102.41 U7901.P2
FBD_DQS_WP0: length 28.2
  TOP w0.133: v1(106.86,124.1) 106.9,124.1 v6(107.5,124.7)
  IN4 w0.095: v6(114.36,102.07) 114.36,102.24 113.72,102.88 113.18,102.88 112.17,103.9 112.17,105.38 111.35,106.19 111.35,116.99 109.91,118.43 109.91,118.86 109.19,119.58 108.5,119.58 107.95,120.12 107.95,124.25 v6(107.5,124.7)
  BOTTOM w0.133: v6(114.36,102.07) 114.54,101.89 114.61,101.89 U7900.C2 ; U7000.AG5 v6(107.5,124.7)
FBD_DQS_WP1: length 33.4
  IN1 w0.095: v6(123.22,102.12) 122.79,101.7 121.87,101.7 121.45,102.12 121.08,102.12 120.82,102.38 119.9,102.38 119.22,103.06 119.22,104.7 118.52,105.39 118.52,114.04 112.23,120.34 112.23,121.29 110.64,122.88 110.64,125.8 v6(109.74,126.7)
  BOTTOM w0.133: v6(123.22,102.12) 123.22,102.08 U7900.C13 ; v6(109.74,126.7) U7000.AD7
FBD_DQS_WP2: length 22.3
  IN4 w0.095: v6(114.71,127.11) 115.7,126.12 115.7,123.11 116.26,122.55 116.26,118.82 120.29,114.79 120.29,113.05 120.66,112.68 120.66,112.14 120.44,111.92 120.44,111.6 120.66,111.38 121.27,111.38 121.43,111.22 122.2,111.22 122.27,111.29 122.81,111.29 v6(123.19,110.91)
  BOTTOM w0.133: U7900.R13 123.5,111.24 123.5,111.22 v6(123.19,110.91) ; v6(114.71,127.11) U7000.V8
FBD_DQS_WP3: length 19.2
  IN2 w0.146: v6(114.39,110.93) 113.84,111.47 113.84,111.79 113.58,112.06 113.3,112.06 113,112.35 113,117.07 111.8,118.28 111.8,121.79 110.85,122.74 110.85,125.73 111.53,126.41 v6(111.56,126.41)
  BOTTOM w0.133: v6(111.56,126.41) 112.41,126.41 112.7,126.7 U7000.AA7 ; U7900.R2 114.63,111.17 114.62,111.17 v6(114.39,110.93)
FBD_DQS_WP4: length 24.7
  TOP w0.133: v6(137.69,111.75) 138.45,111.75 138.47,111.77 v1(139.23,111.77)
  IN1 w0.095: v6(137.69,111.75) 136.98,112.47 136.98,113.66 135.78,114.86 135.78,117.07 131.6,121.25 129.57,121.25 128.68,122.14 125.25,122.14 124.35,123.03 124.35,123.95 v6(125.1,124.7)
  BOTTOM w0.133: U7000.F4 124.7,124.3 v6(125.1,124.7) ; v6(137.69,111.75) 137.49,111.54 137.47,111.54 U7901.C2
FBD_DQS_WP5: length 20.9
  IN4 w0.095: v6(121.16,126.3) 120.85,126.3 120.4,125.85 120.4,119.13 123.76,115.76 123.76,115.32 126.32,112.77 127.38,112.77 127.57,112.58 127.57,111.63 128.07,111.13 v6(128.07,110.94)
  BOTTOM w0.133: U7000.L7 120.89,126.51 120.95,126.51 v6(121.16,126.3) ; U7901.C13 128.49,111.36 v6(128.07,110.94)
FBD_DQS_WP6: length 34.3
  TOP w0.133: v1(129.08,102.01) 129.08,101.62 v6(128.86,101.4)
  IN2 w0.089: 117.54,124.21 117.69,124.37 117.69,127.28 v6(117.09,127.88)
  IN2 w0.146: 117.54,124.21 117.54,120.92 119.1,119.36 119.32,119.36 125.67,113.02 125.67,110.09 126.04,109.72 126.04,109.35 125.67,108.98 125.67,108.63 126.03,108.27 126.03,107.48 126.61,106.9 126.61,106.47 126.61,105.64 127.01,105.24 127.38,105.24 127.7,104.93 127.7,104.14 128.98,102.86 128.98,102.61 128.73,102.35 128.73,101.87 128.86,101.74 v6(128.86,101.4)
  BOTTOM w0.133: v6(128.86,101.4) 128.86,101.66 128.75,101.77 U7901.R13 ; v6(117.09,127.88) 117.23,127.74 117.26,127.74 U7000.R8
FBD_DQS_WP7: length 37.8
  TOP w0.133: v1(118.38,123.83) 118.7,123.51 v6(118.7,123.1)
  IN1 w0.095: v6(137.67,101.39) 136.6,101.39 136.22,101.77 135.12,101.77 134.57,102.32 134.16,102.32 133.68,102.81 133.68,105.35 133.33,105.71 133.33,106.55 131.7,108.18 131.7,115.38 130.39,116.69 122.84,116.69 119.67,119.86 119.67,122.67 119.24,123.1 v6(118.7,123.1)
  BOTTOM w0.133: U7000.P3 v6(118.7,123.1) ; U7901.R2 137.67,101.39 v6(137.67,101.39)
FBD_MF1: length 4.6
  BOTTOM w0.203: U7900.J1 113.12,106.52 112.72,106.92 112.2,106.92 v1(111.71,107.41) 111.38,107.08 R7916.1 R7915.2
FBD_MF2: length 2.9
  TOP w0.203: v1(139.29,107) 139.2,107 v6(138.81,106.62) 138.61,106.82 R7918.1 R7917.2
  BOTTOM w0.203: U7901.J1 138.76,106.57 v6(138.81,106.62)
FBD_VREF_CA1: length 46.9
  TOP w0.254: v1(126.49,104.99) 126.49,104.71 v6(126.14,104.36)
  TOP w0.305: v2(137.87,117.42) 137.25,118.03 R7909.2
  TOP w0.381: v6(126.21,106.73) 126.18,106.73 C7905.1 125.63,107.03 125.12,106.52 ; v6(124.89,106.52) 125.12,106.52 ; 125.12,106.52 125.25,106.52 125.63,106.14 C7903.1 125.63,105.58 125.58,105.53 R7911.2 R7910.1 125.7,103.93 v6(126.14,104.36)
  IN1 w0.381: v2(137.87,117.42) 138.15,117.14 138.15,115.78 139.89,114.04 139.89,110.62 139.09,109.82 139.09,109.31 138.24,108.46 138.24,106.3 139.2,105.34 139.2,101.05 139.19,101.03 139.19,100 138.22,99.03 135.99,99.03 135.65,98.68 132.4,98.68 131.06,100.02 127.38,100.02 126.54,100.86 126.54,103.95 v6(126.14,104.36)
  BOTTOM w0.254: U7901.J14 126.37,106.57 v6(126.21,106.73)
  BOTTOM w0.305: v6(124.89,106.52) U7900.J14
FBD_VREF_DQ1: length 83.1
  TOP w0.305: R7908.2 137.4,118.97 140.09,116.27 v2(140.09,109.52)
  TOP w0.381: v6(129.16,99.43) 129.49,99.76 C7904.1 130.1,99.74 130.38,99.46 v6(130.89,99.46) 131.06,99.62 v1(131.06,100.14) ; v6(119,100.17) 119.22,99.95 119.22,99.24 118.72,98.74 C7900.1 R7901.2 R7900.1 116.22,98.74 v6(115.9,99.05)
  IN2 w0.381: v6(130.89,99.46) 131.72,99.46 132.59,100.32 132.59,100.79 133.5,101.7 133.5,104.66 134.05,105.21 136.21,105.21 138.02,107.02 138.02,108.19 139.35,109.52 v2(140.09,109.52)
  IN4 w0.381: v6(129.16,99.43) 128.23,98.5 121.69,98.5 120.88,99.32 120,99.32 119.74,99.05 v6(115.9,99.05)
  BOTTOM w0.203: U7900.U10 121.18,113.5 121.64,113.96 122.3,113.96 122.72,113.54
  BOTTOM w0.305: v6(119,100.17) 119.61,99.56 120.62,99.56 U7900.A10 ; U7901.U10 v6(130.89,99.46) 130.07,99.46 129.52,98.9 127.31,98.9 125.96,100.24 125.55,100.24 125.33,100.46 125.33,106.27 125.45,106.4 125.45,113.4 125.45,113.4 ; 125.45,113.4 128.07,113.4 128.81,114.14 129.71,114.14 129.98,113.87 129.99,113.87 U7901.A10 ; 125.45,113.4 122.86,113.4 122.72,113.54
FBD_WCK01: length 28.3
  IN1 w0.102: v7(116.79,102.91) 116.49,102.61 116.34,102.61 115.93,103.01 115.24,103.01 114.71,103.55 114.71,107.43 114,108.15 114,115.09 109.58,119.51 109.58,121.22 108.59,122.21 108.59,124.23 108.68,124.33 108.92,124.33 109.1,124.14 v6(109.1,123.95)
  BOTTOM w0.133: v7(116.79,102.91) 116.47,102.91 116.38,102.82 U7900.D4 ; v6(109.1,123.95) 108.85,123.95 108.8,123.9 108.71,123.9 108.59,124.03 108.59,124.18 U7000.AF4
FBD_WCK01#: length 28.2
  IN1 w0.102: v7(109.1,124.7) 108.95,124.55 108.64,124.55 108.39,124.31 108.39,122.14 109.39,121.14 109.39,119.43 113.8,115.01 113.8,108.07 114.52,107.36 114.52,103.47 115.16,102.82 115.85,102.82 116.26,102.42 116.5,102.42 v6(116.79,102.13)
  BOTTOM w0.133: U7000.AF5 v7(109.1,124.7) ; U7900.D5 v6(116.79,102.13)
FBD_WCK23: length 30.8
  IN4 w0.102: v6(113.97,128.72) 113.69,129 113.42,129 113.12,128.69 113.12,126.75 112.74,126.37 112.74,125.96 113.12,125.58 113.12,123.19 113.49,122.82 113.49,121.84 113.27,121.63 112.84,121.63 112.74,121.53 112.74,121.22 112.84,121.12 113.52,121.12 113.75,120.88 113.75,120.47 113.52,120.23 112.84,120.23 112.74,120.13 112.74,119.82 112.84,119.72 113.49,119.72 113.94,119.27 113.94,118.3 115.07,117.18 115.26,116.99 115.26,116.3 115.39,116.16 116.08,116.16 116.57,115.68 116.57,115.38 115.87,114.68 115.87,114.5 116.12,114.25 116.3,114.25 117,114.94 117.3,114.94 118.42,113.83 118.42,113.22 117.83,112.63 117.83,112.5 118.42,111.91 118.42,110.62 118.08,110.28 116.92,110.28 v7(116.79,110.15)
  BOTTOM w0.133: U7000.Y9 113.69,128.49 113.74,128.49 v6(113.97,128.72) ; U7900.P4 116.5,110.39 116.55,110.39 v7(116.79,110.15)
FBD_WCK23#: length 30.8
  IN4 w0.102: v6(114,129.3) 113.46,129.3 112.93,128.77 112.93,126.83 112.55,126.45 112.55,125.88 112.93,125.5 112.93,123.11 113.3,122.74 113.3,121.92 113.2,121.82 112.76,121.82 112.55,121.6 112.55,121.14 112.76,120.93 113.44,120.93 113.56,120.8 113.56,120.55 113.44,120.42 112.76,120.42 112.55,120.21 112.55,119.74 112.76,119.53 113.41,119.53 113.75,119.19 113.75,118.22 114.8,117.18 115.07,116.91 115.07,116.22 115.31,115.97 116.01,115.97 116.38,115.6 116.38,115.46 115.68,114.76 115.68,114.42 116.05,114.06 116.38,114.06 116.7,114.37 117.08,114.75 117.22,114.75 118.23,113.75 118.23,113.3 117.64,112.7 117.64,112.43 118.23,111.83 118.23,110.7 118,110.47 117.23,110.47 v6(116.79,110.91)
  BOTTOM w0.133: v6(116.79,110.91) 116.79,110.9 U7900.P5 ; U7000.Y10 113.8,129.1 v6(114,129.3)
FBD_WCK45: length 25.9
  TOP w0.133: 133.38,114.72 133.38,113.82 133.66,113.54 133.88,113.54 134.01,113.4 134.01,113.03 133.88,112.89 133.66,112.89 133.38,112.61 133.38,111.27 134.26,110.38 135.08,110.38 v6(135.31,110.15) ; 133.38,114.72 133.38,116.62 129.01,120.99 129.01,124.57 127.66,125.92 123.92,125.92 v6(123.5,125.5) ; 133.38,114.72 v1(133.16,114.72)
  BOTTOM w0.133: U7000.H6 123.27,125.73 123.27,125.73 v6(123.5,125.5) ; U7901.D4 135.69,110.57 135.53,110.42 135.53,110.38 v6(135.31,110.15)
FBD_WCK45#: length 25.9
  TOP w0.133: 133.63,116.35 133.63,113.92 133.76,113.79 133.98,113.79 134.26,113.51 134.26,112.92 133.98,112.64 133.76,112.64 133.63,112.51 133.63,111.37 134.37,110.63 134.95,110.63 v6(135.28,110.96) ; 133.63,116.35 133.63,116.73 129.26,121.09 129.26,124.68 127.76,126.18 123.62,126.18 v6(123.5,126.3) ; 133.63,116.35 v1(133.85,116.35)
  BOTTOM w0.133: v6(135.28,110.96) 135.07,110.75 135.07,110.75 U7901.D5 ; v6(123.5,126.3) 123.24,126.3 123.1,126.44 U7000.H7
FBD_WCK67: length 36.9
  TOP w0.133: v1(126.26,117.19) 126.26,116.96 ; 126.26,116.96 126.73,116.96 128.67,115.02 129.48,115.02 132.66,111.83 132.66,108.25 133.41,107.5 133.41,104.66 134.23,103.84 134.54,103.84 135.12,103.26 135.12,103.26 135.13,103.25 135.13,103.16 v6(135.28,103.01) ; 126.26,116.96 124.38,116.96 120.65,120.69 120.65,123.41 120.24,123.82 120.24,127.32 120.16,127.41 119.84,127.73 119.84,128.03 119.94,128.13 120.07,128.13 v6(120.3,127.9)
  BOTTOM w0.133: v6(135.28,103.01) 135.74,103.01 135.85,102.9 135.85,102.73 U7901.P4 ; U7000.M8 119.9,127.17 120.03,127.05 120.17,127.05 120.3,127.17 v6(120.3,127.9)
FBD_WCK67#: length 36.8
  TOP w0.133: 124.66,116.71 v1(124.66,116.48) ; 124.66,116.71 124.28,116.71 120.4,120.59 120.4,123.31 119.99,123.71 119.99,127.22 119.86,127.35 119.78,127.43 119.56,127.65 119.56,128.18 119.76,128.39 119.99,128.39 v6(120.3,128.7) ; 124.66,116.71 126.63,116.71 128.57,114.76 129.37,114.76 132.41,111.73 132.41,108.15 133.16,107.4 133.16,104.56 134.13,103.59 134.44,103.59 134.86,103.16 134.86,103.15 134.87,103.14 134.87,102.81 135.27,102.41 v6(135.27,102.19)
  BOTTOM w0.133: U7000.M9 120.06,128.46 120.07,128.46 v6(120.3,128.7) ; U7901.P5 v6(135.27,102.19)
FBD_ZQ0: length 2.6
  TOP w0.102: R7912.2 123.88,105.76 123.41,105.29 v6(123.23,105.29)
  BOTTOM w0.102: v6(123.23,105.29) 123.23,105.89 123.58,106.23 U7900.J13
FBD_ZQ1: length 8.3
  TOP w0.203: v2(125.9,102.41) 125.58,102.74 R7913.2
  TOP w0.254: v2(125.9,102.41) 126.01,102.3 v1(126.87,102.3)
  BOTTOM w0.203: U7901.J13 128.11,106.19 127.54,106.19 127.52,106.2 126.45,106.2 126.27,106.02 126.27,104.93 126.62,104.58 126.62,103.13 v2(125.9,102.41)
FBVDDQ_SENSE: length 155.1
  TOP w0.203: v2(178.2,89.79) 178.11,89.69 R8909.1 178.25,88.96 178.25,88.55 C8907.2 179.39,87.4 U8900.12
  IN1 w0.254: v2(134.42,174.97) 134.42,175.21 141.32,182.11 154,182.11 156.76,179.35 156.76,167.9 155.15,166.29 155.15,158.5 155.76,157.88 155.76,155.22 156.49,154.49 157,154.49 157.45,154.04 157.45,152.21 156.78,151.54 156.78,150.55 158.55,148.79 158.55,115.66 159.72,114.49 159.97,113.8 159.97,113.5 160.13,113.34 160.17,113.25 160.3,112.87 160.42,112.54 160.65,111.91 161.39,109.84 161.39,106.18 159.67,104.46 158.99,103.32 158.71,102.72 158.42,101.76 158.31,101.03 158.31,99.33 158.4,98.79 158.43,98.56 158.51,98.29 158.86,97.38 158.88,97.32 159.16,96.89 159.62,96.31 161.98,93.95 164.77,93.95 166.42,92.3 175.75,92.3 176.13,92.08 178.2,90.01 v2(178.2,89.79)
  BOTTOM w0.203: v2(134.42,174.97) v1(134.42,173.19) 134.42,172.53 133,171.12 133,168.86 129.72,165.57 126.95,165.57 R7503.2
FBX_PLL_AVDD: length 66.3
  TOP w0.254: C7106.1 119.61,142.14 v6(119.69,142.06)
  TOP w0.381: C7105.1 112.63,130.18 112.61,130.18 v6(112.32,130.47)
  IN1 w0.381: v6(112.32,130.47) 112.51,130.66 112.51,130.95 113.1,131.55 118.33,131.55 118.96,132.17 118.96,141.36 119.66,142.06 v6(119.69,142.06)
  IN2 w0.381: v6(106.73,152.8) 106.73,152.41 107.24,151.91 107.24,151.71 108.18,150.76 116.48,150.76 116.94,150.31 v6(120.12,150.31) 120.12,149.9 119.67,149.46 119.27,149.46 118.97,149.16 118.97,142.78 v6(119.69,142.06)
  IN4 w0.381: v2(102.54,163.84) 101.28,162.59 101.28,161.18 101.26,161.16 101.26,160.66 101.31,160.61 101.31,157.78 100.58,157.05 100.58,154.09 102.02,152.64 103.99,152.64 104.36,152.28 106.21,152.28 v6(106.73,152.8)
  BOTTOM w0.203: v6(119.69,142.06) 119.85,141.9 U7000.L26
  BOTTOM w0.254: U7000.AJ39 106.3,152.23 106.73,152.66 v6(106.73,152.8) ; U7000.AA11 112.33,130.47 v6(112.32,130.47)
  BOTTOM w0.305: U7000.L36 v6(120.12,150.31)
  BOTTOM w0.381: v2(102.54,163.84) 102.79,164.1 C7102.1 103.77,164.57 L7100.1
  vias: v1(119.51,150.21)
FCCM_A: length 72
  TOP w0.102: v2(44.37,175.53) 44.37,175.71 v1(43.83,176.26)
  TOP w0.203: v2(52.77,171.98) 53.04,171.72 55.13,171.72 55.92,172.51 56.74,172.51 57.54,171.72 64.94,171.72 65.5,172.28 66.11,172.28 67.21,171.18 U8003.2 ; U8001.2 44.23,175.25 44.37,175.4 v2(44.37,175.53) ; v2(33.45,175.52) 33.44,175.52 33.3,175.38 U8002.2
  IN1 w0.203: v2(33.45,175.52) 33.45,174.92 33.99,174.39 43.86,174.39 44.37,174.9 v2(44.37,175.53) 44.37,175.91 44.53,176.07 46.23,176.07 48.8,173.5 50.63,173.5 52.15,171.98 v2(52.77,171.98)
  IN1 w0.254: v2(33.45,175.52) 33.45,175.91 32.62,176.75 27.2,176.75 25.09,174.64 23.38,174.64 22.92,175.1 19.33,175.1 19.33,175.1 18.52,175.1 18.06,175.56 14.48,175.56 13.52,174.59 10.32,174.59 9.86,174.13 v2(7.42,174.13)
  BOTTOM w0.203: U8000.24 7.6,174.3 v2(7.42,174.13)
FCCM_B: length 31.5
  TOP w0.102: v1(22.2,172.92) 22.2,172.63 v2(22.58,172.25)
  TOP w0.254: v2(9.88,167.17) 9.94,167.11 U8006.2 ; v2(22.58,172.25) 22.58,172.15 22.38,171.95 U8004.2
  IN4 w0.254: v2(22.58,172.25) 22.58,172.48 22.28,172.79 19.8,172.79 13.98,166.97 13.98,166.55 13.19,165.76 10.94,165.76 9.88,166.81 v2(9.88,167.17) 10.06,167.34 10.06,168.01 12.9,170.86 12.9,173.7 13.85,174.64 v2(14.91,174.64)
  BOTTOM w0.203: v2(14.91,174.64) 14.54,174.64 13.8,175.38 U8000.11
FCCM_C: length 75.7
  TOP w0.102: v2(5.89,179.31) 5.64,179.57 v1(5.64,180.18)
  IN1 w0.254: v2(69.99,168.16) 69.99,168.38 69.65,168.72 59.64,168.72 58.09,170.27 58.09,172.31 53.5,176.9 35.33,176.9 34.41,177.81 26.75,177.81 25.94,177 20.6,177 18.65,178.96 14.94,178.96 13.9,177.92 7.21,177.92 5.89,179.23 v2(5.89,179.31)
  BOTTOM w0.203: U8000.34 6.68,178.58 6.43,178.83 6.13,178.83 5.89,179.07 v2(5.89,179.31)
  BOTTOM w0.254: v2(69.99,168.16) 69.91,168.25 U8005.7
FORCE_OFF#: length 34.7
  TOP w0.102: Q9200.6 140.56,50.54 140.49,50.61 140.49,52.67 140.26,52.91 T9206.1 v2(139.37,53.81) ; R5014.1 118.69,53.35 D5004.2 118.91,52.22 118.91,51.51 119.13,51.3 119.13,49.74 v2(119.24,49.62)
  IN2 w0.102: v2(119.24,49.62) 119.24,49.29 119.9,48.63 123.02,48.63 124.26,49.88 125.39,49.88 125.83,50.32 134.05,50.32 v2(134.59,49.78)
  BOTTOM w0.102: v2(139.37,53.81) 138.91,54.27 136.26,54.27 134.59,52.6 v2(134.59,49.78)
FORCE_OFF_PWR: length 162.3
  TOP w0.102: Q9200.2 137.19,49.67 C9200.1 ; v2(212.03,85.75) 212.03,85.34 212.7,84.68 216.97,84.68 217.22,84.93 Q8106.5 Q8106.2 ; C9200.1 R9205.1 137.21,51.15 138.53,51.15 v2(138.86,51.48) ; C9200.1 R9204.2 v1(136.88,47.46) 137.29,47.46 137.72,47.89 137.72,48.82 137.91,49.02 Q9200.3
  IN2 w0.102: v2(137.8,33.82) 137.81,33.82 140.19,36.2 147.12,36.2 147.78,36.86 167.23,36.86 167.77,36.33 184.28,36.33 185.13,37.18 196.27,37.18 196.55,36.9 198.93,36.9 199.67,37.64 203.58,37.64 207.06,41.11 207.96,41.11 209.78,42.93 209.78,46.17 209.59,46.36 209.59,47.97 210.85,49.23 210.85,55.01 213.02,57.19 213.02,59.51 216.2,62.68 216.2,64.4 212.19,68.41 212.19,77.8 211.56,78.43 211.56,79.46 210.72,80.3 210.72,84.41 212.03,85.72 v2(212.03,85.75)
  BOTTOM w0.102: v2(137.8,33.82) 137.8,34.04 136.86,34.99 136.86,49.47 v2(138.86,51.48)
FP_RST_DBR_N_CPUXDP: length 13.8
  BOTTOM w0.102: XDP4400.48 4.72,129.85 5.32,129.25 5.87,129.25 6.14,128.99 6.14,126.66 5.16,125.68 5.16,121.91 C4402.1 4.24,121 4.24,120.95 v1(3.76,120.46) 4.12,120.11 R4419.1
G1: length 6.9
  BOTTOM w0.102: U3700.11 202.15,31.17 202.62,30.7 202.62,30.19 201.79,29.37 v1(201.79,29.32) 202.01,29.1 202.84,29.1 203.28,29.53 203.28,29.91 203.51,30.14 R3709.2 204.39,30.45 204.27,30.57 R3707.1
G2: length 8
  TOP w0.102: v1(201.29,30.65) 201.24,30.6 v2(201.24,29.99)
  IN3 w0.102: v2(202.62,29.51) 202.14,29.99 v2(201.24,29.99)
  BOTTOM w0.102: v2(202.62,29.51) 202.62,29.82 202.97,30.18 202.97,30.5 R3708.1 ; U3700.12 202.22,30.72 202.36,30.57 202.36,30.32 202.03,29.99 v2(201.24,29.99) 200.19,29.99 199.85,29.65 R3710.2
GATE_SQ14: length 11.1
  TOP w0.102: Q3102.1 152.96,31.02 152.77,31.21 152.27,31.21 151.88,30.81 Q3100.1 151.88,29.22 152.83,28.26 153.24,28.26 v1(153.59,27.91) 154.23,28.54 155.63,28.54 156.52,29.43 R3114.1 R3112.1
GC6_FB_EN: length 347.5
  IN1 w0.102: v2(118.52,37.64) 118.52,38.02 118.86,38.36 126.54,38.36 127.96,36.95 132.68,36.95 133.39,37.66 134.49,37.66 135.38,38.55 144.29,38.55 145.9,36.95 173.24,36.95 174.77,38.48 178.22,38.48 178.97,37.73 178.97,37.18 180.43,35.73 181.58,35.73 181.81,35.49 181.81,35.3 v2(182.4,34.71)
  IN3 w0.102: v2(118.52,37.64) 117.97,38.19 115.57,38.19 115.11,37.74 82.23,37.74 81.84,38.12 58.18,38.12 57.28,39.01 42.31,39.01 38.19,43.13 38.19,47.6 35.2,50.59 35.2,53.85 33.53,55.52 33.53,56.22 29.39,60.36 29.39,61.55 29.26,61.67 29.26,62.88 29.85,63.47 29.85,67.47 27.99,69.33 27.99,80.32 27.39,80.92 27.39,81.21 27.32,81.28 27.32,92.04 25.18,94.18 25.18,95.35 25.78,95.96 25.78,104.8 25.14,105.45 24.16,105.45 23.95,105.66 23.95,106.68 24.17,106.9 27.81,106.9 32.19,111.28 62.47,111.28 63.2,110.55 63.2,109.84 v2(62.94,109.58)
  BOTTOM w0.089: U2000.AV43 178.26,41.82 178.26,40.85 179.35,39.76 180.55,39.76 181.11,39.21 181.42,39.21
  BOTTOM w0.102: v2(62.94,109.58) 62.92,109.58 62.93,109.57 63.81,109.57 63.98,109.4 79.13,109.4 81.31,111.57 v1(81.97,111.57) 91.37,111.57 91.76,111.19 95.93,111.19 96.49,110.63 96.49,108.9 97.31,108.08 105.23,108.08 105.53,108.38 105.53,109.98 105.4,110.11 105.4,114.48 104.7,115.18 104.7,117.31 D7402.1 104.4,117.82 R7436.1 104.17,118.48 104.24,118.56 104.24,126.04 104.04,126.24 102.96,126.24 102.76,126.04 102.13,126.04 101.84,126.32 101.84,126.84 101.64,127.04 101.04,127.04 U7000.AT7 ; 181.42,39.21 182.07,38.56 182.07,35.06 181.81,34.8 181.81,34.51 R2357.2 181.79,34.1 v2(182.4,34.71)
GEN1_I2C_SCL: length 4.3
  TOP w0.114: U5800.12 249,126.65 248.02,125.67 v1(246.74,125.67) R5803.2
GEN1_I2C_SDA: length 4.1
  TOP w0.114: R5804.2 v1(249.43,123.26) 250.25,124.08 U5800.2
GPD8_SUSCLK: length 15.4
  TOP w0.102: T2411.1 174.78,69.69 174.78,68.37 174.8,68.35 R2458.1 175.46,67.22 175.46,66.79 175.97,66.28 175.97,65.27 175.57,64.86 175.57,62.69 175.77,62.49 175.77,61.41 175.57,61.21 175.57,57.18 v2(176.2,56.54)
  BOTTOM w0.089: v2(176.2,56.54) U2000.AN15
GPG2_EC: length 8.5
  TOP w0.102: R3084.1 132.27,31.35 v1(132.09,31.17) 132.09,30.84 131.74,30.49 130.7,30.49 R3001.2 129.79,30.42 128.98,30.42 128.62,30.78 128.62,31.15 128.14,31.62 128.14,32.07 127.86,32.35 U3001.100
GPIO0: length 6
  TOP w0.076: 238.9,49 239.34,49.44 239.74,49.44 U1201.B2
  TOP w0.102: R1227.1 235.06,48.56 235.19,48.68 v1(235.56,48.68) 236.17,48.68 236.27,48.58 237.82,48.58 238.24,49 238.9,49
GPIO2: length 15.4
  TOP w0.076: U1201.D10 240.99,53.03 v4(241.22,52.8)
  BOTTOM w0.102: T1208.1 230.8,55.43 231.7,55.43 231.91,55.22 231.91,54.33 231.61,54.03 231.61,53.48 231.9,53.18 232.46,53.18 232.95,53.67 235.62,53.67 237.03,52.27 238.15,52.27 238.31,52.42 240.85,52.42 v4(241.22,52.8)
GPIO2_GPU_EVENT#: length 14.4
  TOP w0.102: v1(101.2,112.8) 100.39,112.8 R7450.1 99.26,112.54 v2(99.19,112.62)
  BOTTOM w0.102: R7437.1 100.09,114.96 100.09,113.44 100.32,113.22 Q7400.2 99.67,112.18 v2(99.19,112.62)
  BOTTOM w0.103: R7437.1 100.94,115.81 100.94,118.32 100.93,118.33 100.93,118.33 100.83,118.43 100.83,118.43 100.73,118.53 100.73,118.88 99.1,120.51 U7000.AV1
GPIO3: length 17.2
  TOP w0.076: U1201.G11 242.54,53.75 242.54,54.37
  TOP w0.102: v2(241.97,55.55) 242.13,55.55 242.54,55.13 242.54,54.37
  BOTTOM w0.102: T1207.1 228.27,54.96 229,55.69 232.16,55.69 232.4,55.45 234.95,55.45 235.47,55.97 241.55,55.97 241.97,55.55 v2(241.97,55.55)
GPIO3_OC_WARN: length 7.4
  BOTTOM w0.102: U7000.AW4 98.3,124.27 98.73,123.84 98.73,120.11 v1(99.37,119.47) 99.51,119.33 99.98,119.33 100.51,118.8 R7447.1
GPIO5_FRAMELOCK#: length 5.1
  BOTTOM w0.102: T7404.1 101.04,120.46 101.04,123.94 100.7,124.28 U7000.AT4
GPIO6: length 2.3
  TOP w0.076: 242.75,54.37 242.74,54.36 242.74,53.45 U1201.G10
  TOP w0.102: R1229.1 242.75,54.53 242.75,54.37
GPIO7: length 9.9
  TOP w0.076: v4(240.49,51.71) 240.98,51.71 U1201.D7
  TOP w0.102: R1228.1 232.41,51.12 v1(232.65,51.35) 233.31,52.01 238.31,52.01 v2(238.41,51.91)
  IN4 w0.102: v4(240.49,51.71) 240.26,51.71 240.08,51.53 238.79,51.53 v2(238.41,51.91)
GPIO7_BL_PWM: length 1.6
  TOP w0.102: T7405.1 100.1,128.64 v6(100.25,128.79)
  BOTTOM w0.102: v6(100.25,128.79) 100.39,128.79 U7000.AT10
GPIO8_THERM_SHDWN#: length 22
  BOTTOM w0.102: U7000.AV7 99.56,126.24 101.64,126.24 102.15,125.74 102.57,125.74 102.74,125.56 103.13,125.56 103.44,125.24 103.44,121.3 103.81,120.93 v1(103.81,119.75) 103.81,118.51 103.68,118.38 R7444.1 105.19,114.25 105.19,110.29 105.02,110.12 Q7404.2
GPIO10_ALT_MEM_VREF: length 210.2
  TOP w0.381: v6(103.43,119.14) 104.83,119.14 106.27,117.7 106.27,113.09 106.62,112.74 109.49,112.74 110.91,111.32 110.91,109.63 112.83,107.71 112.83,101.46 113.77,100.52 113.77,100.39 114.17,99.99 114.2,99.99 114.5,99.7 114.5,99.69 115.97,98.22 136.4,98.22 136.64,98.46 136.64,101.5 136.14,102 136.14,102.99 136.63,103.48 136.63,114.11 137.24,114.71 Q7900.1 139.12,115.32 v2(139.12,115.77) ; v2(157.33,150.92) 157.33,149.6 v1(157.35,149.57) 157.33,149.55 157.33,144.14 155.15,141.96 148.14,141.96 147.58,141.41 147.58,140.58 147.67,140.49 147.67,132.2 149.93,129.95 150.95,129.95 151.15,130.15 155.38,130.15 156.09,129.45 v2(156.09,127.47) 157.48,126.08 157.48,122.49 v2(156.67,121.68) 155.98,121 154.51,121 153.82,120.31 153.82,118.38 152.64,117.2 145.19,117.2 144.96,116.97 v2(144.96,116.32)
  TOP w0.508: Q7600.1 133.91,176.09 v2(134.16,176.09)
  IN1 w0.381: v2(157.33,150.92) 157.91,151.5 157.91,154.32 157.24,154.99 156.65,154.99 156.19,155.45 156.19,158.05 155.57,158.68 155.57,165.72 v2(155.69,165.85) 158.04,168.2 158.04,180.18 157.4,180.81 156.18,180.81 154.47,182.53 140.61,182.53 v2(134.16,176.09)
  BOTTOM w0.203: v6(103.43,119.14) 103.43,118.3 R7429.2 103.05,118.18 103.05,118.63 102.71,118.97 102.71,125.25 102.47,125.49 101.11,125.49 U7000.AT6
  BOTTOM w0.508: v2(155.69,165.85) 156.2,166.36 Q7700.1 ; v2(156.09,127.47) 155.82,127.74 Q7800.1 ; v2(139.12,115.77) 139.9,115.77 140.46,116.32 v2(144.96,116.32)
GPIO12_AC_BATT#: length 244.2
  IN3 w0.102: v2(180.39,84.02) 181.17,84.79 189.63,84.79 192.28,82.14 204.78,82.14 207.06,84.42 207.06,86.33 207.42,86.68 208.27,86.68 208.75,86.2 210.8,86.2 213.24,88.64 215.64,88.64 215.95,88.76 216.93,89.3 220.98,89.3 v2(222.43,87.85) 223.59,87.85 224.03,87.4 224.03,87.07 223.56,86.59 223.06,86.59 220.72,84.25 220.72,82.93 221.18,82.46 221.18,80.41 218.37,77.59 218.37,77.07 215.63,74.33 215.12,74.33 214.15,73.37 214.15,66.3 214.63,65.82 214.63,64.74 213.54,63.65 213.54,62.53 214.64,61.42 214.64,58.47 216.06,57.05 216.06,50.79 215.84,50.57 215.84,49.17 216.4,48.6 216.4,47.71 v2(217.73,46.38)
  IN4 w0.102: v2(99.19,111.57) 99.19,103.42 109.65,92.96 109.65,89.53 115.14,84.04 115.7,84.04 116.65,83.09 118.78,83.09 122.57,79.3 123.33,79.3 124.12,78.51 125.23,78.51 126.65,77.09 126.65,76.53 127.92,75.26 138.35,75.26 139.47,76.38 145.46,76.38 146.33,75.51 149.3,75.51 150.7,74.11 157.18,74.11 160.29,77.22 175.73,77.22 178.22,79.71 178.75,79.71 180.54,81.51 180.54,83.86 v2(180.39,84.02)
  BOTTOM w0.102: v2(99.19,111.57) 99.6,111.16 Q7405.3 102.67,111.98 102.59,112.05 101.96,112.05 101.48,112.53 v1(101.48,113.62) 101.48,113.85 101.82,114.18 101.82,114.96 R7423.1 101.82,115.8 101.82,118.34 101.54,118.62 101.54,118.93 101.32,119.14 101.18,119.14 100.36,119.96 100.36,122.73 100.04,123.04 99.91,123.04 99.44,123.51 99.44,123.64 99.1,123.99 U7000.AV4 ; R8821.2 222.12,39.59 222.12,41.39 221.84,41.67 220.53,41.67 220.13,42.06 220.13,42.92 220.76,43.54 221.47,43.54 221.69,43.76 221.69,46.72 220.73,47.67 217.98,47.67 217.73,47.42 v2(217.73,46.38)
GPIO23_GPU_PEX_RST_HOLD: length 16.5
  TOP w0.102: D7001.2 96.97,116.34 97.18,116.55 99.08,116.55 99.39,116.86 99.39,119.5 99.75,119.85 100.62,119.85 101.14,119.34 v6(101.14,118.71) 101.75,118.1 v1(101.75,117.54)
  BOTTOM w0.102: R7445.2 101.4,118.26 101.14,118.52 v6(101.14,118.71) 101.14,118.75 99.49,120.4 99.49,123.11 U7000.AV3
GPP_A6_SERIRQ: length 12.4
  TOP w0.114: R2224.2 187.63,57.62 v1(186.94,57.62) 186.56,57.62 186.2,57.26 186.2,57.21 R2203.2 185.52,56.53 184.51,56.53 184.32,56.34 183.84,56.34 183.14,57.04 182.45,57.04 181.46,56.06 180.88,56.06 180.17,55.34 179.91,55.34 179.26,54.7 178.98,54.7 178.62,54.33 v2(178.62,54.33)
  BOTTOM w0.089: v2(178.62,54.33) 178.62,54.33 178.7,54.33 179.12,54.75 179.39,54.75 U2000.BA17
GPP_A14_SUS_STAT#_ESPI_RST#: length 11.1
  BOTTOM w0.089: 184.71,55.6 184.39,55.28 184.01,55.28 183.39,54.67 181.27,54.67 181.2,54.59 180.6,54.59 U2000.BC18
  BOTTOM w0.114: 184.71,55.6 184.88,55.77 187.51,55.77 187.83,56.1 189.02,56.1 189.21,56.29 190.11,56.29 R2226.2
GPP_A18_ISH_GP0: length 18.8
  TOP w0.102: R2239.2 193.18,46.86 v1(193.18,46.15) 192.86,45.83 v2(192.63,45.83)
  IN4 w0.102: v2(179.75,52.02) 181.22,52.02 185.34,47.89 192,47.89 192.63,47.26 v2(192.63,45.83)
  BOTTOM w0.102: v2(179.75,52.02) 180.02,52.28 U2000.BB22
GPP_A19_ISH_GP1: length 10.3
  BOTTOM w0.089: 184.71,54.31 184.31,54.31 182.98,52.98 181.6,52.98 181.55,52.94 181.3,52.94 181.15,53.08 181.02,53.08 U2000.BD21
  BOTTOM w0.102: 184.71,54.31 189.95,54.31 190.15,54.12 R2238.2
GPP_A21_ISH_GP3: length 7.3
  BOTTOM w0.089: 184.71,54.52 184.26,54.52 182.93,53.18 U2000.BE21
  BOTTOM w0.102: R2237.2 187.85,54.52 184.71,54.52
GPP_A22_ISH_GP4: length 5.2
  BOTTOM w0.089: 184.71,55.13 184.69,55.11 184.08,55.11 182.69,53.72 181.88,53.72 181.67,53.93 181.35,53.93 181.18,54.09 181.08,54.09 U2000.BD18
  BOTTOM w0.102: 184.71,55.13 184.94,55.13 R2236.2
GPP_D5: length 16
  TOP w0.102: R2316.2 172.22,34.34 172.22,37.06 172.34,37.18 172.72,37.18 172.83,37.29 172.83,38.46 173.79,39.42 173.79,40.44 173.41,40.82 173.41,44.08 174.56,45.23 174.56,46.33 v2(174.17,46.72) 173.84,47.04 173.84,47.08 v1(173.48,47.44)
  BOTTOM w0.089: U2000.AJ33 174.05,46.83 v2(174.17,46.72)
GPP_D6: length 10.8
  BOTTOM w0.089: U2000.AM43 175.01,41.98 175.01,41.63 175.02,41.62 175.02,41.4 174.68,41.06 174.46,41.06 174.1,40.71 174.1,39.85 174.37,39.58 175,39.58 175.31,39.28 175.31,38.07 175.64,37.73
  BOTTOM w0.102: R2317.2 176.92,34.5 176.92,36.99 176.57,37.35 176.03,37.35 v1(175.67,37.71) 175.64,37.73
GPP_D7: length 8.6
  BOTTOM w0.089: 177.34,37.73 177.45,37.84 177.45,38.09 176.97,38.57 176.53,38.57 175.24,39.86 175.24,40.61 175.58,40.94 175.58,41.38 175.52,41.43 175.52,42.43 U2000.AN42
  BOTTOM w0.102: v1(178.61,36.31) 178.12,36.31 R2318.2 177.33,37.1 177.33,37.16 177.23,37.26 177.23,37.62 177.34,37.73
GPP_D8: length 8
  BOTTOM w0.089: 174.93,37.73 174.93,38.04 174.83,38.14 v1(174.83,39.16) 174.3,39.16 173.93,39.53 173.93,40.59 173.8,40.72 173.8,41.86 174.04,42.11 174.22,42.11 U2000.AL42
  BOTTOM w0.102: R2319.2 176.05,37.15 175.42,37.15 174.93,37.64 174.93,37.73
GPP_H23: length 13.7
  BOTTOM w0.089: U2000.BD36 180.92,45.23 181.3,44.86 181.51,44.86 181.83,44.54 182.61,44.54 182.61,44.54 182.9,44.54 183.44,44 184.71,44
  BOTTOM w0.102: 184.71,44 186.27,44 186.7,43.57 187.11,43.57 187.29,43.74 v1(188.43,43.74) 188.78,43.4 191.69,43.4 191.84,43.55 192.68,43.55 R2463.2
GPP_H_16_SML4CLK: length 14.2
  BOTTOM w0.089: 184.71,43.16 183.21,43.16 182.55,43.82 181.24,43.82 181.04,44.01 U2000.BD39
  BOTTOM w0.102: R2466.2 192.33,41.19 v1(190.55,39.41) 189.51,40.45 188.54,40.45 185.84,43.16 184.71,43.16
GPP_H_17_SML4DATA: length 9.7
  BOTTOM w0.089: 184.71,45.47 184.42,45.47 183.62,46.27 181.52,46.27 U2000.BE34
  BOTTOM w0.102: 184.71,45.47 186.91,45.47 187.12,45.27 189.46,45.27 189.88,44.85 R2469.2
GPP_I5: length 9.2
  TOP w0.102: R2158.2 179.63,66.24 179.16,65.77 179.16,65.08 179,64.92 179,62.49 179.6,61.88 179.6,61.54 179.33,61.26 v1(179.33,60.89) 179.33,60.41 v2(179.5,60.24)
  BOTTOM w0.089: U2000.BA5 179.71,60.44 v2(179.5,60.24)
GPP_I6: length 8.4
  TOP w0.102: R2159.2 179.88,67.58 179.88,66.09 179.36,65.57 179.36,65 179.2,64.84 179.2,62.97 v1(179.56,62.61) 179.81,62.36 179.81,61.31 v2(179.98,61.13)
  BOTTOM w0.089: U2000.BC4 180.35,61.13 v2(179.98,61.13)
GPP_I7: length 9.3
  TOP w0.114: v2(180.3,61.72) 180.47,61.9 180.47,62.39 179.69,63.17 179.69,64.57 180.22,65.11 180.22,65.64 180.38,65.8 v1(180.38,67.13) 181.15,67.9 R2156.2
  BOTTOM w0.102: v2(180.3,61.72) 179.97,61.72 179.85,61.84 179.7,61.84 179.55,61.99 179.55,62.17 179.63,62.25 179.82,62.25 U2000.BB3
GPP_I8: length 9.3
  TOP w0.114: v2(180.97,61.16) 180.97,62.59 180.19,63.37 180.19,64.34 v1(180.75,64.9) 180.87,65.02 180.87,65.58 180.97,65.68 180.97,66.76 181.59,67.39 182.15,67.39 R2101.2
  BOTTOM w0.089: U2000.BD6 v2(180.97,61.16)
GPP_I9: length 7.2
  BOTTOM w0.089: U2000.BE5 181.56,61.05 181.66,61.05 182.4,61.79 182.4,62.48 182.04,62.83 181.76,62.83 181.43,63.16 181.43,64.15 182.32,65.04 182.32,65.83 182.09,66.05 R2160.2
GPP_I10: length 7.1
  BOTTOM w0.089: R2161.2 v1(182.98,65.74) 182.98,64.99 182.35,64.36 182.35,63.23 182.58,63.01 182.58,61.72 181.7,60.84 181.7,60.69 U2000.BE6
GPU MAINPOWER_DISCH_G: length 30.7
  BOTTOM w0.254: v1(157.49,146.54) 157.49,142.73 157.1,142.34 155.53,142.34 154.61,141.42 R5704.2 153.21,140.91 153.21,139.79 152.71,139.29 Q5704.3 ; Q5704.3 152.71,135.63 152.55,135.47 151.93,135.47 151.76,135.3 Q5700.1 ; Q5704.3 Q5705.1 ; Q5702.1 151.11,132.2 151.76,132.85 Q5700.1 ; Q5700.1 152.75,134.28 152.96,134.07 152.96,133.49 153.31,133.14 154.59,133.14 155.31,133.86 Q5701.1 155.31,135.03 156.05,135.77 156.05,136.5 156.2,136.64 Q5703.1
GPU_ALERT#: length 244.1
  TOP w0.102: v2(95.68,111.64) 96.04,112 96.04,113.1 96.37,113.43 96.37,113.9 96.75,114.28 98.46,114.28 98.85,114.68 99.47,114.68 99.62,114.83 Q7403.3
  IN3 w0.102: v2(208.15,82.57) 207.72,82.13 207.72,80.51 211.86,76.37 211.86,58.97 211.36,58.47 211.36,56.16 212.4,55.12 212.4,48.81 213.39,47.82 213.39,45.46 212.5,44.58 212.5,43.22 212.63,43.09 212.63,42.1 209.6,39.08 203.5,39.08 202.59,38.17 200.4,38.17 200.02,37.79 200.02,36.23 198.18,34.38 192.77,34.38 192.49,34.1 181.1,34.1 v2(180.52,34.69)
  IN4 w0.102: v2(208.15,82.57) 207.67,82.57 206.23,81.13 192.54,81.13 188.38,76.96 186.87,76.96 186.21,76.29 183.3,76.29 182.13,77.46 182.13,77.88 180.91,79.1 178.55,79.1 176.06,76.61 174.03,76.61 173.24,75.82 166.71,75.82 164.46,73.57 161.09,73.57 160.77,73.25 155.27,73.25 151.77,69.76 150.39,69.76 149.71,69.07 146.58,69.07 144.26,66.75 142.91,66.75 141.49,68.17 137.24,68.17 135.58,69.83 135.58,70.84 134.74,71.67 130.59,71.67 125.99,76.28 125.99,76.89 125,77.88 123.81,77.88 123.14,78.55 122.46,78.55 118.66,82.35 116.48,82.35 115.51,83.32 114.99,83.32 109.04,89.28 109.04,92.7 96.08,105.66 96.08,108.93 95.28,109.73 95.28,111.24 v2(95.68,111.64)
  BOTTOM w0.089: U2000.AT44 177.04,41.35 177.03,41.33 177.03,40.63 177.34,40.31 177.34,39.85 177.68,39.51 178.55,39.51 179.03,39.03 179.28,39.03 180.05,38.26 180.05,37.73
  BOTTOM w0.102: 180.05,37.73 180.05,37.24 R2371.2 180.1,36.35 180.1,35.11 v2(180.52,34.69) ; v1(95,111.64) v2(95.68,111.64)
GPU_BAT_THRO: length 324.1
  TOP w0.102: v2(24.43,105.91) 25.01,105.91 27.13,103.78 27.13,102.41 27.9,101.64 v1(27.9,95.99) 28.99,94.91 28.99,77.29 28.1,76.41 28.1,72.23 29.23,71.1 29.68,70.65 29.68,65.08 27.91,63.31 27.91,60.38 31.82,56.47 31.82,54.93 32.96,53.79 48.36,53.79 51.32,50.83 60.09,50.83 60.5,50.42 60.5,49.82 v2(62.74,47.59)
  IN2 w0.102: v2(62.74,47.59) 62.74,47.92 62.88,48.06 64.55,48.06 65.23,47.39 71.94,47.39 73.54,45.79 100.62,45.79 102.19,44.21 110.36,44.21 111.31,43.27 113.18,43.27 115.1,45.19 118.46,45.19 118.6,45.04 129.33,45.04 133.45,40.93 135.21,40.93 136.03,40.11 146.8,40.11 147.47,40.78 147.47,42.36 149.05,43.93 151.67,43.93 154.92,47.18 156.47,47.18 156.51,47.14 160.63,47.14 161.23,47.74 165.9,47.74 166.63,48.48 169,48.48 169.61,49.09 173.13,49.09 173.28,48.94 178.71,48.94 178.82,48.83 182.36,48.83 183.43,49.9 183.43,51.01 184.25,51.83 184.51,51.83 185.35,52.66 v2(187.26,52.66)
  IN3 w0.102: v2(62.54,110.08) 61.93,110.69 32.69,110.69 27.92,105.92 24.44,105.92 24.44,105.91 v2(24.43,105.91)
  BOTTOM w0.089: 184.71,53.5 184.56,53.5 183.69,52.63 183.69,51.87 183.45,51.63 181.36,51.63 181.23,51.77 181.21,51.77 181.15,51.8 181.09,51.82 181,51.82 180.91,51.81 180.59,51.81 U2000.BC23
  BOTTOM w0.102: 184.71,53.5 186.77,53.5 187.02,53.25 187.02,52.9 v2(187.26,52.66) R2409.2 ; v2(62.54,110.08) 62.56,110.1 70.54,110.1 71.04,109.6 79.05,109.6 81.61,112.16 91.48,112.16 92.15,111.49 94.05,111.49 94.72,112.16 95.74,112.16 96.31,111.59 96.31,111.16 96.7,110.77 96.7,108.98 97.39,108.28 103.13,108.28 103.62,108.77 Q7405.1
GPU_EVENT#: length 233.6
  TOP w0.102: v2(98.65,110.08) 99.12,110.54 v1(99.44,110.54) 100,111.1 R7450.2
  IN3 w0.102: v2(208.32,83.39) 207.51,82.58 207.51,80.36 211.66,76.22 211.66,59.05 211.15,58.55 211.15,56.07 212.19,55.03 212.19,48.73 213.18,47.74 213.18,46.78 211.61,45.21 211.61,43.6 212.42,42.79 212.42,42.22 209.49,39.28 200.7,39.28 199.73,38.31 199.73,36.23 198.09,34.59 192.68,34.59 192.4,34.3 181.79,34.3 v2(181.41,34.69)
  IN4 w0.102: v2(98.65,110.08) 98.65,109.44 98.27,109.06 98.27,104.04 109.44,92.87 109.44,89.45 115.07,83.82 115.63,83.82 116.61,82.84 118.75,82.84 122.56,79.02 123.31,79.02 124.04,78.3 125.15,78.3 126.43,77.03 126.43,76.44 127.81,75.05 138.44,75.05 139.55,76.17 145.37,76.17 146.26,75.28 149.24,75.28 150.61,73.91 157.26,73.91 160.38,77.02 171.76,77.02 172.54,76.24 173.08,76.24 173.86,77.02 175.82,77.02 178.31,79.51 181.09,79.51 182.6,78 182.6,77.56 183.47,76.7 186.02,76.7 186.88,77.56 188.34,77.56 192.32,81.53 205.9,81.53 207.75,83.39 v2(208.32,83.39)
  BOTTOM w0.089: 178.27,40.3 177.83,40.74 177.83,41.16 177.53,41.46 U2000.AU44
  BOTTOM w0.102: Q7400.3 99.31,110.1 99.29,110.08 v2(98.65,110.08) ; 178.27,40.3 179.18,39.39 179.43,39.39 179.92,38.91 181.45,38.91 181.86,38.49 181.86,37.23 R2358.2 181.83,36.35 181.83,35.11 v2(181.41,34.69)
GPU_ID0: length 16.1
  TOP w0.102: v2(167.09,44.5) 166.52,43.94 166.52,42.96 166.71,42.77 166.71,40.45 165.62,39.36 v1(163.77,39.36) 162.23,39.36 161.34,38.47 R6114.1 160.92,36.34 160.92,34.53 R6113.2
  BOTTOM w0.102: U2000.U39 167.66,43.93 v2(167.09,44.5)
GPU_ID1: length 18
  BOTTOM w0.089: U2000.N42 164.97,41.95 164.93,41.95 164.65,41.67 164.65,41.41 163.67,40.43 162.72,40.43 161.86,39.57 156.82,39.57 v1(156.69,39.44)
  BOTTOM w0.102: R6115.2 153.85,34.49 153.65,34.49 153.26,34.88 153.26,35.21 153.49,35.45 153.51,35.45 153.68,35.62 153.68,36.56 153.9,36.77 R6116.1 154.36,37.35 155.88,38.88 156.13,38.88 v1(156.69,39.44)
GPU_IPC_SCL: length 82.2
  TOP w0.102: U8702.6 118.55,72.22 118.08,71.76 117.73,71.76 117.35,72.13 117.35,73.42 v1(117.09,73.68) 117.09,73.85 118.69,75.45 v2(118.69,75.59)
  IN4 w0.102: v2(84.25,121.55) 84.89,120.92 84.89,113.48 107.18,91.19 107.18,84.65 109.22,82.62 111.56,82.62 112.64,81.54 112.64,78.4 115.86,75.18 118.28,75.18 v2(118.69,75.59)
  BOTTOM w0.102: U7000.BD2 93.96,122.36 93.96,121.77 93.44,121.25 89.26,121.25 88.65,121.87 87.8,121.87 87.33,121.4 86.98,121.4 86.84,121.54 86.12,121.54 R7405.2 84.76,122.06 84.3,121.6 v2(84.25,121.55)
GPU_IPC_SDA: length 81.2
  TOP w0.102: v1(118.79,76.29) 118.75,76.29 v2(118.05,75.59) 118.05,75.33 116.66,73.94 116.66,72.53 117.7,71.49 118.31,71.49 118.39,71.57 U8702.7
  IN4 w0.102: v2(84.89,121.55) 85.09,121.35 85.09,113.57 107.39,91.27 107.39,84.74 109.3,82.82 111.64,82.82 112.86,81.61 112.86,78.54 115.81,75.59 v2(118.05,75.59)
  BOTTOM w0.102: v2(84.89,121.55) 84.89,121.05 85.01,120.92 R7406.2 86.02,121.34 86.75,121.34 86.89,121.2 87.41,121.2 87.83,121.62 88.53,121.62 89.17,120.98 93.71,120.98 94.3,121.57 U7000.BD1
GPU_OVERT#: length 324
  TOP w0.102: v2(178.45,34.7) 177.85,34.1 R2364.2
  IN1 w0.102: v2(116.03,37.73) 116.81,36.95 119.68,36.95 119.75,37.03 127.57,37.03 127.86,36.74 173.32,36.74 174.86,38.28 178.1,38.28 178.77,37.61 178.77,35.86 178.86,35.77 178.86,35.11 v2(178.45,34.7)
  IN3 w0.102: v2(63.42,109.16) 63.42,109.16 63.42,110.64 62.57,111.5 32.1,111.5 27.72,107.12 24.08,107.12 23.73,106.77 23.73,105.58 24.08,105.23 25.04,105.23 25.57,104.71 25.57,96.07 24.96,95.46 24.96,94.12 27.11,91.96 27.11,81.2 27.19,81.13 27.19,80.84 27.74,80.29 27.74,69.23 29.59,67.38 29.59,63.54 29.01,62.95 29.01,61.59 29.18,61.42 29.18,60.27 33.33,56.13 33.33,55.44 35,53.76 35,50.51 37.99,47.52 37.99,43.05 43.12,37.91 81.76,37.91 82.14,37.53 107.7,37.53 108.49,36.74 111.27,36.74 111.96,37.43 115.72,37.43 v2(116.03,37.73)
  BOTTOM w0.089: 178.81,37.73 178.29,38.25 178.04,38.25 177.19,39.1 176.76,39.1 175.83,40.03 175.83,40.44 176.12,40.73 176.12,40.88 U2000.AR45
  BOTTOM w0.102: v2(178.45,34.7) 178.86,35.11 178.86,35.44 179.45,36.03 179.45,36.67 178.86,37.26 178.86,37.68 178.81,37.73 ; v2(63.42,109.16) 79.18,109.16 81.09,111.07 v1(83.79,111.07) 83.94,111.21 91.26,111.21 91.48,110.99 95.85,110.99 96.29,110.55 96.29,108.81 97.23,107.88 105.31,107.88 105.73,108.3 105.73,109.57 106.64,110.48 R7446.1
GPU_PLLVDD: length 89.2
  TOP w0.254: v6(100.25,129.55) 100.74,129.07 100.74,127.22 101.13,126.83 C7213.1 101.13,123.84 101.91,123.06 105.54,123.06 105.98,123.5 105.98,124.42 106.63,125.06 106.63,125.48 107.14,126 110.1,126 110.69,126.6 110.69,128.01 111.02,128.34 111.02,129.25 C7212.1 110.54,130.34 110.73,130.53 v6(110.73,130.52) ; C7214.1 119.61,138.37 v6(119.69,138.44)
  IN4 w0.254: v6(119.69,138.44) 118.62,137.38 118.62,132.05 118.03,131.46 111.67,131.46 v6(110.73,130.52)
  IN4 w0.381: v2(97.88,165.93) 100.13,163.68 100.13,159.98 100.82,159.29 100.82,158.09 100.1,157.36 100.1,153.89 101.82,152.16 103.81,152.16 104.93,151.04 110.31,151.04 v6(110.67,151.4) 111.2,150.87 112.55,150.87 v6(113.08,151.4) 113.72,150.76 116.97,150.76 117.4,150.33 118.34,150.33 118.97,149.7 118.97,139.16 v6(119.69,138.44)
  BOTTOM w0.254: v6(110.67,151.4) 111.1,151.83 U7000.AC39 ; v6(119.69,138.44) 120.23,137.9 U7000.L21 ; v6(113.08,151.4) 113.08,151.68 U7000.Y39 ; U7000.AT11 100.7,130 v6(100.25,129.55) ; U7000.AD11 110.31,130.1 v6(110.73,130.52)
  vias: v1(95.28,165.69)
GPU_THERM_ALERT#: length 12.3
  TOP w0.102: v1(96.98,119.02) 97.23,119.27 v6(97.53,119.27) 97.71,119.27 98.02,119.55 R7414.2 98.48,119.06 97.99,118.58 97.99,117.87 98.22,117.64 Q7403.2
  BOTTOM w0.102: U7000.AW7 97.96,126.36 97.96,122.31 97.77,122.12 97.77,120.92 97.99,120.7 97.99,119.73 v6(97.53,119.27)
GSEN_INT_1: length 4.1
  TOP w0.102: U5800.5 253.17,126.65 v1(254.13,125.69) R5805.2
GSEN_INT_2: length 4.3
  TOP w0.102: R5807.2 v1(254.13,128.48) 252.8,127.15 U5800.6
